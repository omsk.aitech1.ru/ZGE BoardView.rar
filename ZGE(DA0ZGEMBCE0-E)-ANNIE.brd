# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-DLP11SN900HL2L-4P-1
  rect 0.711x0.305 smd: 1(-0.625,0.275) 2(0.625,0.275) 3(0.625,-0.275) 4(-0.625,-0.275)
CLIP-39X35-100X18-3P
  rect 2.54x0.457 smd: 1(-1.975,0) 3(1.975,0)
  rect 0.991x0.889 smd: 2(0,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_2X0_8-0_7H
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
D-1_6X1
  rect 0.635x0.991 smd: 1(-0.55,0) 2(0.55,0)
D-2_8X1_78
  rect 2.21x1.397 smd: 1(-0.95,0)
  rect 0.889x1.397 smd: 2(1.6,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
DCJK-JPD113D-DB570-7H-5P
  round 1.702 hole 1.702 unplated: (-3.5,0) (3.5,0)
  oval 2.007x3.505 hole 0.991x2.489: 1(5.7,-2.45) 2(-5.7,-2.45) 3(5.7,3.35) 4(-5.7,3.35) 8(0,2.2) 9(0,-2)
  oval 2.718x2.007 hole 1.702x0.991: 5(3,5.35) 6(-3,5.35)
  round 1.905 hole 1.499: 7(0,5.35)
DDR4-D4AR0-26001-1P40-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DDR4-D4AR0-26001-1P52-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DDR4-D4AR0-26001-1P92-RVS-260P
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 2.007x3.505 smd: 261(37.75,8) 262(-37.75,12)
DDR4-D4AS0-26001-1P40-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN10-3X3-5-11P-G5318
  rect 0.254x0.711 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 6(1,1.5) 7(0.5,1.5) 8(0,1.5) 9(-0.5,1.5) 10(-1,1.5)
  rect 2.591x1.6 smd: 11(0,0)
DFN10-3X3-5-11P-RT9296
  rect 0.305x0.991 smd: 1(-1,-1.6) 2(-0.5,-1.6) 3(0,-1.6) 4(0.5,-1.6) 5(1,-1.6) 6(1,1.6) 7(0.5,1.6) 8(0,1.6) 9(-0.5,1.6) 10(-1,1.6)
  rect 2.464x1.626 smd: 11(0,0)
DFN12-3X3-45-13P-0_95H
  rect 0.254x0.991 smd: 1(-1.125,-1.6) 2(-0.675,-1.6) 3(-0.225,-1.6) 4(0.225,-1.6) 5(0.675,-1.6) 6(1.125,-1.6) 7(1.125,1.6) 8(0.675,1.6) 9(0.225,1.6) 10(-0.225,1.6) 11(-0.675,1.6) 12(-1.125,1.6)
  rect 2.489x1.6 smd: 13(0,0)
DFN14-3X2-4-15P-0_85H
  rect 0.203x0.711 smd: 1(-1.2,-1) 2(-0.8,-1) 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 6(0.8,-1) 7(1.2,-1) 8(1.2,1) 9(0.8,1) 10(0.4,1) 11(0,1) 12(-0.4,1) 13(-0.8,1) 14(-1.2,1)
  rect 2.591x0.914 smd: 15(0,0)
DFN2018-6-1_8X2-5-7P
  rect 0.356x0.254 smd: 1(0.975,-0.5) 2(0.975,0) 3(0.975,0.5) 4(-0.975,0.5) 5(-0.975,0) 6(-0.975,-0.5)
  rect 1.194x1.6 smd: 7(0,0)
DFN-8L-3X3-65-5P-0_9H
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(-0.51,0)
DP-2DT1517-321211F-20P
  round 0.787 hole 0.559: 1(5.5,8.48) 2(5,6.98) 3(4.5,8.48) 4(4,6.98) 5(3.5,8.48) 6(3,6.98) 7(2.5,8.48) 8(2,6.98) 9(1.5,8.48) 10(1,6.98) 11(0.5,8.48) 12(0,6.98) 13(-0.5,8.48) 14(-1,6.98) 15(-1.5,8.48) 16(-2,6.98) 17(-2.5,8.48) 18(-3,6.98) 19(-3.5,8.48) 20(-4,6.98)
  oval 1.194x2.489 hole 0.61x1.905: 21(8.2,7.58) 22(9.7,0) 23(-8.2,7.58) 24(-9.7,0)
ECAP6_3X5_8-7_2-2P
  rect 3.505x0.991 smd: 1(2.75,0) 2(-2.75,0)
ECAP6_3X7_7-7_8
  rect 3.2x0.991 smd: 1(2.6,0) 2(-2.6,0)
ECAP7X3_5-7_2
  rect 3.505x2.007 smd: 1(2.7,0) 2(-2.7,0)
ESD3-0_985X0_585
  custom 0.062x0.062 smd: 1(0.35,-0.225) 2(0.35,0.225)
  custom 0.1x0.1 smd: 3(-0.35,0)
ESD10-2_5X1-5-9P-AZ1143
  rect 0.254x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.381x1.549 smd: 3(0,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
FILTER-MCM2012B900GBE-4P
  rect 0.762x0.406 smd: 1(-0.925,0.4) 2(0.925,0.4) 3(0.925,-0.4) 4(-0.925,-0.4)
FPC-51695-0450M-V01-45P-L
  rect 0.305x0.61 smd: 1(-11,2.85) 2(-10.5,2.85) 3(-10,2.85) 4(-9.5,2.85) 5(-9,2.85) 6(-8.5,2.85) 7(-8,2.85) 8(-7.5,2.85) 9(-7,2.85) 10(-6.5,2.85) 11(-6,2.85) 12(-5.5,2.85) 13(-5,2.85) 14(-4.5,2.85) 15(-4,2.85) 16(-3.5,2.85) 17(-3,2.85) 18(-2.5,2.85) 19(-2,2.85) 20(-1.5,2.85) 21(-1,2.85) 22(-0.5,2.85) 23(0,2.85) 24(0.5,2.85) 25(1,2.85) 26(1.5,2.85) 27(2,2.85) 28(2.5,2.85) 29(3,2.85) 30(3.5,2.85) 31(4,2.85) 32(4.5,2.85) 33(5,2.85) 34(5.5,2.85) 35(6,2.85) 36(6.5,2.85) 37(7,2.85) 38(7.5,2.85) 39(8,2.85) 40(8.5,2.85) 41(9,2.85) 42(9.5,2.85) 43(10,2.85) 44(10.5,2.85) 45(11,2.85)
  rect 0.406x0.787 smd: 46(-12.5,0) 47(12.5,0)
GS12401-1011-9H-40P-R
  round 0.762 hole 0.762 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.25,0) 42(-12.25,0)
  rect 2.794x1.499 smd: 43(5.7,-2.05) 44(-5.7,-2.05)
H-C102D102N
  round 2.591 hole 2.591 unplated: (0,0)
H-C315D220P2
  round 8.001 hole 5.588: 1(0,0)
H-O114X102D114X102N
  oval 2.896x2.591 hole 2.896x2.591 unplated: (0.002,0.009)
H-TC228BC181D138P2
  round 4.597 hole 3.505: 1(0,0)
H-TC228IBC181D130P2
  round 4.597 hole 3.302: 1(0,0)
H-TC228IBC189D146P2
  round 4.801 hole 3.708: 1(0,0)
H-TIC220BC283D146P2
  round 5.588 hole 3.708: 1(0,0)
H-ZGE-1N
  custom 1x1 hole 4.013 unplated: (0.002,0.009)
HDMI-HDM-020-1S19HG-19P
  oval 0.813x0.991 hole 0.61x0.711: 1(4.5,8.61) 2(4,7.11) 3(3.5,8.61) 4(3,7.11) 5(2.5,8.61) 6(2,7.11) 7(1.5,8.61) 8(1,7.11) 9(0.5,8.61) 10(0,7.11) 11(-0.5,8.61) 12(-1,7.11) 13(-1.5,8.61) 14(-2,7.11) 15(-2.5,8.61) 16(-3,7.11) 17(-3.5,8.61) 18(-4,7.11) 19(-4.5,8.61)
  oval 1.499x2.692 hole 0.889x2.108: 20(9.15,6.3) 22(-9.15,6.3)
  oval 1.499x2.311 hole 0.889x1.727: 21(9.15,0) 23(-9.15,0)
HG-C276D118P2
  round 7.01 hole 2.997: 1(0,0)
  round 0.61 hole 0.356: 2(2.997,0) 3(2.119,2.119) 4(0,2.997) 5(-2.119,2.119) 6(-2.997,0) 7(-2.119,-2.119) 8(0,-2.997) 9(2.119,-2.119)
HG-C315D118P2
  round 8.001 hole 2.997: 1(0,0)
  round 0.61 hole 0.356: 2(2.997,0) 3(2.119,2.119) 4(0,2.997) 5(-2.119,2.119) 6(-2.997,0) 7(-2.119,-2.119) 8(0,-2.997) 9(2.119,-2.119)
HG-TIC315BC394D118P2
  round 8.001 hole 2.997: 1(0,0)
  round 0.61 hole 0.356: 2(2.997,0) 3(2.119,2.119) 4(0,2.997) 5(-2.119,2.119) 6(-2.997,0) 7(-2.119,-2.119) 8(0,-2.997) 9(2.119,-2.119)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L3X3-1_6H
  rect 0.787x2.692 smd: 1(-1.1,0) 2(1.1,0)
L4_5X4_7-2_8H
  rect 2.007x2.489 smd: 1(-2.5,0) 2(2.5,0)
L5_1X5_2-1_6H
  rect 1.905x2.489 smd: 1(-2.047,0) 2(2.047,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L6_6X6_6-6_05-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L10X10-3_8
  rect 4.089x4.089 smd: 1(-4.75,0) 2(4.75,0)
L11_5X7_9-3_8H
  rect 3.505x3.708 smd: 1(-5.25,0) 2(5.25,0)
LED19-113-T1D-CP2Q2HY-3T
  rect 0.787x0.787 smd: 1(-0.75,0) 2(0.75,0)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
NGFF-NASE0-S6701-TSH4-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TS40-75P-KM
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
PAD-ZGE-1
  custom 0.2x0.2 smd: 1(0,0) 4(73.353,-21.946) 6(121.839,-40.66) 8(72.962,-69.329) 9(39.489,-68.946) 12(-44.902,-40.625)
  custom 1.638x1.638 smd: 2(33.528,0.127)
  custom 1.763x1.763 smd: 3(37.12,-21.946) 7(114.099,-68.946)
  custom 1.513x1.513 smd: 5(117.003,-21.946)
  custom 0.576x0.576 smd: 10(-35.926,-68.946)
  custom 1.901x1.901 smd: 11(-44.902,-53.945)
  custom 0.375x0.375 smd: 13(-44.902,-16.693)
  custom 0.325x0.325 smd: 14(-28.402,-13.609)
POWER-3X3-65-6P-0_9H
  rect 0.508x0.406 smd: 1(1.5,-0.975) 2(1.5,-0.325) 3(1.5,0.325) 4(1.5,0.975)
  custom 0.263x0.263 smd: 5(0,0.65) 7(0,-0.65)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5_2X5_55-1_27-7P-1H
  rect 0.508x0.559 smd: 1(-1.905,-2.8) 5(1.905,2.8) 6(0.635,2.8) 7(-0.635,2.8) 8(-1.905,2.8)
  custom 0.463x0.463 smd: 2(0,-2.1)
  rect 4.648x2.54 smd: 9(0,0.55)
POWER-5X6-1_27-7P-0_8H
  rect 0.66x0.635 smd: 1(-1.905,-2.84) 5(1.905,2.84) 6(0.635,2.84) 7(-0.635,2.84) 8(-1.905,2.84)
  custom 0.488x0.488 smd: 2(0,-2.18)
  rect 3.988x2.667 smd: 9(0,0.795)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
QFN10-3X3-5-16P
  rect 0.279x0.838 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  custom 0.413x0.413 smd: 11(0,0)
  round 0.508 hole 0.254: 12(-0.75,0.5) 13(0.75,0.5) 14(-0.75,-0.5) 15(0.75,-0.5) 16(0,0)
QFN16-3X3-5-17P-SLGC55544C
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN16-3X3-5-MP8858
  custom 0.062x0.062 smd: 1(-0.75,-1.4)
  rect 0.254x0.711 smd: 2(-0.25,-1.45) 3(0.25,-1.45) 4(0.75,-1.45) 9(0.75,1.45) 10(0.25,1.45) 11(-0.25,1.45) 12(-0.75,1.45)
  rect 0.711x0.254 smd: 5(1.45,-0.75) 8(1.45,0.75) 13(-1.45,0.75) 16(-1.45,-0.75)
  rect 1.194x0.254 smd: 6(1.2,-0.25) 7(1.2,0.25) 14(-1.2,0.25) 15(-1.2,-0.25)
QFN20-3X3-4-26P
  rect 0.203x0.787 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.787x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN20-3X3-4-26P-0_8H
  custom 0.05x0.05 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN24-4X4-5-25P-CYPD4136
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.743x2.743 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-ISL95812HRZ-SMT
  custom 0.05x0.05 smd: 1(-1.4,-2) 8(1.4,-2) 9(2,-1.4) 16(2,1.4) 17(1.4,2) 24(-1.4,2) 25(-2,1.4) 32(-2,-1.4)
  rect 0.203x0.787 smd: 2(-1,-2) 3(-0.6,-2) 4(-0.2,-2) 5(0.2,-2) 6(0.6,-2) 7(1,-2) 18(1,2) 19(0.6,2) 20(0.2,2) 21(-0.2,2) 22(-0.6,2) 23(-1,2)
  rect 0.787x0.203 smd: 10(2,-1) 11(2,-0.6) 12(2,-0.2) 13(2,0.2) 14(2,0.6) 15(2,1) 26(-2,1) 27(-2,0.6) 28(-2,0.2) 29(-2,-0.2) 30(-2,-0.6) 31(-2,-1)
  rect 2.642x2.642 smd: 33(0,0)
QFN32-4X4-4-33P-MT6605N
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.642x2.642 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN33-5X5-5-19P
  rect 0.305x0.61 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4)
  custom 0.32x0.32 smd: 9(2.4,-1.75)
  custom 0.542x0.542 smd: 12(2.4,0.25)
  rect 3.81x0.61 smd: 16(0,2.4)
  rect 0.61x1.295 smd: 24(-2.4,1.25)
  rect 0.559x0.305 smd: 27(-2.4,0.25) 28(-2.4,-0.25)
  rect 0.61x0.305 smd: 29(-2.4,-0.75) 30(-2.4,-1.25) 31(-2.4,-1.75)
  rect 1.422x1.118 smd: 32(-1.05,-1.185)
  rect 0.559x0.356 smd: 33(-1.66,0.225)
QFN36-4_2X4_2-4-37P
  custom 0.05x0.05 smd: 1(-1.8,-2.1) 2(-1.4,-2.1) 3(-1,-2.1) 4(-0.6,-2.1) 5(-0.2,-2.1) 6(0.2,-2.1) 7(0.6,-2.1) 8(1,-2.1) 9(1.4,-2.1) 10(1.8,-2.1) 11(2.1,-1.4) 12(2.1,-1) 13(2.1,-0.6) 14(2.1,-0.2) 15(2.1,0.2) 16(2.1,0.6) 17(2.1,1) 18(2.1,1.4) 19(1.8,2.1) 20(1.4,2.1) 21(1,2.1) 22(0.6,2.1) 23(0.2,2.1) 24(-0.2,2.1) 25(-0.6,2.1) 26(-1,2.1) 27(-1.4,2.1) 28(-1.8,2.1) 29(-2.1,1.4) 30(-2.1,1) 31(-2.1,0.6) 32(-2.1,0.2) 33(-2.1,-0.2) 34(-2.1,-0.6) 35(-2.1,-1) 36(-2.1,-1.4)
  rect 2.997x2.997 smd: 37(0,0)
QFN39-6X5-45-21P-1H
  rect 0.254x0.61 smd: 1(-2.275,-2.4) 2(-1.825,-2.4) 3(-1.375,-2.4) 4(-0.925,-2.4) 5(-0.475,-2.4) 6(-0.025,-2.4)
  custom 0.55x0.55 smd: 7(1.15,0)
  rect 0.66x4.394 smd: 10(2.875,0)
  rect 2.159x2.362 smd: 25(-1.275,1.525)
  rect 0.61x0.254 smd: 30(-2.9,2.05) 31(-2.9,1.6) 32(-2.9,1.15) 33(-2.9,0.7) 34(-2.9,0.25) 35(-2.9,-0.2) 36(-2.9,-0.65) 37(-2.9,-1.1) 38(-2.9,-1.55) 39(-2.9,-2)
  rect 2.057x1.854 smd: 40(-1.275,-0.875)
  rect 0.406x0.559 smd: 41(0.25,-1.525)
QFN40-5X5-4-41P-92HD99
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.708x3.708 smd: 41(0,0)
QFN40-5X5-4-41P-UP9511
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN40-6X4-4-49P-SMT
  custom 0.05x0.05 smd: 1(-1.4,-3.014) 2(-1,-3.014) 3(-0.6,-3.014) 4(-0.2,-3.014) 5(0.2,-3.014) 6(0.6,-3.014) 7(1,-3.014) 8(1.4,-3.014) 9(2.014,-2.2) 10(2.014,-1.8) 11(2.014,-1.4) 12(2.014,-1) 13(2.014,-0.6) 14(2.014,-0.2) 15(2.014,0.2) 16(2.014,0.6) 17(2.014,1) 18(2.014,1.4) 19(2.014,1.8) 20(2.014,2.2) 21(1.4,3.014) 22(1,3.014) 23(0.6,3.014) 24(0.2,3.014) 25(-0.2,3.014) 26(-0.6,3.014) 27(-1,3.014) 28(-1.4,3.014) 29(-2.014,2.2) 30(-2.014,1.8) 31(-2.014,1.4) 32(-2.014,1) 33(-2.014,0.6) 34(-2.014,0.2) 35(-2.014,-0.2) 36(-2.014,-0.6) 37(-2.014,-1) 38(-2.014,-1.4) 39(-2.014,-1.8) 40(-2.014,-2.2)
  rect 2.692x4.699 smd: 41(0,0)
  round 0.508 hole 0.254: 42(0,-2.1) 43(1.1,-0.75) 44(1.1,0.75) 45(0,2.1) 46(-1.1,0.75) 47(-1.1,-0.75) 48(0,-0.75) 49(0,0.75)
QFN48-6X6-4-49P-0_9H
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 3.81x3.81 smd: 49(0,0)
QFN48-6X6-4-49P-PS8409
  custom 0.05x0.05 smd: 1(-2.2,-2.975) 2(-1.8,-2.975) 3(-1.4,-2.975) 4(-1,-2.975) 5(-0.6,-2.975) 6(-0.2,-2.975) 7(0.2,-2.975) 8(0.6,-2.975) 9(1,-2.975) 10(1.4,-2.975) 11(1.8,-2.975) 12(2.2,-2.975) 13(2.975,-2.2) 14(2.975,-1.8) 15(2.975,-1.4) 16(2.975,-1) 17(2.975,-0.6) 18(2.975,-0.2) 19(2.975,0.2) 20(2.975,0.6) 21(2.975,1) 22(2.975,1.4) 23(2.975,1.8) 24(2.975,2.2) 25(2.2,2.975) 26(1.8,2.975) 27(1.4,2.975) 28(1,2.975) 29(0.6,2.975) 30(0.2,2.975) 31(-0.2,2.975) 32(-0.6,2.975) 33(-1,2.975) 34(-1.4,2.975) 35(-1.8,2.975) 36(-2.2,2.975) 37(-2.975,2.2) 38(-2.975,1.8) 39(-2.975,1.4) 40(-2.975,1) 41(-2.975,0.6) 42(-2.975,0.2) 43(-2.975,-0.2) 44(-2.975,-0.6) 45(-2.975,-1) 46(-2.975,-1.4) 47(-2.975,-1.8) 48(-2.975,-2.2)
  rect 4.496x4.496 smd: 49(0,0)
QFN52-6X6-4-53P-1H-SMT
  custom 0.05x0.05 smd: 1(-2.4,-2.987) 13(2.4,-2.987) 14(2.987,-2.4) 26(2.987,2.4) 27(2.4,2.987) 39(-2.4,2.987) 40(-2.987,2.4) 52(-2.987,-2.4)
  rect 0.203x0.838 smd: 2(-2,-2.987) 3(-1.6,-2.987) 4(-1.2,-2.987) 5(-0.8,-2.987) 6(-0.4,-2.987) 7(0,-2.987) 8(0.4,-2.987) 9(0.8,-2.987) 10(1.2,-2.987) 11(1.6,-2.987) 12(2,-2.987) 28(2,2.987) 29(1.6,2.987) 30(1.2,2.987) 31(0.8,2.987) 32(0.4,2.987) 33(0,2.987) 34(-0.4,2.987) 35(-0.8,2.987) 36(-1.2,2.987) 37(-1.6,2.987) 38(-2,2.987)
  rect 0.838x0.203 smd: 15(2.987,-2) 16(2.987,-1.6) 17(2.987,-1.2) 18(2.987,-0.8) 19(2.987,-0.4) 20(2.987,0) 21(2.987,0.4) 22(2.987,0.8) 23(2.987,1.2) 24(2.987,1.6) 25(2.987,2) 41(-2.987,2) 42(-2.987,1.6) 43(-2.987,1.2) 44(-2.987,0.8) 45(-2.987,0.4) 46(-2.987,0) 47(-2.987,-0.4) 48(-2.987,-0.8) 49(-2.987,-1.2) 50(-2.987,-1.6) 51(-2.987,-2)
  rect 4.75x4.75 smd: 53(0,0)
QFN54-8X4_2-4-55P
  custom 0.05x0.05 smd: 1(-3.6,-2.1) 2(-3.2,-2.1) 3(-2.8,-2.1) 4(-2.4,-2.1) 5(-2,-2.1) 6(-1.6,-2.1) 7(-1.2,-2.1) 8(-0.8,-2.1) 9(-0.4,-2.1) 10(0,-2.1) 11(0.4,-2.1) 12(0.8,-2.1) 13(1.2,-2.1) 14(1.6,-2.1) 15(2,-2.1) 16(2.4,-2.1) 17(2.8,-2.1) 18(3.2,-2.1) 19(3.6,-2.1) 20(4,-1.4) 21(4,-1) 22(4,-0.6) 23(4,-0.2) 24(4,0.2) 25(4,0.6) 26(4,1) 27(4,1.4) 28(3.6,2.1) 29(3.2,2.1) 30(2.8,2.1) 31(2.4,2.1) 32(2,2.1) 33(1.6,2.1) 34(1.2,2.1) 35(0.8,2.1) 36(0.4,2.1) 37(0,2.1) 38(-0.4,2.1) 39(-0.8,2.1) 40(-1.2,2.1) 41(-1.6,2.1) 42(-2,2.1) 43(-2.4,2.1) 44(-2.8,2.1) 45(-3.2,2.1) 46(-3.6,2.1) 47(-4,1.4) 48(-4,1) 49(-4,0.6) 50(-4,0.2) 51(-4,-0.2) 52(-4,-0.6) 53(-4,-1) 54(-4,-1.4)
  rect 6.807x2.997 smd: 55(0,0)
QFN56-7X7-4-57P-ALC2865-CG
  rect 0.203x0.991 smd: 1(-2.6,-3.6) 2(-2.2,-3.6) 3(-1.8,-3.6) 4(-1.4,-3.6) 5(-1,-3.6) 6(-0.6,-3.6) 7(-0.2,-3.6) 8(0.2,-3.6) 9(0.6,-3.6) 10(1,-3.6) 11(1.4,-3.6) 12(1.8,-3.6) 13(2.2,-3.6) 14(2.6,-3.6) 29(2.6,3.6) 30(2.2,3.6) 31(1.8,3.6) 32(1.4,3.6) 33(1,3.6) 34(0.6,3.6) 35(0.2,3.6) 36(-0.2,3.6) 37(-0.6,3.6) 38(-1,3.6) 39(-1.4,3.6) 40(-1.8,3.6) 41(-2.2,3.6) 42(-2.6,3.6)
  rect 0.991x0.203 smd: 15(3.6,-2.6) 16(3.6,-2.2) 17(3.6,-1.8) 18(3.6,-1.4) 19(3.6,-1) 20(3.6,-0.6) 21(3.6,-0.2) 22(3.6,0.2) 23(3.6,0.6) 24(3.6,1) 25(3.6,1.4) 26(3.6,1.8) 27(3.6,2.2) 28(3.6,2.6) 43(-3.6,2.6) 44(-3.6,2.2) 45(-3.6,1.8) 46(-3.6,1.4) 47(-3.6,1) 48(-3.6,0.6) 49(-3.6,0.2) 50(-3.6,-0.2) 51(-3.6,-0.6) 52(-3.6,-1) 53(-3.6,-1.4) 54(-3.6,-1.8) 55(-3.6,-2.2) 56(-3.6,-2.6)
  rect 4.597x4.597 smd: 57(0,0)
QFN56-7X7-4-78P
  rect 0.711x0.787 smd: 1(-2.6,-3.35) 3(-1.8,-3.35) 11(1.4,-3.35) 13(2.2,-3.35)
  rect 0.203x0.711 smd: 5(-1,-3.35) 6(-0.6,-3.35) 7(-0.2,-3.35) 8(0.2,-3.35) 9(0.6,-3.35) 10(1,-3.35) 29(2.6,3.35) 30(2.2,3.35) 31(1.8,3.35) 32(1.4,3.35) 33(1,3.35) 34(0.6,3.35) 35(0.2,3.35) 36(-0.2,3.35) 37(-0.6,3.35) 38(-1,3.35) 39(-1.4,3.35) 40(-1.8,3.35) 41(-2.2,3.35) 42(-2.6,3.35)
  rect 0.711x0.203 smd: 15(3.35,-2.6) 16(3.35,-2.2) 17(3.35,-1.8) 18(3.35,-1.4) 19(3.35,-1) 20(3.35,-0.6) 21(3.35,-0.2) 22(3.35,0.2) 23(3.35,0.6) 24(3.35,1) 25(3.35,1.4) 26(3.35,1.8) 27(3.35,2.2) 28(3.35,2.6) 43(-3.35,2.6) 44(-3.35,2.2) 45(-3.35,1.8) 46(-3.35,1.4) 47(-3.35,1) 48(-3.35,0.6) 49(-3.35,0.2) 50(-3.35,-0.2) 51(-3.35,-0.6) 52(-3.35,-1) 53(-3.35,-1.4) 54(-3.35,-1.8) 55(-3.35,-2.2) 56(-3.35,-2.6)
  rect 2.591x1.753 smd: 57(-1.45,-1.875)
  rect 2.54x1.753 smd: 58(1.475,-1.875)
  rect 5.512x3.404 smd: 59(0,1.05)
  round 0.508 hole 0.254: 60(-2.325,-2.312) 61(-1.45,-2.312) 62(-0.575,-2.312) 63(0.6,-2.312) 64(1.475,-2.312) 65(2.35,-2.312) 66(-2.325,-1.437) 67(-1.45,-1.437) 68(-0.575,-1.437) 69(0.6,-1.437) 70(1.475,-1.437) 71(2.35,-1.437) 72(-1.32,-0.15) 73(0,-0.15) 74(1.32,-0.15) 75(-2.5,1.05) 76(-1.32,1.05) 77(0,1.05) 78(1.32,1.05) 79(2.5,1.05) 80(-1.32,2.25) 81(0,2.25) 82(1.32,2.25)
QFN60-7X7-4-61P-0_9H
  rect 0.203x0.991 smd: 1(-2.8,-3.6) 2(-2.4,-3.6) 3(-2,-3.6) 4(-1.6,-3.6) 5(-1.2,-3.6) 6(-0.8,-3.6) 7(-0.4,-3.6) 8(0,-3.6) 9(0.4,-3.6) 10(0.8,-3.6) 11(1.2,-3.6) 12(1.6,-3.6) 13(2,-3.6) 14(2.4,-3.6) 15(2.8,-3.6) 31(2.8,3.6) 32(2.4,3.6) 33(2,3.6) 34(1.6,3.6) 35(1.2,3.6) 36(0.8,3.6) 37(0.4,3.6) 38(0,3.6) 39(-0.4,3.6) 40(-0.8,3.6) 41(-1.2,3.6) 42(-1.6,3.6) 43(-2,3.6) 44(-2.4,3.6) 45(-2.8,3.6)
  rect 0.991x0.203 smd: 16(3.6,-2.8) 17(3.6,-2.4) 18(3.6,-2) 19(3.6,-1.6) 20(3.6,-1.2) 21(3.6,-0.8) 22(3.6,-0.4) 23(3.6,0) 24(3.6,0.4) 25(3.6,0.8) 26(3.6,1.2) 27(3.6,1.6) 28(3.6,2) 29(3.6,2.4) 30(3.6,2.8) 46(-3.6,2.8) 47(-3.6,2.4) 48(-3.6,2) 49(-3.6,1.6) 50(-3.6,1.2) 51(-3.6,0.8) 52(-3.6,0.4) 53(-3.6,0) 54(-3.6,-0.4) 55(-3.6,-0.8) 56(-3.6,-1.2) 57(-3.6,-1.6) 58(-3.6,-2) 59(-3.6,-2.4) 60(-3.6,-2.8)
  rect 3.988x3.988 smd: 61(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
RC2037
  rect 1.397x4.191 smd: 1(-1.3,0) 2(1.3,0)
RC2512
  rect 3.099x3.988 smd: 1(-2.2,0) 2(2.2,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-5P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,-0.65)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SOIC8-6-1_27-AT25M02
  rect 0.61x1.6 smd: 1(-1.905,-2.7) 2(-0.635,-2.7) 3(0.635,-2.7) 4(1.905,-2.7) 5(1.905,2.7) 6(0.635,2.7) 7(-0.635,2.7) 8(-1.905,2.7)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON8-3X3-65-7P
  rect 0.305x0.508 smd: 1(-0.975,-1.35) 2(-0.325,-1.35) 3(0.325,-1.35) 4(0.975,-1.35) 5(0.975,1.35)
  rect 1.6x0.508 smd: 8(-0.325,1.35)
  rect 2.388x1.6 smd: 9(0,0)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-2_85-95-5P
  rect 0.787x0.559 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-6-2_8-95-6P-G5126TB1U
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P-1_1H
  rect 1.194x0.305 smd: 1(1.05,-0.65) 2(1.05,0) 3(1.05,0.65) 4(-1.05,0.65) 5(-1.05,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT363-2_1-65-6P-PJ4N3KDW
  rect 0.508x0.457 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SOT563-1_6-5-6P-PJX138K
  rect 0.457x0.305 smd: 1(0.675,-0.5) 2(0.675,0) 3(0.675,0.5) 4(-0.675,0.5) 5(-0.675,0) 6(-0.675,-0.5)
SPAD-C315
  round 8.001 smd: 1(0,0)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-533B-Q-TR-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TP2075
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TQFN20-4X4-5-25P
  rect 0.305x0.94 smd: 1(-1,-1.925) 2(-0.5,-1.925) 3(0,-1.925) 4(0.5,-1.925) 5(1,-1.925) 11(1,1.925) 12(0.5,1.925) 13(0,1.925) 14(-0.5,1.925) 15(-1,1.925)
  rect 0.94x0.305 smd: 6(1.925,-1) 7(1.925,-0.5) 8(1.925,0) 9(1.925,0.5) 10(1.925,1) 16(-1.925,1) 17(-1.925,0.5) 18(-1.925,0) 19(-1.925,-0.5) 20(-1.925,-1)
  rect 2.108x2.108 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5)
TSOT23-6-2_8-95-6P-1H
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
UB3-2UB4006-157101F-9P
  round 1.397 hole 0.813: 1(-3.5,5.9) 2(-1,5.9) 3(1,5.9) 4(3.5,5.9) 5(4,7.4) 6(2,7.4) 7(0,7.4) 8(-2,7.4) 9(-4,7.4)
  oval 1.397x2.692 hole 0.787x2.108: 10(-8,0) 11(8,0) 12(8,6.4) 13(-8,6.4)
UB31-MJ8E0B-T880-422-24P
  round 0.813 hole 0.813 unplated: (-3.95,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.95,0)
  round 0.61 hole 0.457: 1(-0.9,-0.525) 2(0.9,-0.525) B1(3.6,-1.35) B2(3.2,-2.09) B3(2.4,-2.09) B4(1.6,-2.09) B5(0.8,-2.09) B6(0.4,-1.35) B7(-0.4,-1.35) B8(-0.8,-2.09) B9(-1.6,-2.09) B10(-2.4,-2.09) B11(-3.2,-2.09) B12(-3.6,-1.35)
  oval 0.889x1.6 hole 0.61x1.295: 3(-4.55,-2.8) 4(4.55,-2.8) 5(-4.55,-6.7) 6(4.55,-6.7)
  rect 0.254x0.711 smd: A1(-2.75,0.35) A2(-2.25,0.35) A3(-1.75,0.35) A4(-1.25,0.35) A5(-0.75,0.35) A6(-0.25,0.35) A7(0.25,0.35) A8(0.75,0.35) A9(1.25,0.35) A10(1.75,0.35) A11(2.25,0.35) A12(2.75,0.35)
UB31-UCF3T-40N30-0P00-24P-TBT
  round 0.61 hole 0.61 unplated: (-3.6,0)
  oval 0.838x0.508 hole 0.838x0.508 unplated: (3.6,0.065)
  custom 0.413x0.413 hole 0.61x1.905: 1(-4.32,2) 2(4.32,2)
  oval 1.245x0.711 hole 1.245x0.711: 3(-3.995,1.4) 4(3.995,1.4)
  oval 1.295x2.591 hole 0.711x2.007: 5(-4.32,-3.05) 6(4.32,-3.05)
  rect 0.279x0.889 smd: A1(-2.625,2.7) A2(-2.125,2.7) A3(-1.625,2.7) A4(-1.125,2.7) A5(-0.625,2.7) A6(-0.125,2.7) A7(0.375,2.7) A8(0.875,2.7) A9(1.375,2.7) A10(1.875,2.7) A11(2.375,2.7) A12(2.875,2.7)
  rect 0.279x0.787 smd: B1(2.625,1.1) B2(2.125,1.1) B3(1.625,1.1) B4(1.125,1.1) B5(0.625,1.1) B6(0.125,1.1) B7(-0.375,1.1) B8(-0.875,1.1) B9(-1.375,1.1) B10(-1.875,1.1) B11(-2.375,1.1) B12(-2.875,1.1)
unnamed#2
  round 1.016 smd: 1(0,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
WTB-50281-00401-001-4P-L
  rect 0.787x2.007 smd: 1(-1.875,4.05) 2(-0.625,4.05) 3(0.625,4.05) 4(1.875,4.05)
  rect 2.007x2.489 smd: 5(-4.075,0) 6(4.075,0)
WTB-50458-01001-V02-10P-L
  rect 0.559x1.295 smd: 1(-9,5.025) 2(-7,5.025) 3(-5,5.025) 4(-3,5.025) 5(-1,5.025) 6(1,5.025) 7(3,5.025) 8(5,5.025) 9(7,5.025) 10(9,5.025)
  rect 1.295x2.057 smd: 11(-12.1,0) 12(12.1,0)
