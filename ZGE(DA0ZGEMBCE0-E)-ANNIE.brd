# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
3V3_SYS on IN1 (solid shape): 231.91,12.86 237.37,12.86 237.49,12.97 243.58,12.97 244,12.55 244,12.54 244.21,12.32 244.21,11.62 243.99,11.4 243.99,11.21 243.56,10.79 235.01,10.79 234.94,10.71 234.92,10.71 234.44,11.19 228.75,11.19 228.5,10.94 228.49,10.94 228.32,10.81 228.26,10.61 228.28,10.51 228.31,10.42 228.31,10.13 228.28,10.06 228.27,9.99 228.26,9.97 227.93,9.64 226.56,9.64 226.38,9.82 226.38,11.35 227.47,12.44 228.49,12.44 228.5,12.43 229.98,12.43 230.52,12.96 231.01,12.96 231.03,12.97 231.8,12.97
3V3_SYS on IN3 (solid shape): outline of 764 points within 246.6,9.14 267.07,15.08
3V3_SYS on IN4 (solid shape): outline of 845 points within 260.29,13.96 278.56,30.65
5V_VCONN on TOP (solid shape): 250.62,15.41 250.62,14.98 250.51,14.87 250.36,14.88 250.31,14.88 250.26,14.88 250.16,14.87 250.01,14.81 249.93,14.68 249.92,14.67 249.75,14.49 249.45,14.49 249.2,14.74 249.2,14.77 248.86,14.77 248.83,14.79 248.81,14.83 248.81,14.98 248.83,15.01 248.86,15.03 249.2,15.03 249.2,15.27 248.86,15.27 248.83,15.29 248.81,15.33 248.81,15.54 248.96,15.69 250.34,15.69
5V_VCONN on BOTTOM (solid shape): 248.58,20.21 248.58,19.55 248.43,19.4 247.74,19.4 247.73,19.38 247.72,19.38 247.64,19.33 247.62,19.24 247.62,18.53 247.66,18.43 247.76,18.39 248.31,18.39 248.39,18.4 248.4,18.38 248.79,18 248.79,17.42 249.01,17.19 250.59,17.19 250.74,17.34 251.43,17.34 251.53,17.24 251.53,16.78 251.28,16.53 251.27,16.53 251.07,16.42 250.97,16.23 250.96,16.21 250.87,16.12 250.87,15.1 250.21,14.44 249.35,14.44 249.22,14.57 249.22,15.55 249.46,15.79 249.51,15.81 249.55,15.84 249.61,15.87 249.68,15.84 249.81,15.76 249.95,15.73 250.35,16.12 249.95,16.51 249.82,16.49 249.7,16.42 249.64,16.4 249.57,16.43 249.44,16.51 249.29,16.54 249.16,16.52 249.05,16.45 249.04,16.45 248.98,16.43 248.91,16.45 248.79,16.53 248.65,16.55 248.51,16.53 248.39,16.45 248.31,16.43 248.25,16.46 248.23,16.48 247.88,16.48 247.85,16.49 247.81,16.51 247.57,16.76 247.57,17.24 247.45,17.35 246.65,18.15 246.65,19.4 247.76,20.51 248.29,20.51
51211V_DRVH on TOP (solid shape): 164.03,21.76 164.07,21.74 164.08,21.71 164.08,20.83 164.11,20.83 164.14,20.8 164.14,20.79 164.18,20.73 164.23,20.7 164.24,20.69 164.41,20.52 164.57,20.52 164.58,20.54 164.69,20.54 164.86,20.37 164.86,19.97 164.79,19.9 164.23,19.9 164.15,19.98 164.15,20.35 163.79,20.72 163.79,21.73 163.81,21.76
51211V_DRVL on TOP (solid shape): 166.3,11.5 166.3,10.97 166.05,10.71 165.01,10.71 164.9,10.82 164.9,11.63 164.98,11.71 166.1,11.71
51211V_DRVL on TOP (solid shape): 162.58,21.65 162.58,20.83 162.59,20.83 162.59,20.28 162.35,20.04 162.03,20.04 161.9,20.17 161.9,21.53 162.15,21.78 162.45,21.78
51211V_SW on TOP (solid shape): 163.58,21.71 163.58,20.83 163.59,20.83 163.59,20.6 163.83,20.36 163.83,20.03 163.77,19.97 163.28,19.97 163.25,19.99 163.24,20.06 163.23,20.12 163.23,20.8 163.26,20.83 163.28,20.83 163.28,21.75 163.31,21.78 163.51,21.78
51211V_SW on TOP (solid shape): 171.79,13.96 171.79,9.91 171.19,9.3 168.26,9.3 168.12,9.16 167.28,9.16 167.14,9.3 166.5,9.3 166.26,9.54 166.26,10.19 166.85,10.78 166.85,11.74 166.5,12.09 161.06,12.09 160.99,12.16 160.88,12.16 160.84,12.17 160.83,12.21 160.83,14.6 160.93,14.7 171.05,14.7
+1.2V on TOP (solid shape): 53.23,160.21 53.23,159.33 52.95,159.05 51.78,159.05 51.57,159.26 51.56,159.29 51.56,159.32 51.6,159.41 51.61,159.5 51.58,159.65 51.48,159.8 51.48,159.82 51.48,160.21 51.63,160.37 53.08,160.37
+1.2V on TOP (solid shape): 52.33,167.64 52.33,167.61 52.32,167.59 52.27,167.47 52.25,167.35 52.25,167.01 52.94,166.32 52.99,166.32 53,166.31 53.99,166.31 54,166.32 54.25,166.56 55.62,166.56 56.51,165.68 56.51,164.79 56.53,164.76 56.53,162.88 56.14,162.49 56.13,162.48 56,162.4 55.91,162.27 55.91,162.26 55.82,162.17 55.24,162.17 55.11,162.3 55.11,164.74 55.14,164.76 55.14,165.24 54.63,165.75 51.28,165.75 51.2,165.83 51.2,166.54 51.63,166.97 51.63,167.45 51.86,167.68 52.29,167.68
+1.2V on TOP (solid shape): 49.22,164.3 49.22,160.67 49.02,160.47 48.79,160.47 48.76,160.48 48.76,160.5 48.64,160.63 48.48,160.7 48.29,160.89 48.3,160.92 48.3,160.95 48.3,161.25 48.26,161.38 48.15,161.47 48.15,161.59 48.2,161.7 48.22,161.81 48.11,162.08 47.86,162.21 47.67,162.39 47.67,164.58 47.92,164.84 48.69,164.84
+1.2V on BOTTOM (solid shape): 93.74,73.93 93.74,72.05 93.49,71.8 91.84,71.8 91.71,71.92 91.71,73.83 92.14,74.26 92.14,74.74 92.3,74.9 92.78,74.9
+1.2V on IN1 (solid shape): outline of 458 points within 91.38,61 98.09,74.34
+1.2V on IN1 (solid shape): outline of 820 points within 51.66,157.17 97.38,163.34
+1.2V on IN3 (solid shape): outline of 782 points within 47.54,159.2 61.66,167.34
+1.2V on IN3 (solid shape): outline of 950 points within 96.03,61.13 115.06,163.93
+1.2V_U3 on TOP (solid shape): 274.54,10.38 274.54,10.15 274.16,9.77 274.16,9.14 274.06,9.03 273.03,9.03 272.95,9.11 272.95,9.66 273.73,10.43 274.49,10.43
+1.2V_U3 on TOP (solid shape): 279.53,12.41 279.77,12.41 280.08,12.11 280.33,12.11 280.35,12.1 280.37,12.09 280.4,12.06 280.49,11.98 280.49,11.57 280.42,11.5 278.03,11.5 277.97,11.57 277.97,11.6 277.99,11.63 278.02,11.65 278.72,11.65 278.72,11.85 278.02,11.85 277.99,11.86 277.97,11.9 277.97,12.03 277.99,12.05 278.72,12.05 278.73,12.06 278.73,12.26 278.02,12.26 277.97,12.31 277.97,12.4 278.02,12.45 278.72,12.45 278.72,12.47 278.75,12.5 278.83,12.5 278.84,12.51 278.86,12.51 278.86,12.53 278.98,12.65 279.29,12.65
+1.2V_U3 on BOTTOM (solid shape): outline of 295 points within 271.16,9.03 280.14,15.71
+1.2VSUS on TOP (solid shape): 11.18,47.63 12.3,47.63 12.52,47.41 12.52,46.75 12.41,46.65 10.79,46.65 10.61,46.83 10.61,47.51 10.84,47.74 11.07,47.74
+1.2VSUS on TOP (solid shape): 128.26,35.7 128.26,34.81 128.09,34.64 127.48,34.64 127.32,34.48 127.32,33.95 126.99,33.62 115.51,33.62 115.16,33.98 115.16,35.7 115.44,35.98 127.98,35.98
+1.2VSUS on TOP (solid shape): 137.92,34.44 137.92,33.75 137.66,33.49 131.08,33.49 130.83,33.75 130.83,34.69 131.01,34.87 131.01,34.92 131.03,34.95 131.03,35.96 131.11,36.03 136.32,36.03
+1.2VSUS on TOP (solid shape): 139.75,35.67 139.75,34.77 140.1,34.42 140.1,34.05 139.97,33.93 138.5,33.93 138.38,34.05 138.38,34.57 137.59,35.37 137.59,35.81 137.79,36.01 139.41,36.01
+1.2VSUS on TOP (solid shape): 111.02,100.52 111.06,100.5 111.11,100.49 111.82,100.49 112.02,100.29 112.02,98.57 111.41,97.96 106.01,97.96 105.63,98.34 105.63,100.4 105.76,100.52
+1.2VSUS on TOP (solid shape): 149.12,30.72 149.12,24.73 149.09,24.69 149.08,24.68 149.04,24.64 149.02,24.59 149.02,24.21 149.04,24.15 149.09,24.12 149.12,24.1 149.12,23.3 148.59,22.77 147.45,22.77 145.94,21.27 145.94,18.52 146.2,18.26 146.2,15.49 145.86,15.15 142.73,15.15 142.3,15.58 142.3,23.09 143.33,24.12 143.33,24.58 143.11,24.8 143.11,24.86 142.99,25.14 142.72,25.25 142.66,25.25 142.56,25.34 142.56,26.03 141.95,26.64 141.95,28.77 142.53,29.35 146.34,29.35 146.93,29.94 146.93,30.62 147.03,30.73 147.64,30.73 147.8,30.88 148.96,30.88
+1.2VSUS on TOP (solid shape): 144.93,35.73 144.93,35.19 144.91,35.18 144.91,34.75 144.8,34.64 144.52,34.64 144.21,34.33 144.21,33.72 144.09,33.6 141.52,33.6 141.34,33.77 141.34,34.38 141.09,34.64 140.71,34.64 140.55,34.79 140.55,34.9 143.57,34.9 143.57,34.85 143.57,34.79 143.59,34.74 143.61,34.69 143.64,34.64 143.68,34.6 143.72,34.56 143.77,34.53 143.82,34.51 143.88,34.49 143.93,34.48 143.99,34.48 144.04,34.49 144.1,34.51 144.15,34.53 144.2,34.56 144.24,34.6 144.28,34.64 144.31,34.69 144.33,34.74 144.35,34.79 144.35,34.85 144.35,34.9 144.35,34.96 144.33,35.01 144.31,35.06 144.28,35.11 144.24,35.15 144.2,35.19 144.15,35.22 144.1,35.25 144.04,35.26 143.99,35.27 143.93,35.27 143.88,35.26 143.82,35.25 143.77,35.22 143.72,35.19 143.68,35.15 143.64,35.11 143.61,35.06 143.59,35.01 143.57,34.96 143.57,34.9 140.55,34.9 140.55,35.88 140.71,36.03 144.62,36.03
+1.2VSUS on TOP (solid shape): 176.68,44.11 176.68,43.48 177.82,42.33 178.16,42.33 178.18,42.33 178.47,42.07 178.82,41.99 178.9,41.99 178.97,42 179.01,42 179.03,41.99 179.66,41.99 179.72,41.93 179.72,41.57 179.6,41.44 178.45,41.44 178.33,41.57 178.07,41.57 177.69,41.19 177.69,40.81 178.33,40.17 178.33,37.25 175.36,34.29 166.69,34.29 166.08,33.68 148.53,33.68 148.02,33.17 147.33,33.17 147.24,33.27 147.24,35.79 147.51,36.06 170.44,36.06 170.61,35.88 170.61,35.86 170.81,35.86 170.87,35.8 171.77,35.8 171.83,35.86 172.61,35.86 172.98,36.23 173.02,36.25 173.05,36.29 173.88,37.13 173.88,39.16 175.41,40.68 175.41,41.95 174.77,42.59 174.26,42.59 173.88,42.97 173.88,43.86 174.64,44.62 176.17,44.62
+1.2VSUS on TOP (solid shape): outline of 130 points within 97.96,89.94 110.82,93.73
+1.2VSUS on TOP (solid shape): outline of 170 points within 139.32,53.67 166.06,62.93
+1.2VSUS on TOP (solid shape): outline of 300 points within 108.5,57.53 137.64,64.68
+1.2VSUS on BOTTOM (solid shape): 178.25,48.89 178.25,48.43 177.82,48 177.82,47.29 177.56,47.03 177.18,47.03 175.71,45.56 175.71,43.09 175.43,42.82 174.21,42.82 174.01,43.02 174.01,44.72 174.28,44.99 174.28,45.76 175.53,47.02 175.53,48.05 176.5,49.01 178.12,49.01
+1.2VSUS on BOTTOM (solid shape): 12.96,48.76 13.16,48.61 13.41,48.62 13.47,48.62 13.79,48.3 13.79,47.69 13.68,47.59 12.11,47.59 12,47.48 12,47.19 11.66,46.85 10.59,46.85 10.39,47.04 10.39,49.09 10.76,49.46 12.26,49.46
+1.2VSUS on BOTTOM (solid shape): 270.01,10.42 270.77,10.42 271.01,10.18 271.01,9.59 271.02,9.58 271.02,9.56 271.32,9.27 271.32,9.08 271.3,9.05 271.27,9.03 269.87,9.03 269.69,9.21 269.69,9.55 269.7,9.57 269.71,9.59 269.86,9.9 269.71,10.2 269.7,10.22 269.69,10.24 269.69,10.33 269.79,10.43 270,10.43
+1.2VSUS on BOTTOM (solid shape): 63.3,21.34 63.3,21.32 63.32,21.23 63.37,21.14 63.37,20.62 63.35,20.58 63.08,20.44 62.98,20.18 63.02,20 63.14,19.86 63.18,19.79 63.15,19.71 62.96,19.52 61.77,19.52 61.72,19.57 61.72,21.2 62.07,21.56 63.09,21.56
+1.2VSUS on BOTTOM (solid shape): outline of 115 points within 138.5,57.57 147.58,63.03
+1.2VSUS on BOTTOM (solid shape): outline of 246 points within 93.14,61.3 113.4,73.76
+1.2VSUS on BOTTOM (solid shape): outline of 273 points within 114.88,57.66 134.25,63.41
+1.2VSUS on BOTTOM (solid shape): outline of 846 points within 127.79,44.57 145.68,52.63
+1.2VSUS on BOTTOM (solid shape): outline of 1236 points within 127.5,25.52 166.33,35.91
+1.2VSUS on BOTTOM (solid shape): outline of 11512 points within 107.89,81.91 166.47,113.3
+1.2VSUS on IN1 (solid shape): outline of 163 points within 89.25,13.28 95.8,18.25
+1.2VSUS on IN1 (solid shape): outline of 172 points within 61.48,19.42 66.49,22.19
+1.2VSUS on IN1 (solid shape): outline of 600 points within 128.42,20.44 177.39,28.19
+1.2VSUS on IN2 (solid shape): 271.9,9.97 271.9,8.88 271.42,8.4 269.54,8.4 269.41,8.53 269.41,9.31 270.25,10.15 271.72,10.15
+1.2VSUS on IN2 (solid shape): 178.61,21 178.61,20.39 178.45,20.23 176.7,20.23 176.68,20.26 176.67,20.28 176.56,20.5 176.34,20.59 176.32,20.59 176,20.91 176,21.77 176.35,22.11 177.49,22.11
+1.2VSUS on IN2 (solid shape): outline of 91 points within 202.28,8.45 207.26,10.51
+1.2VSUS on IN2 (solid shape): outline of 121 points within 245.54,8.42 252.04,10.43
+1.2VSUS on SVCC (solid shape): outline of 878 points within 8.43,18.97 92.81,51.1
+1.2VSUS on SVCC1 (solid shape): outline of 1026 points within 88.28,34.61 147.08,112.31
+1.2VSUS on IN4 (solid shape): outline of 16821 points within 103.07,38.73 175.91,64.57
+1.8V_AON on TOP (solid shape): 102.63,107.89 102.63,107.15 102.2,106.72 100.17,106.72 99.99,106.9 99.99,107.71 100.3,108.02 102.51,108.02
+1.8V_AON on TOP (solid shape): 24.3,84.98 24.3,83.89 23.64,83.23 23.21,83.23 23.06,83.38 23.06,84.62 23.22,84.78 23.56,84.78 23.89,85.11 24.17,85.11
+1.8V_AON on TOP (solid shape): 29.85,92.93 29.85,91.28 29.43,90.86 28.34,90.86 27.51,91.69 27.51,91.89 28.01,92.38 28.8,92.38 29.42,93.01 29.77,93.01
+1.8V_AON on TOP (solid shape): 33.86,79.2 33.86,78.32 34.22,77.95 34.22,77.66 34.06,77.49 33.38,77.49 33.18,77.69 33.18,79.31 33.28,79.41 33.66,79.41
+1.8V_AON on TOP (solid shape): 41.89,81.53 41.89,81.13 42.09,80.94 42.09,79.81 41.17,78.9 39.35,78.9 39.15,79.09 39.15,80.68 39.39,80.92 40.97,80.92 41.19,81.14 41.19,81.55 41.28,81.64 41.79,81.64
+1.8V_AON on TOP (solid shape): 101.87,124.04 101.87,122.72 101.97,122.62 102.25,122.62 102.43,122.44 102.43,121.53 102.05,121.15 102.03,121.15 101.96,121.11 101.92,121.03 101.92,121.02 101.9,121 101.9,119.88 101.8,119.78 101.29,119.78 100.78,120.29 100.78,123.84 101.09,124.15 101.77,124.15
+1.8V_AON on TOP (solid shape): 43.15,102.63 44.07,102.63 44.11,102.62 44.13,102.58 44.13,101.44 44.78,100.79 46,100.79 46.42,100.37 46.42,99.59 46.13,99.31 46.12,99.3 46.1,99.3 45.96,99.3 45.94,99.3 45.93,99.31 45.52,99.72 43.83,99.72 43.09,100.46 43.09,100.97 43.09,100.99 43.1,101 43.53,101.43 43.53,101.66 43.35,101.85 43.12,101.85 42.97,101.69 42.82,101.69 42.72,101.79 42.28,101.79 42.18,101.9 42.18,102.35 42.44,102.61 42.64,102.61 42.82,102.78 43,102.78
+1.8V_AON on TOP (solid shape): outline of 103 points within 17.87,90.1 21.48,93.37
+1.8V_AON on TOP (solid shape): 13.57,92.62 13.67,92.58 13.84,92.56 13.89,92.58 14.2,92.58 14.38,92.4 14.38,88.33 14.39,88.32 14.39,88.24 14.47,88.24 14.48,88.23 14.52,88.23 14.61,88.18 14.61,88.08 14.58,87.99 14.57,87.9 14.96,87.51 15.35,87.9 15.34,87.99 15.31,88.08 15.31,88.18 15.4,88.23 20.43,88.23 20.51,88.19 20.52,88.1 20.55,87.8 20.79,87.61 20.81,87.59 20.82,87.56 20.82,86.78 20.44,86.4 19.81,86.4 19.14,85.74 16.91,85.74 16.18,85.01 16.18,85.01 16.11,84.95 15.77,84.66 15.46,84.32 15.45,84.31 15.43,84.3 15.04,84.3 15,84.32 14.99,84.35 14.99,85.02 14.55,85.46 14.42,85.55 14.27,85.58 13.99,85.46 13.87,85.18 13.9,85.03 13.99,84.9 14.2,84.69 14.2,84.35 14.19,84.32 14.15,84.3 13.56,84.3 13.36,84.3 12.69,84.97 12.69,86.14 11.34,87.49 9.37,87.49 9.36,87.49 8.93,87.49 8.47,87.95 8.47,90.67 8.82,91.02 9.11,90.99 9.4,90.98 11.02,91.25 12.46,92.02 12.79,92.3 13.1,92.61 13.11,92.62 13.13,92.62
+1.8V_AON on BOTTOM (solid shape): 10.89,128.95 10.89,126.89 10.79,126.79 10.51,126.79 10.43,126.86 9.85,126.86 9.8,126.91 9.8,127.17 9.92,127.3 9.92,128.95 10.05,129.07 10.76,129.07
+1.8V_AON on BOTTOM (solid shape): 10.2,115.71 10.2,115.31 10.94,114.57 10.94,113.35 10.64,113.05 10.64,112.28 10.31,111.95 9.72,111.95 9.62,112.06 9.62,112.26 9.63,112.28 9.64,112.3 9.72,112.37 9.77,112.46 9.78,112.47 9.85,112.54 9.85,114.67 9.72,114.8 9.72,115.71 9.8,115.79 10.13,115.79
+1.8V_AON on BOTTOM (solid shape): 22.12,106.69 22.12,104.33 22.28,104.18 24.02,104.18 24.21,104 24.21,102.59 23.92,102.3 22.79,102.3 22.51,102.58 21.13,102.58 20.9,102.81 20.9,103.45 20.75,103.6 20.66,103.6 20.62,103.61 20.6,103.61 19.91,103.61 19.84,103.59 19.79,103.53 19.78,103.52 19.22,102.96 18.86,102.96 18.68,103.14 18.68,103.4 18.74,103.47 18.95,103.47 19.04,103.51 19.09,103.61 19.09,103.91 19.26,104.08 19.27,104.09 19.47,104.23 19.54,104.46 19.54,104.51 19.53,104.57 19.53,104.59 19.6,104.66 20.17,104.66 20.17,105.01 19.68,105.01 19.64,105.02 19.63,105.06 19.63,105.26 19.64,105.3 19.68,105.31 20.17,105.31 20.17,105.38 20.19,105.41 20.22,105.43 20.25,105.43 20.35,105.53 20.35,106.66 20.44,106.75 22.07,106.75
+1.8V_AON on BOTTOM (solid shape): 13.57,92.62 13.67,92.58 13.89,92.58 13.99,92.62 14,92.62 14.11,92.62 14.25,92.49 14.26,92.47 14.26,92.45 14.26,91.87 14.2,91.81 14.2,90.84 13.74,90.38 13.74,90.36 13.66,90.29 13.66,90.19 13.65,90.18 13.65,87.32 13.56,87.23 13.54,87.21 13.52,87.21 10.87,87.21 10.84,87.22 10.65,87.41 10.55,87.41 10.51,87.43 10.5,87.44 10.45,87.47 10.4,87.48 10.35,87.48 9.43,87.48 9.19,87.73 9.17,87.75 9.17,87.78 8.28,88.67 8.19,88.67 8.15,88.71 8.14,88.73 8.13,88.75 8.13,89.46 8.26,89.59 8.3,89.64 8.33,89.69 8.53,89.88 8.53,90.44 9.06,90.98 9.08,90.99 9.25,90.98 9.4,90.98 10.26,91.06 11.09,91.28 11.1,91.28 11.52,91.28 11.88,91.64 12.02,91.72 12.16,91.81 12.65,92.18 13.1,92.61 13.11,92.62 13.13,92.62
+1.8V_AON on BOTTOM (solid shape): 38.03,104.03 38.1,104 38.13,103.92 38.13,103.9 38.47,103.56 38.82,103.9 38.82,103.92 38.84,104 38.92,104.03 40.96,104.03 41.4,103.6 42.08,103.6 42.59,103.09 44.32,103.09 44.57,102.84 44.91,102.84 44.94,102.84 45.21,102.84 45.26,102.78 45.26,102.15 45.21,102.1 45,102.1 44.93,102.11 44.86,102.1 44.32,102.1 44.16,101.95 44.16,101.21 44.31,101.06 45.33,101.06 45.34,101.05 46.62,101.05 46.63,101.06 46.68,101.06 46.7,101.04 46.7,100.4 46.6,100.3 45.63,100.3 45.45,100.13 45.45,99.48 45.3,99.33 45.11,99.33 45.04,99.34 44.98,99.33 44.51,99.33 44.31,99.53 44.31,99.95 44.14,100.13 43.05,100.13 42.35,100.83 42.35,101.44 41.69,102.1 41.58,102.1 41.57,102.1 41.5,102.13 41.42,102.14 41.34,102.13 41.27,102.1 41.26,102.1 41.04,102.1 40.94,102.17 40.81,102.19 40.76,102.18 40.69,102.17 40.66,102.17 40.51,102.33 39.19,102.33 39.13,102.34 38.83,102.34 38.77,102.33 37.46,102.33 37.15,102.63 37.15,103.49 37.16,103.5 37.18,103.57 37.19,103.65 37.18,103.73 37.16,103.8 37.15,103.81 37.15,103.85 37.33,104.03
+1.8V_AON on BOTTOM (solid shape): outline of 256 points within 20.16,89.59 28.92,93.51
+1.8V_AON on IN1 (solid shape): 41.4,79.85 41.4,78.63 41.42,78.6 41.42,78.58 41.52,78.33 41.78,78.22 41.91,78.25 42.03,78.33 42.04,78.33 42.07,78.35 42.1,78.35 42.14,78.33 42.15,78.32 42.44,78.17 42.72,78.32 42.73,78.33 42.77,78.35 43.06,78.35 43.08,78.35 43.1,78.33 43.38,78.2 43.66,78.33 43.67,78.35 43.7,78.35 43.76,78.35 44.27,78.86 44.85,78.86 45.03,78.68 45.03,77.84 44.8,77.61 40.48,77.61 40.3,77.79 40.3,77.98 39.95,78.33 39.11,78.33 39.01,78.23 38.98,78.24 38.93,78.25 38.88,78.25 38.63,78.14 38.52,77.89 38.53,77.84 38.56,77.75 38.61,77.66 38.63,77.55 38.54,77.49 38.51,77.49 38.44,77.52 38.42,77.61 38.42,77.65 38.42,77.69 38.12,78.04 37.73,77.79 36.53,77.79 36.14,78.04 35.83,77.69 35.86,77.56 35.93,77.45 35.94,77.43 35.94,77.36 35.86,77.36 35.73,77.49 33.06,77.49 32.76,77.79 32.76,78.68 32.96,78.88 34.08,78.88 34.31,79.11 36.79,79.11 37.28,79.6 37.28,79.7 37.76,80.18 41.07,80.18
+1.8V_AON on IN1 (solid shape): outline of 1032 points within 76.35,119.93 103.4,157.34
+1.8V_AON on IN1 (solid shape): outline of 2672 points within 8.33,95.22 46.63,121.45
+1.8V_AON on IN2 (solid shape): outline of 439 points within 86,103.65 101.85,123.87
+1.8V_AON on IN2 (solid shape): outline of 769 points within 9.42,111.67 13.51,121.12
+1.8V_AON on IN3 (solid shape): 86.02,107.43 86.02,107 86.81,106.21 92.75,106.21 92.76,106.21 92.89,106.18 93.03,106.21 93.04,106.21 99.77,106.21 99.8,106.21 99.81,106.18 100.15,105.95 100.48,106.18 100.48,106.2 100.51,106.21 100.73,106.21 101.42,105.53 101.42,104.31 101.14,104.03 99.1,104.03 98.93,104.21 98.93,104.49 98.37,105.05 87.9,105.05 86.65,103.8 86.62,103.78 86.59,103.79 86.5,103.85 86.39,103.86 86.18,103.77 86.09,103.56 86.11,103.46 86.16,103.36 86.17,103.33 86.15,103.3 86.1,103.24 85.16,103.24 84.93,103.47 84.93,107.15 85.36,107.59 85.87,107.59
+1.8V_AON on IN4 (solid shape): outline of 647 points within 18.54,84.45 27.83,97.83
+1.8V_AON on IN4 (solid shape): outline of 3923 points within 7.92,119.9 79.9,159.89
+1.8V_DEEP_SUS on TOP (solid shape): 52.91,40.02 53.13,39.81 52.91,39.59 50.02,39.59 49.81,39.39 49.74,39.34 49.66,39.32 49.51,39.39 49.44,39.54 49.46,39.62 49.51,39.69 49.76,39.94 52.59,39.94 52.68,40.02
+1.8V_DEEP_SUS on BOTTOM (solid shape): 212.95,32.73 212.95,32.33 212.85,32.22 212.39,32.22 212.16,32 212.16,31.28 211.85,30.97 211.83,30.96 211.81,30.96 211.78,30.97 211.67,31.02 211.55,31.04 211.27,30.93 211.16,30.65 211.2,30.47 211.33,30.32 211.33,30.29 211.33,29.39 210.99,29.05 210.99,28.26 210.84,28.11 210.53,28.11 210.31,28.34 209.16,28.34 208.55,27.73 207.99,27.73 207.89,27.83 207.89,28.25 207.97,28.32 207.97,28.36 208.02,28.41 208.43,28.41 208.55,28.54 208.55,28.92 208.82,29.19 208.9,29.23 208.96,29.28 209.35,29.67 209.37,29.67 209.53,29.74 209.6,29.91 209.6,29.97 209.67,30.04 209.67,30.27 209.71,30.31 209.73,30.31 209.97,30.44 210.06,30.7 210.06,30.75 210.05,30.8 210.05,31.23 210.08,31.3 210.4,31.46 210.51,31.72 210.49,31.86 210.42,31.98 210.42,32.19 210.67,32.44 211.44,32.44 211.86,32.86 212.82,32.86
+1.8V_DEEP_SUS on IN2 (solid shape): outline of 327 points within 211.62,27.83 217.63,32.94
+1.8V_DEEP_SUS on IN3 (solid shape): outline of 1011 points within 199.76,27.07 213.73,33.16
+1.8V_DEEP_SUS on IN4 (solid shape): outline of 523 points within 194.13,24.98 202.06,32.2
+1.8V_MAIN on TOP (solid shape): 25.22,104.21 25.62,104.21 25.77,104.36 26.94,104.36 27.12,104.18 28.37,104.18 28.38,104.15 28.58,103.97 28.85,103.95 28.92,103.88 28.92,101.46 28.75,101.29 23.63,101.29 23.5,101.41 23.5,102.42 24.09,103 24.09,104.19 24.25,104.36 25.06,104.36
+1.8V_MAIN on TOP (solid shape): outline of 96 points within 17.09,98.11 19.35,102.79
+1.8V_MAIN on TOP (solid shape): 57.37,100.7 57.45,100.66 57.47,100.58 57.47,100.51 57.36,100.41 57.34,100.4 57.32,100.4 57.28,100.4 57.25,100.4 57,100.15 57.25,99.9 57.32,99.91 57.39,99.94 57.41,99.95 57.48,99.95 57.76,100.23 57.78,100.23 57.99,100.32 58.08,100.53 58.08,100.58 58.1,100.66 58.18,100.7 58.47,100.7 58.8,100.36 58.8,100.07 58.67,99.94 58.67,99.67 58.8,99.53 58.8,99.4 58.7,99.3 58.59,99.3 58.26,99.63 58.16,99.73 57.81,99.73 57.65,99.58 57.65,99.11 57.44,98.9 57.44,98.73 57.3,98.59 57.04,98.59 57.02,98.59 57.01,98.6 56.84,98.77 56.84,98.87 56.5,99.21 56.5,99.22 56.42,99.36 56.29,99.44 56.27,99.44 56.02,99.69 55.93,99.69 55.89,99.7 55.85,99.7 55.81,99.7 55.76,99.69 55.69,99.69 55.57,99.57 55.57,98.89 55.27,98.58 55.04,98.58 53.69,99.93 53.69,100.35 53.71,100.41 53.72,100.46 53.71,100.51 53.71,100.54 53.73,100.56 53.87,100.7
+1.8V_MAIN on BOTTOM (solid shape): 27.15,103.22 27.15,102.38 26.84,102.07 26.23,102.07 25.7,101.54 24.96,101.54 24.78,101.72 24.78,102.34 24.81,102.37 24.83,102.37 24.97,102.46 25.02,102.61 25.02,102.77 25.14,102.89 25.14,103.06 25.39,103.31 27.05,103.31
+1.8V_MAIN on BOTTOM (solid shape): outline of 90 points within 33.24,80.23 35.02,82.92
+1.8V_MAIN on BOTTOM (solid shape): 57.42,101.02 57.42,100.84 57.29,100.71 56.79,100.71 56.61,100.52 56.61,99.84 56.69,99.76 56.69,99.69 57.31,99.69 57.42,99.58 57.42,98.75 57.22,98.54 56.85,98.54 56.78,98.61 56.63,98.61 56.55,98.7 56.5,98.74 56.45,98.77 56.4,98.85 56.43,98.93 56.49,99.03 56.51,99.14 56.21,99.45 55.9,99.14 55.93,99.02 56,98.92 56.03,98.84 55.98,98.76 55.86,98.65 55.78,98.5 55.78,98.48 55.75,98.46 54.79,98.46 54.62,98.3 54.62,98.18 54.61,98.15 54.59,98.14 54.41,98 54.32,97.78 54.32,97.77 54.3,97.75 54.19,97.73 54.13,97.82 54.13,98.63 54.75,99.25 54.75,100.2 54.66,100.3 54.02,100.3 53.9,100.41 53.9,100.59 54.05,100.74 54.05,100.95 54.16,101.06 57.38,101.06
+1.8V_MAIN on IN1 (solid shape): 27.37,103.27 27.37,99.36 26.96,98.94 26.87,98.91 26.79,98.98 26.68,99.12 26.51,99.2 26.47,99.22 26.42,99.24 26.35,99.31 26.37,99.4 26.42,99.5 26.44,99.61 26.33,99.86 26.08,99.97 26,99.96 25.93,99.93 25.81,99.9 25.71,99.82 25.63,99.79 25.56,99.82 25.44,99.91 25.29,99.94 25.14,99.9 25.01,99.8 24.93,99.77 24.85,99.81 24.72,99.92 24.56,99.97 24.37,99.92 24.24,99.78 24.16,99.73 24.07,99.78 23.94,99.9 23.77,99.94 23.41,99.58 23.77,99.23 23.95,99.28 24.08,99.41 24.17,99.47 24.25,99.42 24.3,99.35 24.3,99.3 24.26,99.28 24.2,99.28 24.1,99.18 24.1,98.67 23.89,98.47 23.11,98.47 22.65,98.92 22.65,100.45 22.71,100.54 22.82,100.53 22.92,100.47 23.04,100.44 23.1,100.43 23.16,100.42 23.41,100.53 23.51,100.78 23.47,100.94 23.36,101.07 23.32,101.14 23.34,101.22 23.39,101.32 23.41,101.44 23.41,101.45 23.31,101.7 23.07,101.8 23.02,101.88 23.05,101.96 24.66,103.57 27.07,103.57
+1.8V_MAIN on IN2 (solid shape): outline of 1814 points within 25.01,98.47 56.69,105.43
+1.8V_MAIN on IN4 (solid shape): outline of 444 points within 17.11,99.33 26.9,105.76
+1.8V_S5 on TOP (solid shape): outline of 728 points within 163.14,14.27 192.78,33.09
+1.8V_S5 on BOTTOM (solid shape): 210.39,28.1 210.39,27.26 210.21,27.08 208.95,27.08 208.93,27.09 208.92,27.1 208.89,27.13 208.86,27.15 208.84,27.17 208.84,27.19 208.84,27.8 209.26,28.23 210.26,28.23
+1.8V_S5 on BOTTOM (solid shape): 229.11,12.8 229.22,12.82 230.73,12.82 230.98,12.56 230.98,11.42 231,11.36 231.03,11.32 231.03,10.87 231,10.82 230.98,10.76 230.98,9.39 230.99,9.35 231.01,9.31 230.8,9.11 228.57,9.11 228.34,9.34 228.34,12.46 228.69,12.82 229.01,12.82
+1.8V_S5 on IN1 (solid shape): outline of 1605 points within 190.92,15.36 210.86,28.6
+1.8V_S5 on IN4 (solid shape): outline of 5325 points within 209.64,9.03 247.82,30.56
+1V_GFX on TOP (solid shape): 81.58,98.21 81.58,97.83 82.04,97.37 82.98,97.37 83.15,97.2 83.15,96.59 83.38,96.36 89.02,96.36 89.15,96.23 89.15,93.49 88.97,93.31 80.66,93.31 80.6,93.25 76.5,93.25 76.49,93.23 76.27,93.23 75.96,93.54 75.96,98.26 76.07,98.37 81.43,98.37
+1V_GFX on TOP (solid shape): 99.78,97.87 100.1,97.71 100.42,97.87 101.99,97.87 102.39,97.48 102.39,97.47 102.46,97.4 104.69,97.4 104.92,97.17 104.92,96.14 105.48,95.58 106.25,95.58 106.43,95.41 106.43,95 106.27,94.83 102.28,94.83 102.27,94.82 102.24,94.82 101.93,94.51 101.93,94.48 100.86,93.41 99.23,93.41 99.08,93.56 99.08,95.55 98.51,96.11 97.4,96.11 96.94,96.57 95.73,96.57 95.73,96.58 95.56,96.58 95.33,96.81 95.33,97.65 95.56,97.87
+1V_GFX on TOP (solid shape): 48.89,100.73 48.97,100.68 48.98,100.58 48.96,100.52 48.95,100.45 49.04,100.23 49.25,100.14 49.27,100.14 49.35,100.07 49.35,99.6 49.31,99.53 49.3,99.45 49.36,99.28 49.53,99.2 49.6,99.16 49.62,99.09 49.62,99.08 49.59,99 49.52,98.97 48.97,98.97 48.91,99 48.85,99 48.79,99 48.73,98.97 48.28,98.97 48.16,99.09 48.16,99.11 48.07,99.32 47.87,99.4 47.85,99.41 47.66,99.59 47.57,99.68 47.45,99.7 47.35,99.68 47.27,99.63 47.25,99.61 47.24,99.61 46.92,99.29 46.66,99.29 46.58,99.38 46.58,100.22 47.08,100.73
+1V_GFX on TOP (solid shape): 60.05,100.76 60.14,100.7 60.13,100.59 60.06,100.49 60.04,100.38 60.35,100.07 60.65,100.38 60.63,100.49 60.57,100.59 60.55,100.7 60.64,100.76 61.2,100.76 61.98,99.97 61.99,99.96 62,99.94 62,99.68 61.99,99.66 61.98,99.64 61.9,99.45 61.98,99.26 61.99,99.24 62,99.22 62,98.85 61.86,98.71 61.84,98.7 61.82,98.7 61.69,98.67 61.57,98.57 61.54,98.57 61.34,98.57 60.18,99.72 59.77,99.72 59.66,99.61 59.66,98.85 59.4,98.59 59.25,98.59 58.79,99.05 58.79,99.2 58.92,99.33 58.92,99.61 58.82,99.71 58.82,99.89 58.95,100.02 58.95,100.55 59.15,100.76
+1V_GFX on TOP (solid shape): 51.67,100.73 51.75,100.69 51.77,100.6 51.76,100.55 51.76,100.51 52.06,100.2 52.37,100.51 52.36,100.55 52.35,100.6 52.37,100.69 52.45,100.73 52.8,100.73 52.9,100.63 52.9,100.36 52.82,100.26 52.8,100.15 52.82,100.04 52.9,99.94 52.9,99.92 52.9,99.74 52.7,99.53 52.7,99.31 52.41,99.02 52.39,99.01 52.35,99 52.29,99 52.23,98.97 51.68,98.97 51.64,98.99 51.63,99.08 51.79,99.24 51.79,99.24 51.87,99.33 51.9,99.45 51.83,99.63 51.65,99.7 51.49,99.65 51.4,99.51 51.4,99.49 51.31,99.41 51.29,99.4 51.1,99.3 51.02,99.1 51.03,99.06 51.01,99.02 50.97,99 50.93,99 50.89,99.02 50.88,99.06 50.88,99.12 50.8,99.33 50.58,99.42 50.43,99.38 50.32,99.28 50.24,99.23 50.16,99.27 50.05,99.35 49.93,99.38 49.91,99.38 49.84,99.4 49.8,99.47 49.79,99.54 49.75,99.6 49.75,100.24 49.56,100.43 49.56,100.45 49.55,100.52 49.53,100.58 49.53,100.68 49.62,100.73
+1V_GFX on BOTTOM (solid shape): outline of 147 points within 58.76,98.69 63.67,101.08
+1V_GFX on BOTTOM (solid shape): outline of 189 points within 46.91,98.66 53.92,101.13
+1V_GFX on IN1 (solid shape): outline of 4687 points within 47.44,91.43 77.74,101.26
+1V_GFX on IN2 (solid shape): outline of 168 points within 75.89,92.79 99.22,97.96
+1V_S5 on TOP (solid shape): 218.69,37.66 218.69,37.55 218.59,37.45 218.59,37.25 218.39,37.05 218.34,37.02 218.31,36.99 218.29,36.98 218.27,36.97 217.91,37.01 217.87,37.03 217.79,37.07 217.7,37.08 217.61,37.05 217.53,36.99 217.51,36.98 217.49,36.97 217.18,36.97 217.16,36.98 217.14,36.99 216.95,37.08 216.76,36.99 216.74,36.98 216.72,36.97 216.36,37.01 216.32,37.03 216.24,37.07 216.15,37.08 216.06,37.05 215.98,36.99 215.97,36.98 215.95,36.97 215.65,36.97 215.23,37.39 215.23,37.71 215.94,38.42 217.93,38.42
+1V_S5 on TOP (solid shape): 236.24,45.03 236.24,43.73 235.94,43.43 235.93,43.42 235.91,43.42 235.21,43.42 235.16,43.37 234.71,43.37 234.63,43.41 234.61,43.5 234.62,43.55 234.63,43.6 234.51,43.88 234.23,44 234.08,43.97 233.95,43.88 233.88,43.85 233.8,43.88 233.67,43.97 233.52,44 233.45,43.99 233.43,44 233.27,44.16 233.27,44.59 233.29,44.62 233.3,44.62 233.5,44.75 233.58,44.97 233.58,44.98 233.62,45.05 233.69,45.08 233.89,45.28 236,45.28
+1V_S5 on TOP (solid shape): outline of 87 points within 167.6,15.39 180.1,27.35
+1V_S5 on TOP (solid shape): outline of 217 points within 211.22,32.76 219.15,36.21
+1V_S5 on TOP (solid shape): outline of 350 points within 187.9,45.88 198.98,57.37
+1V_S5 on BOTTOM (solid shape): 215.03,42.13 214.98,42.03 214.97,41.92 215.05,41.68 215.26,41.54 215.3,41.53 215.3,41.24 215.38,41.16 215.38,40.25 215.15,39.81 215.54,39.5 215.64,39.51 215.74,39.55 215.84,39.55 215.89,39.47 215.89,38.75 216.17,38.47 218.84,38.47 218.94,38.37 218.94,37.81 218.61,37.48 218.61,37.08 218.48,36.95 215.71,36.95 215.58,37.08 215.58,37.11 215.54,37.15 215.54,37.2 215.36,37.38 214.9,37.38 214.75,37.53 214.75,38.17 214.48,38.44 214.48,39.57 214.46,39.63 214.42,39.68 214.42,40.81 214.27,40.96 214.27,42.08 214.52,42.33 215.03,42.33
+1V_S5 on BOTTOM (solid shape): outline of 196 points within 212.29,33.01 220.44,36.8
+1V_S5 on SVCC1 (solid shape): outline of 1459 points within 172.74,23.66 235.98,54.4
+2.5VSUS on TOP (solid shape): 100.7,41.46 100.78,41.44 100.87,41.43 100.92,41.43 100.97,41.44 101,41.44 101.02,41.43 101.16,41.29 101.16,39.74 100.76,39.34 100.76,36.97 100.68,36.9 99.87,36.9 99.61,37.15 99.61,39.64 99.15,40.1 99.15,41.42 99.21,41.47 100.69,41.47
+2.5VSUS on TOP (solid shape): 103.89,39.34 103.92,39.33 104.09,39.11 104.31,39.04 104.49,39.09 104.63,39.2 104.69,39.24 104.76,39.23 104.86,39.19 104.96,39.17 105.03,39.14 105.06,39.07 105.09,38.91 105.2,38.76 105.2,38.74 105.2,38.07 105.14,38.01 105.14,35.16 104.97,34.99 102.79,34.99 102.69,35.09 102.69,36.59 103.45,37.35 103.45,39.03 103.75,39.34
+2.5VSUS on TOP (solid shape): outline of 141 points within 96.15,55.95 107.26,74.51
+2.5VSUS on BOTTOM (solid shape): outline of 338 points within 98.44,36.31 105.4,53.28
+2.5VSUS on IN4 (solid shape): outline of 153 points within 104.16,50.71 107.82,57.32
+3.3V_AON on TOP (solid shape): 22.04,100.42 22.79,100.42 22.96,100.25 22.96,99.63 22.79,99.46 21.53,99.46 21.53,100.02 21.41,100.14 21.41,100.5 21.52,100.61 21.85,100.61
+3.3V_AON_S on TOP (solid shape): 21.17,99.97 21.17,99.35 21.29,99.35 21.54,99.1 21.74,99.1 21.99,98.86 21.99,96.98 21.96,96.91 21.9,96.88 21.54,96.49 21.9,96.09 21.96,96.06 21.99,95.99 21.99,94.91 21.72,94.64 21.09,94.64 21.05,94.66 21.04,94.7 21.04,95.38 21.02,95.38 20.99,95.39 20.98,95.42 20.95,95.47 20.95,95.56 20.97,95.59 20.98,95.59 21.15,95.74 21.22,95.95 21.1,96.23 20.82,96.35 20.77,96.34 20.72,96.33 20.64,96.35 20.6,96.43 20.6,96.45 20.6,96.46 20.64,96.53 20.65,96.6 20.65,96.9 20.63,96.98 20.59,97.05 20.59,97.22 20.61,97.26 20.73,97.4 20.77,97.57 20.76,97.69 20.71,97.79 20.7,97.8 20.7,97.9 20.59,98.01 20.59,99.97 20.74,100.12 21.02,100.12
+3V on TOP (solid shape): 101.15,45.72 101.5,45.72 101.67,45.56 101.67,44.52 101.55,44.4 100.76,44.4 100.76,44.42 100.27,44.42 100.17,44.52 100.17,45.79 100.42,46.04 100.83,46.04
+3V on TOP (solid shape): 181.51,104.22 181.51,103.91 181.51,103.9 181.51,103.4 181.33,103.23 180.59,103.23 179.94,103.89 179.35,103.89 179.15,104.08 179.15,104.5 179.24,104.58 181.15,104.58
+3V on TOP (solid shape): 233.01,39.82 233.01,39.28 232.89,39.16 232.89,38.5 232.71,38.32 232.35,38.32 231.64,39.03 231.39,39.03 231.13,39.28 231.13,39.74 231.24,39.85 232.44,39.85 232.49,39.89 232.94,39.89
+3V on TOP (solid shape): 75.33,162.65 75.33,161.83 75.08,161.57 75.08,160.96 74.96,160.85 73.65,160.85 73.63,160.86 73.6,160.92 73.56,160.97 73.55,160.98 73.55,161 73.55,162 73.69,162.14 74.41,162.14 74.47,162.2 74.47,162.32 74.83,162.68 75.3,162.68
+3V on TOP (solid shape): 101.44,43.16 101.44,41.83 101.19,41.58 101.08,41.58 101.04,41.61 99.96,41.61 99.44,42.12 99.44,42.34 99.44,42.37 99.43,42.46 99.28,42.61 99.26,42.63 98.91,42.63 98.67,42.87 98.67,43.2 98.85,43.37 99.64,43.37 99.66,43.39 101.21,43.39
+3V on TOP (solid shape): 193.65,55.15 193.69,55.05 193.79,55.01 193.92,55.01 193.92,54.06 193.89,53.91 193.87,53.76 193.87,53.74 193.69,53.56 192.22,53.56 191.23,54.55 191.23,54.78 191.23,54.81 191.23,55.63 191.38,55.78 191.86,55.78 192.13,56.05 192.13,56.43 193.65,56.43
+3V on TOP (solid shape): 190.25,29.75 193.41,29.75 193.85,29.31 193.85,28.57 193.67,28.39 192.27,28.39 192.18,28.3 192.01,28.3 191.91,28.26 191.87,28.16 191.87,26.84 191.71,26.69 190.59,26.69 190.43,26.85 190.43,26.88 189.76,27.55 189.76,27.85 189.77,27.89 189.77,27.92 189.77,28.3 189.77,28.33 189.76,28.37 189.76,29.56 190.06,29.86 190.15,29.86
+3V on TOP (solid shape): 234.92,34.56 234.92,34.13 234.82,34.03 234.36,34.03 234.13,33.8 234.13,33.2 234.13,33.18 234.01,33.02 233.97,32.86 233.98,32.78 233.97,32.76 233.72,32.51 233.31,32.51 233.29,32.53 233.29,32.96 233.06,33.19 232.97,33.2 232.94,33.2 232.66,33.2 232.63,33.2 232.6,33.19 232.5,33.19 232.28,32.96 231.34,32.96 231.21,33.09 231.21,33.57 231.41,33.77 232.17,33.77 232.22,33.82 232.35,33.82 232.53,34 232.91,34 233.17,34.26 233.17,34.59 233.37,34.79 234.69,34.79
+3V on TOP (solid shape): 32.16,39.23 32.16,39.21 32.22,39.12 32.31,39.04 32.35,38.99 32.34,38.91 32.32,38.83 32.31,38.75 32.42,38.47 32.7,38.35 32.96,38.45 33.09,38.68 33.09,38.7 33.12,38.73 34.11,38.73 34.21,38.62 34.21,37.89 33.9,37.58 32.49,37.58 32.37,37.7 32.37,37.77 31.98,38.17 31.59,37.77 31.59,37.63 31.57,37.6 31.54,37.58 30.96,37.58 30.85,37.68 30.85,38.74 31.35,39.24 32.13,39.24
+3V on TOP (solid shape): 95.71,34.05 96.11,34.05 96.15,34.04 96.16,34 96.16,33.95 96.04,33.83 95.94,33.83 95.64,33.7 95.52,33.4 95.52,33.36 95.46,33.26 95.35,33.28 95.02,33.61 94.95,33.61 94.94,33.63 94.9,33.67 94.86,33.69 94.82,33.7 94.82,33.75 94.37,33.75 94.37,33.74 94.35,33.71 94.25,33.64 94.23,33.55 94.23,33.25 94.27,33.15 94.37,33.11 94.82,33.11 94.85,33.11 94.91,33.12 95.54,32.5 96.47,32.5 96.69,32.71 96.95,32.45 96.95,30.8 96.84,30.7 96.53,30.7 96.44,30.73 96.36,30.74 96.28,30.73 96.19,30.7 96.01,30.7 95.99,30.72 95.95,30.76 95.88,30.77 94.51,30.77 94.45,30.76 94.4,30.72 94.39,30.7 93.98,30.7 93.96,30.72 93.91,30.76 93.85,30.77 92.48,30.77 92.43,30.76 92.38,30.73 92.35,30.72 92.31,30.73 90.94,32.1 90.94,32.58 92.34,33.97 94.59,33.97 94.75,34 94.88,34.08 94.89,34.09 94.92,34.1 95.71,34.1
+3V on TOP (solid shape): outline of 339 points within 92.98,52.63 107.67,66.53
+3V on BOTTOM (solid shape): 75,162.3 75,160.97 74.92,160.89 74.14,160.89 74.04,160.99 74.04,161.81 74.28,162.05 74.28,162.34 74.47,162.53 74.77,162.53
+3V on BOTTOM (solid shape): 219.01,14 218.97,13.96 218.34,13.96 218.28,13.9 217.63,13.9 217.63,14.43 217.7,14.5 218.17,14.5 218.46,14.78 219.01,14.78
+3V on BOTTOM (solid shape): 176.84,105.76 176.84,105.29 175.7,104.15 174.96,104.15 173.98,103.18 172.13,103.18 171.96,103.34 171.96,104.25 172.08,104.36 172.7,104.36 173.55,105.21 175.49,105.21 176.12,105.83 176.76,105.83
+3V on BOTTOM (solid shape): 14.78,47.01 16.35,47.01 16.44,46.91 16.44,46.5 16.36,46.42 14.67,46.42 14.66,46.41 14.64,46.41 14.5,46.27 14.27,46.27 13.96,46.57 12.11,46.57 12.01,46.68 12.01,47.01 12.14,47.14 12.14,47.31 12.19,47.36 14.42,47.36
+3V on BOTTOM (solid shape): 47.56,29.42 48.79,29.42 48.86,29.35 48.86,28.84 48.86,28.83 48.83,28.72 48.83,28.61 48.83,28.59 48.81,28.57 48.69,28.44 45.22,28.44 45.1,28.56 45.1,28.94 45.12,28.98 45.15,28.99 45.17,28.99 45.91,29.73 47.25,29.73
+3V on BOTTOM (solid shape): 239.92,51.81 239.92,50.51 239.79,50.38 238.7,50.38 238.66,50.43 238.66,50.47 238.67,50.48 238.75,50.61 238.78,50.75 238.72,50.96 238.53,51.13 238.52,51.16 238.52,51.76 238.68,51.91 239.82,51.91
+3V on BOTTOM (solid shape): 276.29,59.31 276.29,56.4 275.66,55.77 274.39,55.77 274.26,55.9 274.26,56.76 273.78,57.24 273.78,58.7 273.82,58.77 273.9,58.8 273.96,58.79 274.24,58.91 274.35,59.19 274.35,59.25 274.33,59.32 274.34,59.41 274.43,59.45 276.15,59.45
+3V on BOTTOM (solid shape): 98.14,51.98 98.14,51.56 98.01,51.43 98.01,50.52 97.99,50.48 97.96,50.47 97.88,50.45 97.81,50.41 97.35,49.94 97.32,49.9 97.29,49.85 97.25,49.83 97.21,49.83 97.18,49.86 97.08,49.99 96.94,50.07 96.93,50.08 96.83,50.18 96.83,50.43 97.09,50.7 97.11,50.7 97.35,50.83 97.44,51.09 97.42,51.23 97.34,51.35 97.32,51.39 97.32,51.43 97.48,51.58 97.54,51.79 97.52,51.91 97.47,52.01 97.45,52.05 97.5,52.11 98.02,52.11
+3V on BOTTOM (solid shape): 94.48,66.39 94.5,66.33 94.54,66.28 94.71,66.11 94.71,64.83 94.56,64.68 94.52,64.61 94.5,64.53 94.5,64.44 94.29,64.23 93.8,64.23 93.8,64.34 93.73,64.51 93.56,64.58 93.26,64.58 93.13,64.55 93.04,64.44 93.03,64.41 92.83,64.41 92.75,64.4 92.68,64.35 92.25,63.92 92.23,63.89 92.21,63.86 92.04,63.69 91.69,63.69 91.46,63.92 91.46,64.33 91.87,64.74 91.88,64.75 91.92,64.82 91.93,64.9 91.93,65.18 92.43,65.69 92.69,65.69 92.86,65.76 92.93,65.92 92.93,66.19 93.18,66.43 93.64,66.43 93.72,66.45 93.79,66.49 93.82,66.52 94.35,66.52
+3V on BOTTOM (solid shape): 179.76,65.96 179.83,65.95 179.9,65.96 179.98,65.98 181.28,65.98 181.36,65.96 181.43,65.95 181.75,65.95 182.29,65.41 182.72,65.41 182.9,65.42 183.03,65.29 183.03,64.96 183.02,64.93 182.99,64.91 182.47,64.91 181.87,65.51 181.43,65.51 181.28,65.48 181.15,65.4 180.99,65.4 180.89,65.36 180.85,65.26 180.85,64.9 180.85,64.89 180.86,64.84 180.89,64.8 180.89,64.74 181.04,64.58 181.51,64.58 181.52,64.58 181.6,64.58 182.09,64.08 182.09,63.42 181.72,63.05 180.35,63.05 180.19,63.21 180.19,63.37 180.19,63.39 180.19,63.83 180.19,64.54 180.26,64.61 180.26,64.66 180.36,64.76 180.36,64.78 180.4,64.84 180.42,64.89 180.42,64.9 180.42,65.26 180.4,65.33 180.35,65.38 180.26,65.47 180,65.47 179.91,65.5 179.83,65.51 179.38,65.51 179.32,65.57 179.32,65.9 179.39,65.98 179.68,65.98
+3V on BOTTOM (solid shape): 182.37,104.43 182.37,102.5 182.47,99.59 182.77,96.7 182.77,96.67 182.57,96.47 181.6,96.47 181.43,96.64 181.43,98.13 180.77,98.79 180.77,98.92 180.79,98.94 180.94,99.33 180.79,99.72 180.77,99.74 180.77,99.82 180.79,99.84 180.94,100.24 180.77,100.64 180.77,100.8 180.74,100.83 180.74,100.9 180.63,101.18 180.35,101.29 180.25,101.28 180.15,101.24 180.12,101.22 179.95,101.38 179.95,102 179.99,102.08 180.07,102.1 180.49,102.31 180.42,102.77 180.38,102.8 180.54,102.96 180.54,103.1 180.99,103.55 180.99,104.59 181.04,104.59 181.19,104.65 181.24,104.79 181.24,105.08 181.23,105.14 181.2,105.2 181.24,105.24 181.55,105.24
+3V on IN1 (solid shape): 9.54,53.2 10.08,53.2 10.76,52.52 10.76,52.16 10.78,52.15 10.76,52.11 10.72,52.03 10.71,51.93 10.82,51.68 11.07,51.58 11.16,51.59 11.25,51.63 11.28,51.65 11.45,51.48 12.8,51.48 12.83,51.45 14.98,51.45 15.97,50.46 15.97,48.6 15.66,48.29 15.6,48.29 15.35,48.19 15.25,47.93 15.25,47.92 15.31,47.73 15.47,47.6 15.5,47.59 15.5,46.77 14.84,46.11 13.92,46.11 13.61,46.42 13.61,48.07 13.86,48.33 13.9,48.29 14.01,48.22 14.14,48.2 14.39,48.3 14.5,48.56 14.49,48.64 14.46,48.72 14.44,48.75 14.73,49.04 14.73,49.39 14.7,49.43 14.7,49.65 14.72,49.68 14.72,50.05 14.47,50.29 14.12,50.29 14.04,50.22 13.99,50.22 13.94,50.25 13.82,50.35 13.66,50.39 13.42,50.3 13.31,50.07 13.3,50.03 11.02,50.03 10.71,50.21 10.4,50.03 9.89,50.03 9.45,50.46 9.45,51.82 9.43,51.84 9.43,52.03 9.24,52.03 9.04,52.24 8.15,52.24 7.82,52.57 7.82,53.48 7.94,53.61 9.14,53.61
+3V on IN1 (solid shape): outline of 421 points within 178.83,63.37 182.18,106.01
+3V on IN2 (solid shape): outline of 100 points within 100.14,38.81 105.95,45.87
+3V on IN2 (solid shape): outline of 350 points within 6.62,50.38 10.5,68.11
+3V on SVCC (solid shape): outline of 1502 points within 90.7,16.3 235.48,59.1
+3V on IN3 (solid shape): outline of 83 points within 180.4,53.32 184.04,64.95
+3V on IN3 (solid shape): 88.77,33.57 89.91,33.57 90.73,32.75 95.11,32.75 95.46,32.4 95.46,32.14 95.26,31.94 91.54,31.94 91.45,32.03 90.31,32.03 90.22,32.08 90.24,32.19 90.3,32.3 90.32,32.43 89.97,32.79 89.61,32.43 89.64,32.3 89.7,32.19 89.72,32.09 89.63,32.03 88.97,32.03 88.12,32.87 88.11,32.89 88.11,32.91 88,33.16 87.75,33.27 87.73,33.27 87.5,33.5 86.95,33.5 86.72,33.58 86.5,33.5 84.28,33.5 84.02,33.76 84.02,34.42 84.14,34.54 85.83,34.54 85.91,34.62 85.93,34.62 86.34,35.04 87.31,35.04
+3V on IN3 (solid shape): outline of 4390 points within 229.63,45.89 276.73,59.45
+3V on IN4 (solid shape): 180.18,105.42 180.18,104.21 179.89,103.92 179.22,103.92 179.12,104.01 179.12,104.5 178.95,104.67 178.48,104.67 177.98,104.17 176.51,104.17 175.33,105.35 175.33,105.65 175.71,106.04 179.56,106.04
+3V on IN4 (solid shape): outline of 752 points within 100.09,38.55 108.73,44.1
+3V on IN4 (solid shape): outline of 1082 points within 205.48,12.56 227.6,18.79
+3V3PD on TOP (solid shape): 248.29,31.26 248.32,31.24 248.32,29.98 248.33,29.96 248.33,29.4 248.18,29.25 247.36,29.25 247.06,28.95 247.06,28.26 246.88,28.08 246.12,28.08 246.04,28.17 246.04,28.98 246.02,29.05 245.97,29.1 245.95,29.11 245.95,30.31 246.04,30.39 246.46,30.39 246.98,30.91 247.91,30.91 248.05,31.06 248.05,31.12 248.06,31.14 248.08,31.18 248.09,31.22 248.09,32.02 248.29,32.02
+3V3PD-1 on TOP (solid shape): 282.08,57.32 282.13,57.28 282.19,57.27 283,57.27 283.02,57.27 283.1,57.19 283.1,55.92 282.86,55.68 282.8,55.68 282.75,55.67 280.82,55.67 280.56,55.92 280.56,57.06 280.82,57.32
+3V3PD-1 on TOP (solid shape): 279.56,52.07 279.64,52.07 280.05,51.66 280.05,51.64 280.07,51.64 280.08,51.63 280.13,51.63 280.17,51.61 280.19,51.58 280.94,51.58 280.99,51.53 280.99,51.4 280.97,51.38 280.19,51.38 280.16,51.35 280.1,51.35 280.07,51.32 280.05,51.32 280.05,51.29 279.65,50.9 279.29,50.9 278.94,51.25 278.94,51.6 278.76,51.78 278.5,51.78 278.25,52.04 278.25,52.65 278.33,52.72 278.9,52.72
+3V3PD-1 on IN4 (solid shape): outline of 247 points within 276.75,50.56 283.64,56.63
+3V_AR on TOP (solid shape): 270.1,55.39 270.1,55.08 269.77,54.75 269.06,54.75 268.88,54.93 268.37,54.93 268.29,55.01 267.56,55.01 267.47,55.1 267.47,55.28 267.64,55.46 267.77,55.46 267.91,55.6 267.91,55.73 267.97,55.79 269.7,55.79
+3V_AR on BOTTOM (solid shape): 273.98,56.63 273.98,54.32 273.7,54.04 269.18,54.04 269.07,54.16 269.07,54.64 268.84,54.87 267.9,54.87 267.75,55.02 267.75,55.55 267.93,55.73 270.16,55.73 270.36,55.93 270.93,55.93 271,56 272.38,56 272.84,56.46 272.84,56.76 272.94,56.86 273.75,56.86
+3V_AR on IN3 (solid shape): outline of 2446 points within 255.31,52.14 270.07,59.89
+3V_AR on IN4 (solid shape): outline of 191 points within 254.07,55.54 259.78,60.47
+3V_DEEP_SUS on TOP (solid shape): 212.82,13.99 212.82,12.39 212.67,12.23 212.46,12.23 211.88,12.82 211.68,12.82 210.99,13.5 210.99,14.01 211.19,14.22 212.59,14.22
+3V_DEEP_SUS on TOP (solid shape): 221.12,35.18 221.12,34.74 221.1,34.67 221.1,34.61 221.1,34.55 221.12,34.49 221.12,33.64 221.03,33.55 220.11,33.55 219.91,33.75 219.91,34.49 219.91,34.53 219.91,35.02 220.16,35.27 221.03,35.27
+3V_DEEP_SUS on TOP (solid shape): 238.88,34.96 238.88,34.46 238.82,34.34 238.79,34.2 238.81,34.09 238.86,33.98 238.78,33.89 238.3,33.89 238.25,33.94 238.25,34.48 238.24,34.49 238.24,34.51 238.22,34.51 237.98,34.74 237.98,35.07 238.11,35.19 238.65,35.19
+3V_DEEP_SUS on TOP (solid shape): 187.98,42.01 187.97,41.98 187.95,41.9 187.94,41.82 187.96,41.69 188.03,41.57 188.03,41.3 187.76,41.03 187.68,41.05 187.63,41.05 187.35,40.93 187.24,40.65 187.24,40.6 187.26,40.53 186.72,39.99 186.42,39.99 186.41,40 186.41,41.92 186.52,42.03 187.27,42.03 187.38,42.15 187.85,42.15
+3V_DEEP_SUS on BOTTOM (solid shape): 276.46,52.12 276.46,51.09 276.29,50.92 274.77,50.92 274.57,51.12 274.57,52.21 274.72,52.37 276.22,52.37
+3V_DEEP_SUS on BOTTOM (solid shape): 210.5,17.01 210.5,16.54 210.05,16.09 207.45,16.09 206.69,15.33 206.41,15.33 206.25,15.49 206.25,15.76 207.31,16.82 208.71,16.82 208.97,17.09 210.42,17.09
+3V_DEEP_SUS on BOTTOM (solid shape): 231.92,23.38 231.92,23.14 231.91,23.08 231.9,22.98 231.77,22.85 230.51,22.85 230.14,22.49 229.57,22.49 229.03,21.94 229.03,21.59 228.86,21.43 228.34,21.43 228.24,21.53 228.24,22.48 229.39,23.64 231.66,23.64
+3V_DEEP_SUS on BOTTOM (solid shape): 224.55,30.7 224.55,30.07 224.51,30.06 224.24,29.94 224.12,29.66 224.11,29.62 224.02,29.53 223.56,29.53 223.01,30.09 223.01,30.8 223.13,30.93 224.33,30.93
+3V_DEEP_SUS on BOTTOM (solid shape): 219.88,34.78 219.94,34.77 220.22,34.77 220.28,34.78 220.34,34.81 220.59,34.81 220.66,34.78 220.72,34.77 220.88,34.77 221.06,34.58 221.08,34.5 221.11,34.43 221.11,33.6 220.95,33.44 220.64,33.44 220.52,33.52 220.38,33.54 220.11,33.44 219.95,33.11 219.88,33.08 219.43,33.08 219.3,33.21 219.3,34.39 219.72,34.81 219.81,34.81
+3V_DEEP_SUS on BOTTOM (solid shape): 217.67,30.97 217.67,30.21 217.47,30.01 217.21,30.01 217.18,30.01 217.16,30.03 216.88,30.17 216.59,30.03 216.58,30.02 216.54,29.99 216.5,29.99 215.82,29.32 215.8,29.31 215.78,29.3 214.3,29.3 214.28,29.31 213.22,29.31 213.09,29.44 213.09,29.47 213.09,29.48 213.12,29.56 213.13,29.63 213.02,29.88 212.77,29.99 212.74,30 212.57,30.16 212.57,30.49 212.64,30.56 212.66,30.57 212.74,30.58 212.8,30.59 213.21,30.59 213.21,30.59 214.4,30.59 214.47,30.51 214.98,30.51 215.12,30.65 215.23,30.65 215.25,30.68 216.31,30.68 216.76,31.12 217.52,31.12
+3V_DEEP_SUS on BOTTOM (solid shape): 230.13,35.52 230.28,35.52 230.3,35.5 231.64,35.5 231.66,35.52 231.69,35.52 231.9,35.73 232.2,35.73 232.3,35.63 232.3,35.44 232.37,35.28 232.54,35.21 232.72,35.21 232.96,34.97 232.96,34.36 232.84,34.23 231.71,34.23 231.68,34.25 231.68,34.27 231.59,34.4 231.44,34.45 231.14,34.45 230.98,34.39 230.9,34.22 230.9,34.2 230.71,34.01 230.71,33.79 229.92,33 229.68,33 229.64,33 229.29,33 229.2,33.09 229.2,33.57 229.38,33.75 229.42,33.77 229.45,33.75 229.57,33.68 229.71,33.66 229.99,33.77 230.11,34.05 230.04,34.27 229.86,34.42 229.86,34.9 229.51,35.25 229.32,35.25 229.2,35.37 229.2,35.91 229.26,35.97 229.68,35.97
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 235 points within 199.89,20.64 208.75,26.45
+3V_DEEP_SUS on IN1 (solid shape): outline of 180 points within 223.68,15.37 228.66,18.91
+3V_DEEP_SUS on IN1 (solid shape): outline of 1004 points within 204.26,10.63 219.77,19.22
+3V_DEEP_SUS on IN2 (solid shape): outline of 1412 points within 255.62,43.65 276.47,51.78
+3V_DEEP_SUS on SVCC1 (solid shape): 235.98,42.61 235.98,40.5 235.73,40.4 235.63,40.15 235.73,39.9 235.98,39.79 235.98,33.06 236.02,32.87 236.13,32.7 236.49,32.34 236.49,31.11 236.13,30.75 236.02,30.59 235.98,30.39 235.98,26.92 233.59,24.53 233.48,24.37 233.44,24.17 233.44,20.09 233.31,19.96 233.27,19.78 233.31,19.6 233.44,19.47 233.44,18.75 233.26,18.62 233.19,18.41 233.26,18.19 233.44,18.07 233.44,17.91 232.85,17.31 196.32,17.31 195.85,17.78 195.85,29.04 196.21,29.39 196.27,29.44 196.32,29.51 198.06,31.25 198.1,31.25 198.18,31.26 198.25,31.28 206.16,31.28 206.27,31.21 206.4,31.18 206.53,31.21 206.65,31.28 206.85,31.28 206.96,31.22 207.08,31.2 207.2,31.22 207.31,31.28 219.98,31.28 220.18,31.32 220.34,31.43 221.78,32.87 221.89,32.8 222.03,32.77 222.28,32.87 222.38,33.13 222.36,33.26 222.28,33.37 223.11,34.21 223.13,34.2 223.38,34.31 223.49,34.56 223.49,34.58 225.15,36.24 225.27,36.32 225.35,36.44 226.95,38.04 227.06,38.2 227.1,38.4 227.1,41.74 228.07,42.71 234.05,42.71 234.31,42.78 234.49,42.97 235.63,42.97
+3V_DEEP_SUS on IN3 (solid shape): outline of 803 points within 230.8,37.87 257.8,45.48
+3V_DP on TOP (solid shape): 89.38,154.27 89.38,153.05 89.11,152.79 88.83,152.79 88.83,154.05 88.31,154.58 88.31,154.85 88.46,155.01 88.64,155.01
+3V_DP on TOP (solid shape): 96.39,154.45 96.39,154.07 96.21,153.89 94.81,153.89 94.71,153.99 94.71,154.19 94.81,154.3 95.65,154.3 95.93,154.58 96.26,154.58
+3V_DP on TOP (solid shape): 82.72,162.34 82.72,161.71 82.29,161.28 81.45,161.28 81.27,161.1 80.71,161.1 80.69,161.12 80.68,161.13 80.64,161.21 80.58,161.27 80.57,161.29 80.56,161.31 80.56,162.33 80.76,162.52 82.54,162.52
+3V_DP on BOTTOM (solid shape): 90.12,151.09 90.12,150.26 90.14,150.24 90.14,148.92 90.36,148.69 90.36,148.22 90.25,148.11 88.88,148.11 88.78,148.21 88.78,150.16 89.77,151.15 90.07,151.15
+3V_DP on BOTTOM (solid shape): 96.96,152.08 96.96,151.51 96.75,151.3 96.12,151.3 95.99,151.43 95.99,151.72 95.71,152.01 94.81,152.01 94.77,152.05 94.77,152.16 94.8,152.19 95.8,152.19 96.05,152.44 96.59,152.44
+3V_DP on BOTTOM (solid shape): 88.84,156.19 88.84,155.2 88.95,155.08 88.95,155.04 89.65,154.35 89.65,154.06 89.59,154 88.79,154 88.79,153.99 88.53,154.24 88.48,154.3 88.42,154.35 88.31,154.46 88.31,154.47 88.31,155.27 88.1,155.47 88.1,155.65 88.11,155.66 88.19,155.82 88.22,156 88.21,156.11 88.17,156.22 88.17,156.25 88.18,156.28 88.25,156.34 88.69,156.34
+3V_DP on BOTTOM (solid shape): 97.78,158.35 97.78,157.01 97.47,156.7 97.47,156.15 97.32,156 96.57,156 96.36,155.79 96.36,154.33 96.21,154.18 95.88,154.18 95.71,154 94.88,154 94.84,154.04 94.84,154.31 94.95,154.47 95,154.65 95.03,154.72 95.09,154.75 95.34,154.86 95.43,155.1 95.43,155.15 95.42,155.2 95.43,155.27 95.49,155.32 95.68,155.46 95.75,155.69 95.72,155.85 95.63,155.98 95.6,156.05 95.63,156.13 95.7,156.2 95.7,156.38 95.72,156.41 95.75,156.43 96.07,156.43 96.23,156.59 96.35,156.59 96.74,156.98 96.75,156.99 96.97,157.13 97.05,157.37 97.02,157.54 96.91,157.67 96.88,157.73 96.89,157.8 96.94,157.91 96.95,158.02 96.95,158.06 96.95,158.27 97.11,158.43 97.7,158.43
+3V_DP on IN1 (solid shape): outline of 922 points within 87.65,145.74 97.26,155.49
+3V_DVDD on TOP (solid shape): 36.1,38.71 36.1,38.61 35.68,38.19 35.68,36.02 36,35.7 36,34.79 35.96,34.75 35.95,34.75 35.8,34.6 34.98,34.6 34.85,34.73 34.85,35.02 35.11,35.28 35.11,35.68 34.83,35.96 34.37,35.96 34.26,36.07 34.26,36.26 34.26,36.27 34.26,36.48 34.61,36.82 34.61,37.42 34.4,37.63 34.4,38.7 34.51,38.82 35.12,38.82 35.35,39.04 35.77,39.04
+3V_DVDD_IO on TOP (solid shape): 30.49,38.75 30.49,37.67 30.93,37.23 31.69,37.23 31.84,37.08 31.84,36.86 31.74,36.76 30.76,36.76 30.59,36.59 29.28,36.59 29.18,36.69 29.18,37.86 29.58,38.26 29.58,38.7 29.59,38.75 29.6,38.8 29.66,38.86 30.37,38.86
+3V_EDP on BOTTOM (solid shape): 174.82,90.92 174.82,89.81 173.91,88.89 173.91,88.61 173.78,88.48 173.3,88.48 173.24,88.43 172.89,88.43 172.74,88.58 172.74,89.25 174.44,90.95 174.8,90.95
