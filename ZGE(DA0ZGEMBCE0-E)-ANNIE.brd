# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_WAKE#_TBT: length 44.4
  TOP w0.089: v1(259.25,57.48) 259.25,57.07 259.82,56.51 U7.W1
  TOP w0.14: R1153.2 237.52,44.01 237.13,43.62 237.13,43.2 237.38,42.94 237.6,42.94 v1(237.94,42.6) ; Q22.1 253.59,58.18 R140.2 254.37,58.18 254.78,58.59 255.26,58.59 v1(255.74,59.07)
  IN2 w0.089: v1(251.63,59.59) 251.37,59.59 251.02,59.25 251.02,57.03 250.71,56.72 250.71,56.14 247,52.43 247,49.73 245.19,47.92 245.19,45.9 243.83,44.54 241.14,44.54 239.67,43.07 238.63,43.07 238.16,42.6 v1(237.94,42.6)
  BOTTOM w0.14: R130.2 251.63,59.59 v1(251.63,59.59) 252.37,60.34 255.27,60.34 255.52,60.09 255.52,59.53 R737.2 255.14,59.05 255.72,59.05 v1(255.74,59.07) 256.41,59.07 257.98,57.51 v1(258.21,57.51) 258.24,57.48 v1(259.25,57.48)
PCIECOMP_N: length 4.8
  TOP w0.203: U14.B12 209.38,45.32 209.95,45.89 209.95,46.42 210.41,46.88 210.41,47.64 210.79,48.02 210.79,48.88 R171.1
PCIECOMP_P: length 4.8
  TOP w0.203: R171.2 210.17,49.34 210,49.34 209.87,49.22 209.87,48.89 210.08,48.68 210.33,48.68 210.48,48.53 210.48,48.15 210.08,47.74 210.08,47.03 209.59,46.55 209.59,46.08 U14.A13
PCM_CLK: length 188.9
  IN3 w0.089: v1(208.1,13.31) 208.1,12.88 207.51,12.3 206.23,12.3 205.9,11.97 199.43,11.97 197.98,13.42 196.28,13.42 195.09,14.61 191.41,14.61 187.98,18.04 187.1,18.04 185.46,19.67 184.16,19.67 183.68,20.15 178.09,20.15 177.19,19.26 176.26,19.26 175.51,20 175.51,22.07 174.48,23.11 174.48,23.65 171.45,26.67 166.95,26.67 166.16,25.88 164.8,25.88 164.39,26.29 153.2,26.29 152.69,25.78 148.52,25.78 147.83,25.09 143.61,25.09 143.26,25.44 141.95,25.44 141.62,25.11 133.25,25.11 130.59,22.44 125.34,22.44 121.46,26.33 120.2,26.33 119.48,27.05 102.45,27.05 99.87,24.47 99.87,23.35 99.53,23 98.12,23 97.48,23.65 96.52,23.65 96.52,23.65 96.19,23.65 95.42,22.87 95.42,22.54 94.49,21.62 89.48,21.62 89.43,21.56 88.42,21.56 87.28,22.71 84.95,22.71 84.18,23.49 82.89,23.49 82.4,23.98 77.66,23.98 76.11,25.53 74.63,25.53 74.26,25.9 74.26,27.06 70.66,30.66 70.66,31.32 69.45,32.53 67.42,32.53 67.22,32.33 66.79,32.33 66.51,32.6 64.89,32.6 64.36,32.07 63.93,32.07 63.37,32.63 62.11,32.63 62.03,32.55 60.73,32.55 60.66,32.48 58.61,32.48 58.31,32.78 58.31,33.76 56.58,35.5 54.28,35.5 54.13,35.34 52.59,35.34 52.07,35.86 49.21,35.86 v1(48.7,36.37)
  BOTTOM w0.14: CN16.8 49.07,34.5 48.88,34.7 48.88,36.19 v1(48.7,36.37) ; R1118.1 207.64,13.77 v1(208.1,13.31)
PCM_IN: length 188.8
  IN3 w0.089: v1(208.73,13.15) 207.69,12.11 206.31,12.11 205.98,11.78 199.35,11.78 197.9,13.23 196.2,13.23 195.01,14.42 191.33,14.42 187.9,17.85 187.02,17.85 185.38,19.48 184.08,19.48 183.6,19.96 178.17,19.96 177.27,19.07 176.01,19.07 175.05,20.02 171.43,20.02 171.23,19.83 165.88,19.83 165.2,19.15 160.28,19.15 159.04,20.39 151.63,20.39 149.03,22.99 144.21,22.99 143.85,22.64 133.76,22.64 131.25,20.12 118.35,20.12 116.54,21.93 116.54,22.54 114.92,24.17 111.74,24.17 111.24,24.66 104.4,24.66 100.41,20.67 100.41,19.6 99.06,18.24 97.69,18.24 97.08,18.85 95.64,18.85 94.04,20.45 91.84,20.45 91.2,19.81 88.87,19.81 88.49,19.43 84.82,19.43 83.62,20.63 83.62,20.95 83.31,21.26 83.31,21.72 82.81,22.21 82.51,22.21 81.91,22.81 80.23,22.81 79.76,22.35 79.76,21.58 78.91,20.73 77.5,20.73 76.27,21.97 74.88,21.97 74.8,22.05 73.51,22.05 73.26,22.31 73.26,23.6 73.03,23.83 73.03,24.57 72.24,25.37 71.07,25.37 70.6,25.83 70.6,28.34 69.49,29.46 69.49,30.84 69,31.33 67.87,31.33 67.43,30.88 66.75,30.88 66.64,30.78 65.55,30.78 65.43,30.9 63.73,30.9 63.01,30.18 62.12,30.18 61.6,30.7 59.46,30.7 58.75,31.41 55.94,31.41 54.99,32.36 54.99,33.03 53.27,34.74 51.83,34.74 v5(51.65,34.92)
  BOTTOM w0.14: R1117.1 208.68,13.68 208.73,13.63 v1(208.73,13.15) ; CN16.12 51.13,35.5 51.65,34.98 v5(51.65,34.92)
PD1#: length 43.1
  TOP w0.14: U22.7 15.39,22.67 15.56,22.49 15.56,21.62 v1(15.2,21.26) 15.07,21.12 D52.2 14,20.36 13.31,19.68 R475.2 13.31,19.1 12.75,18.54 R503.2 11.67,17.64 11.68,17.63 D59.2 11.13,16.78 10.99,16.92 10.99,17.56 R511.1 ; v1(41.32,27.14) 41.39,27.07 U20.7 ; U25.7 24.66,20.31 v1(25.01,20.66)
  IN4 w0.086: v1(41.32,27.14) 40.66,26.48 38.29,26.48 35.38,23.57 31.21,23.57 28.75,21.11 25.45,21.11 v1(25.01,20.66) 24.92,20.75 15.48,20.75 15.2,21.03 v1(15.2,21.26)
  BOTTOM w0.14: R1021.2 15.07,21.12 v1(15.2,21.26)
PD_GPIO1: length 1.9
  TOP w0.14: U13.17 254.22,33.17 R337.2
PD_GPIO2: length 2.3
  TOP w0.14: U13.18 253.86,33.57 254.34,34.04 R311.2
PD_GPIO16: length 1.7
  TOP w0.14: v1(245.08,35.83) 245.35,35.57 U13.48
  BOTTOM w0.14: v1(245.08,35.83) 245.09,35.84 245.88,35.84 R870.2
PD_GPIO17: length 2.4
  TOP w0.14: v1(244.76,35.23) 244.83,35.17 U13.49
  BOTTOM w0.14: v1(244.76,35.23) 245.15,34.85 R884.2
PD_LDO_1V8: length 4.4
  TOP w0.14: C228.1 249.36,41.19 249.17,41 v1(249.17,40.77) 249.33,40.6 249.68,40.6 249.94,40.35 249.94,39.92 249.5,39.48 249.5,39.05 249.39,38.94 U13.35
PECI: length 5.4
  TOP w0.089: U3.BT34 160.92,128.58 163.13,130.79 R52.2 163.72,130.98 R47.1
PEG_COMP: length 11.1
  TOP w0.254: U3.G2 123.56,105.51 123.56,104.73 122.42,103.59 120.36,103.59 119.61,104.34 118.92,104.34 118.59,104.66 118.21,104.66 118.11,104.56 115.47,104.56 v1(115.42,104.62) 115.37,104.56 R102.2
PEG_RXN0: length 101.1
  TOP w0.095: v1(121.86,110.39) 121.78,110.47 121.78,110.6 121.96,110.78 U3.E10
  BOTTOM w0.102: 117.19,109.76 117.22,109.76 117.25,109.72 118.18,109.72 118.46,109.45 119.19,109.45 119.95,110.21 120.92,110.21 121.35,109.78 121.95,109.78 122.11,109.94 122.11,110.33 122.05,110.39 v1(121.86,110.39)
  BOTTOM w0.14: 117.19,109.76 116.8,109.76 116.75,109.7 116.71,109.66 115.58,108.53 115.58,103.4 113.25,101.08 113.25,91.79 110.43,88.96 110.43,87.51 104.64,81.73 104.43,81.73 102.91,80.2 101.9,80.2 100.9,81.2 97.54,81.2 96.88,80.53 96.88,78.9 95.94,77.96 95.74,77.96 94.96,77.18 94.96,76.99 94.17,76.2 89.15,76.2 87.34,78.01 57.11,78.01 52.66,82.45 52.66,83.74 52.93,84.01 CG890.1
PEG_RXN0_C: length 13.3
  TOP w0.102: v2(54.12,95.62) 54.56,95.62 54.66,95.72 54.66,95.86 54.57,95.95 UG1.BH26
  BOTTOM w0.102: v2(54.12,95.62) 54,95.5 54,95.36 54.35,95.01 54.35,94.02 53.02,92.69 53.02,92.48 53.05,92.45 53.05,92.42
  BOTTOM w0.14: CG890.2 52.95,84.46 52.77,84.64 52.77,88.09 53.05,88.38 53.05,92.42
PEG_RXN1: length 98.1
  TOP w0.089: v1(121.87,111.16) 121.87,111.18 122.19,111.5 U3.E11
  BOTTOM w0.102: 116.66,110.24 116.68,110.24 116.71,110.27 119.24,110.27 119.5,110.53 121.43,110.53 121.68,110.78 121.68,110.97 v1(121.87,111.16)
  BOTTOM w0.14: CG898.1 53.69,82.64 53.69,82.21 57.33,78.58 87.58,78.58 89.41,76.75 93.95,76.75 94.41,77.21 94.41,77.72 95.21,78.51 95.71,78.51 96.33,79.13 96.33,80.76 96.74,81.17 96.74,82.95 97.98,84.19 100.72,84.19 102.58,86.04 104.48,86.04 104.91,85.61 107.71,85.61 109.64,87.54 109.64,89.08 112.71,92.14 112.71,101.31 115.03,103.63 115.03,108.83 116.44,110.24 116.66,110.24
PEG_RXN1_C: length 15.9
  TOP w0.105: UG1.BE26 v2(54.78,97.72)
  BOTTOM w0.102: 53.61,92.42 53.61,92.45 53.64,92.48 53.64,92.84 53.94,93.13 53.95,93.13 54.62,93.8 54.62,96.35 54.28,96.69 54.28,97.08 54.78,97.58 v2(54.78,97.72)
  BOTTOM w0.14: 53.61,92.42 53.61,87.29 53.9,87.01 53.9,85.49 53.65,85.24 53.65,83.51 CG898.2
PEG_RXN2: length 95.2
  TOP w0.089: U3.E12 122.17,112.37 121.96,112.37 121.77,112.18 121.77,112.05 v1(121.85,111.97)
  BOTTOM w0.102: 116.66,111.32 116.68,111.32 116.71,111.29 117.67,111.29 117.89,111.52 119.65,111.52 119.96,111.83 121.31,111.83 121.42,111.93 121.42,112.26 121.52,112.36 121.74,112.36 121.92,112.18 121.92,112.04 v1(121.85,111.97)
  BOTTOM w0.14: 116.66,111.32 116,111.32 115.56,110.89 113.95,109.28 113.95,104.08 111.58,101.71 111.58,92.66 108.5,89.58 108.5,88.15 107.47,87.12 102.11,87.12 100.25,85.27 94.93,85.27 93.33,86.87 89.27,86.87 82.06,79.66 57.79,79.66 55,82.45 55,83.86 55.15,84.01 CG888.1
PEG_RXN2_C: length 13.6
  TOP w0.102: UG1.BG27 55.04,96.65 54.94,96.55 54.94,96.39 55,96.32 v2(55.48,96.32)
  BOTTOM w0.102: v2(55.48,96.32) 55.26,96.11 55.26,93.08 55.03,92.85 55.03,92.48 55.06,92.45 55.06,92.42
  BOTTOM w0.14: 55.06,92.42 55.06,92.27 54.69,91.9 54.69,87.94 54.98,87.65 54.98,84.6 55.12,84.46 CG888.2
PEG_RXN3: length 91.5
  TOP w0.089: v1(121.86,112.75) 122.19,113.07 U3.E13
  BOTTOM w0.102: v1(121.86,112.75) 121.59,113.02 121.59,113.15 121.35,113.39 120.29,113.39 118.94,112.03 118.39,112.03 118.26,112.16 116.66,112.16
  BOTTOM w0.14: CG895.1 56.27,82.87 56.09,82.69 56.09,82.55 58.17,80.47 81.73,80.47 88.93,87.68 93.67,87.68 95.27,86.08 99.86,86.08 101.72,87.93 102.44,87.93 103.25,88.74 105.81,88.74 108.28,91.21 108.98,91.21 110.76,92.99 110.76,102.66 113.11,105.01 113.11,109.66 115.61,112.16 116.66,112.16
PEG_RXN3_C: length 14.2
  TOP w0.102: v2(56.22,95.62) 56.26,95.59 56.79,95.59 56.9,95.69 56.9,95.87 56.82,95.95 UG1.BH29
  BOTTOM w0.102: v2(56.22,95.62) 56.11,95.51 56.11,95.31 56.33,95.09 56.33,93.07 55.88,92.62 55.88,92.47 55.91,92.45 55.91,92.42
  BOTTOM w0.14: 55.91,92.42 55.91,86.62 56.18,86.35 56.18,83.46 56.32,83.32 CG895.2
PEG_RXN4: length 91.1
  TOP w0.095: v1(122.51,113.54) 122.41,113.43 122.01,113.43 121.81,113.63 121.81,113.76 121.98,113.93 U3.E14
  BOTTOM w0.102: v1(122.51,113.54) 122.51,113.37 122.4,113.26 122.23,113.26 121.56,113.94 120.13,113.94 119.29,113.09 117.68,113.09 117.58,112.99 116.66,112.99
  BOTTOM w0.14: CG886.1 57.32,84.01 57.15,83.84 57.15,83.45 59.31,81.28 81.39,81.28 88.6,88.49 94,88.49 95.6,86.89 99.42,86.89 101.27,88.74 102.11,88.74 102.91,89.55 104.09,89.55 107.43,92.88 107.43,93.59 109.94,96.1 109.94,102.99 111.81,104.85 111.81,106.05 112.3,106.54 112.3,110.07 114.34,112.11 115.22,112.99 116.66,112.99
PEG_RXN4_C: length 15.3
  TOP w0.105: UG1.BE29 v2(56.22,98.38)
  BOTTOM w0.102: v2(56.22,98.38) 56.44,98.16 56.59,98.16 56.87,97.88 56.87,93.03 57.14,92.76 57.14,92.48 57.17,92.45 57.17,92.42
  BOTTOM w0.14: CG886.2 57.45,84.54 57.45,86.3 56.8,86.95 56.8,89.5 57.17,89.87 57.17,92.42
PEG_RXN5: length 88.9
  TOP w0.089: U3.E15 122.51,114.39 v1(122.51,114.32)
  BOTTOM w0.102: 116.66,113.81 116.68,113.78 118.18,113.78 118.44,113.52 119.01,113.52 119.94,114.45 121.16,114.45 121.44,114.73 121.87,114.73 121.87,114.73 122.02,114.73 122.44,114.32 v1(122.51,114.32)
  BOTTOM w0.14: CG884.1 59.32,84.01 59.18,83.87 59.18,83.62 60.71,82.1 81.05,82.1 88.26,89.3 94.34,89.3 95.86,87.79 99.16,87.79 100.93,89.56 101.77,89.56 102.58,90.36 103.76,90.36 106.62,93.22 106.62,93.93 109.12,96.44 109.12,104.69 109.73,105.29 109.73,110.85 111.32,112.44 111.96,112.44 112.11,112.29 113.21,112.29 114.73,113.81 116.66,113.81
PEG_RXN5_C: length 14.2
  TOP w0.102: UG1.BG30 57.12,96.65 57.03,96.55 57.03,96.41 57.12,96.32 57.35,96.32
  TOP w0.105: v2(57.58,96.32) 57.35,96.32
  BOTTOM w0.102: 57.99,92.42 57.99,92.45 57.95,92.48 57.95,92.85 57.4,93.41 57.4,96.15 v2(57.58,96.32)
  BOTTOM w0.14: 57.99,92.42 57.99,89.54 57.61,89.16 57.61,87.49 59.02,86.08 59.02,84.61 59.17,84.46 CG884.2
PEG_RXN6: length 89.5
  TOP w0.089: U3.E16 122.19,115.48 122.36,115.3 122.45,115.3 122.55,115.41 122.55,115.86 v1(122.51,115.9)
  BOTTOM w0.102: 116.66,114.63 116.74,114.63 116.81,114.56 119.35,114.56 119.76,114.97 120.96,114.97 121.13,115.14 122.33,115.14 122.78,115.59 122.78,115.78 122.66,115.9 v1(122.51,115.9)
  BOTTOM w0.14: 116.66,114.63 114.4,114.63 112.91,113.13 112.42,113.13 111.92,113.63 109.55,113.63 108.86,112.94 108.86,105.58 108.31,105.03 108.31,96.77 107.53,95.99 106.93,95.99 105.8,94.87 105.8,93.56 103.42,91.18 102.24,91.18 101.43,90.37 100.58,90.37 98.81,88.6 96.2,88.6 94.68,90.12 87.92,90.12 80.71,82.91 61.52,82.91 60.97,83.47 60.97,83.85 61.11,83.99 CG892.1
PEG_RXN6_C: length 13.8
  TOP w0.102: UG1.BH32 58.76,95.95 58.87,95.83 58.87,95.69 58.74,95.56 58.4,95.56 v2(58.27,95.69)
  BOTTOM w0.102: 58.82,92.42 58.82,92.45 58.79,92.48 58.79,92.85 58.44,93.2 58.44,95.16 58.27,95.33 v2(58.27,95.69)
  BOTTOM w0.14: CG892.2 61.09,84.44 60.93,84.6 60.93,85.86 59.43,87.36 59.43,88.23 58.82,88.84 58.82,92.42
PEG_RXN7: length 79.6
  TOP w0.095: v1(121.86,115.9) 121.86,115.97 U3.E17
  BOTTOM w0.102: 116.68,115.23 116.71,115.26 117.67,115.26 118.05,114.88 119.2,114.88 119.59,115.27 120.87,115.27 120.94,115.34 121.31,115.34 v1(121.86,115.9)
  BOTTOM w0.14: CG894.1 67.81,83.72 67.99,83.9 68.29,83.9 68.73,83.47 76.68,83.47 79.94,86.72 83.75,86.72 87.7,90.66 94.9,90.66 96.42,89.14 98.58,89.14 101.88,92.45 103.92,92.45 105.1,93.62 105.1,94.93 107.73,97.57 107.73,105.23 108.31,105.81 108.31,113.23 109.71,114.63 112.26,114.63 112.87,115.23 116.68,115.23
PEG_RXN7_C: length 21.4
  TOP w0.102: UG1.BE32 58.65,98.03 v2(58.97,97.7)
  BOTTOM w0.102: v2(58.97,97.7) 58.72,97.45 58.64,97.45 58.39,97.2 58.39,96.78 58.77,96.4 58.77,93.67 59.79,92.65 59.79,92.48 59.76,92.45 59.76,92.42
  BOTTOM w0.14: 59.76,92.42 59.76,88.72 59.98,88.5 59.98,87.59 62.19,85.38 62.19,84.23 62.86,83.56 66.59,83.56 66.74,83.7 67.24,83.7 CG894.2
PEG_RXN8: length 46
  TOP w0.089: v1(122.51,117.47) 122.84,117.15 U3.F18
  BOTTOM w0.102: v1(122.51,117.47) 122.51,117.21 122.37,117.07 122.01,117.07 121.53,116.58 119.93,116.58 119.47,116.12 118.21,116.12 118.04,116.28 116.71,116.28 116.68,116.31 116.66,116.31
  BOTTOM w0.14: CG880.1 98.21,90.52 98.4,90.52 101.4,93.53 103,93.53 103.55,94.08 103.55,94.92 106.6,97.97 106.6,107.08 107.22,107.7 107.22,113.72 109.21,115.71 111.8,115.71 112.4,116.31 116.66,116.31
PEG_RXN8_C: length 52.2
  TOP w0.102: UG1.BG33 59.04,96.65 58.94,96.54 58.94,96.36 59.04,96.25 59.61,96.25 v2(59.68,96.32)
  BOTTOM w0.102: 60.91,92.42 60.91,92.45 60.88,92.48 60.88,92.69 59.48,94.08 59.48,96.13 v2(59.68,96.32)
  BOTTOM w0.14: 60.91,92.42 60.91,91.7 61.23,91.37 61.23,87.86 63.93,85.16 76.68,85.16 79.41,87.89 83.39,87.89 87.25,91.74 88.98,91.74 89.59,92.35 94.74,92.35 96.73,90.37 97.42,90.37 97.56,90.5 CG880.2
PEG_RXN9: length 44.9
  TOP w0.095: U3.D19 121.47,117.93 121.31,117.93 121.21,117.83 v1(121.21,117.47)
  BOTTOM w0.102: 117.27,117.32 117.3,117.32 117.33,117.29 118.04,117.29 118.67,116.66 119.12,116.66 119.51,117.05 121.27,117.05 121.45,117.23 121.45,117.38 121.36,117.47 v1(121.21,117.47)
  BOTTOM w0.14: CG878.1 98.26,91.98 98.7,91.98 101.05,94.34 101.82,94.34 105.76,98.28 105.76,107.66 106.41,108.31 106.41,114.19 109.65,117.44 111.06,117.44 111.18,117.56 114.57,117.56 114.81,117.32 117.27,117.32
PEG_RXN9_C: length 49.9
  TOP w0.102: v2(60.38,95.66) 60.47,95.57 61.01,95.57 61.11,95.67 61.11,95.85 61.01,95.95 UG1.BH35
  BOTTOM w0.102: 61.75,92.42 61.75,92.45 61.72,92.48 61.72,92.71 60.55,93.88 60.55,95.08 60.19,95.43 60.19,95.52 60.34,95.66 v2(60.38,95.66)
  BOTTOM w0.14: 61.75,92.42 61.75,92 62.05,91.71 62.05,90.19 62.43,89.81 62.43,87.94 64.4,85.98 76.33,85.98 79.05,88.7 83.06,88.7 86.92,92.56 88.65,92.56 89.25,93.16 95.08,93.16 96.38,91.87 97.42,91.87 97.56,92.01 CG878.2
PEG_RXN10: length 45.2
  TOP w0.089: v1(122.51,119.05) 122.84,118.72 U3.F20
  BOTTOM w0.102: 117.79,118.14 117.83,118.14 117.86,118.11 118.16,118.11 118.57,117.7 119.65,117.7 120.05,118.1 121.56,118.1 v1(122.51,119.05)
  BOTTOM w0.14: 117.79,118.14 115.49,118.14 115.26,118.38 110.85,118.38 110.73,118.26 109.3,118.26 105.58,114.54 105.58,109 104.93,108.36 104.93,98.6 101.49,95.15 100.71,95.15 99.15,93.59 98.24,93.59 CG867.1
PEG_RXN10_C: length 50
  TOP w0.105: UG1.BE35 60.75,98.05 v2(60.42,98.38)
  BOTTOM w0.102: 62.6,92.42 62.6,92.45 62.56,92.48 62.56,92.63 61.08,94.11 61.08,97.78 60.81,98.05 60.58,98.05 60.42,98.21 v2(60.42,98.38)
  BOTTOM w0.14: CG867.2 97.27,93.58 96.52,93.58 96.12,93.98 88.92,93.98 88.42,93.48 84.71,93.48 80.75,89.51 78.7,89.51 75.97,86.79 64.8,86.79 63.64,87.95 63.64,91.27 62.6,92.31 62.6,92.42
PEG_RXN11: length 87.6
  TOP w0.095: U3.D21 121.64,119.54 121.64,119.69 121.54,119.79 121.3,119.79 121.21,119.71 v1(121.21,119.05)
  BOTTOM w0.102: 117.79,118.99 117.81,118.99 117.84,118.95 117.99,118.95 118.7,118.25 119.17,118.25 119.49,118.57 121.1,118.57 121.31,118.78 121.31,118.95 v1(121.21,119.05)
  BOTTOM w0.14: CG875.1 63.79,92.65 63.65,92.51 63.65,92.41 64.78,91.28 65.41,91.28 66.06,90.63 66.06,88.24 66.69,87.61 75.64,87.61 78.35,90.33 80.41,90.33 85.29,95.2 90.86,95.2 91.27,94.79 99.2,94.79 100.37,95.96 101.12,95.96 103.31,98.15 103.31,98.9 104.1,99.69 104.1,114.92 109.61,120.43 110.49,120.43 110.68,120.23 114.74,120.23 115.99,118.99 117.79,118.99
PEG_RXN11_C: length 6.1
  TOP w0.102: 61.55,96.32 61.36,96.32 61.25,96.42 61.25,96.57 61.34,96.65 UG1.BG36
  TOP w0.105: v2(61.78,96.32) 61.55,96.32
  BOTTOM w0.102: CG875.2 63.56,93.1 63.46,93.2 63.46,93.6 63.16,93.89 61.94,93.89 61.59,94.25 61.59,96.13 v2(61.78,96.32)
PEG_RXN12: length 84.9
  TOP w0.089: v1(122.51,120.62) 122.51,120.37 122.66,120.23 U3.F22
  BOTTOM w0.102: v1(122.51,120.62) 122.51,120.43 122.34,120.26 122.07,120.26 121.52,119.71 120.14,119.71 119.77,119.34 118.45,119.34 118.02,119.77 117.84,119.77 117.81,119.8 117.79,119.8
  BOTTOM w0.14: 117.79,119.8 116.63,119.8 115.38,121.05 111.04,121.05 110.81,121.28 109.31,121.28 103.28,115.25 103.28,100.02 102.47,99.21 102.47,98.47 100.78,96.78 100.04,96.78 98.89,95.63 91.6,95.63 91.22,96.02 82.89,96.02 76.03,89.15 70.61,89.15 70,89.75 70,90.8 69.6,91.2 68.54,91.2 68.39,91.35 66.48,91.35 65.74,92.09 65.4,92.09 65.14,92.35 65.14,92.51 65.28,92.65 CG873.1
PEG_RXN12_C: length 5.6
  TOP w0.102: UG1.BH38 62.96,95.95 63.07,95.84 63.07,95.7 62.99,95.63 v2(62.53,95.63)
  BOTTOM w0.102: CG873.2 65.16,93.1 65.06,93.2 65.06,93.64 64.7,94 63.7,94 62.37,95.32 62.37,95.47 v2(62.53,95.63)
PEG_RXN13: length 81.9
  TOP w0.095: U3.D23 121.54,121.16 121.42,121.28 121.28,121.28 121.19,121.19 121.19,120.65 v1(121.21,120.62)
  BOTTOM w0.102: v1(121.21,120.62) 121.43,120.4 121.43,120.26 121.33,120.15 119.77,120.15 119.43,119.81 118.76,119.81 117.99,120.58 117.99,120.63 117.97,120.65
  BOTTOM w0.14: 117.97,120.65 117.31,121.31 115.41,123.22 110.06,123.22 102.46,115.62 102.46,100.35 101.64,99.53 101.64,98.81 100.46,97.63 99.74,97.63 98.57,96.46 95.14,96.46 94.75,96.85 82.58,96.85 76.67,90.94 73.45,90.94 72.38,92.02 69.27,92.02 69.12,92.17 67.05,92.17 66.91,92.31 66.91,92.57 66.99,92.65 CG871.1
PEG_RXN13_C: length 8.9
  TOP w0.105: UG1.BE38 v2(62.52,98.38)
  BOTTOM w0.102: v2(62.52,98.38) 62.81,98.09 62.95,98.09 63.19,97.85 63.19,95.65 63.54,95.29 63.54,94.78 63.87,94.45 65.2,94.45 65.8,93.84 66.54,93.84 66.98,93.4 66.98,93.24 CG871.2
PEG_RXN14: length 79.2
  TOP w0.095: U3.F24 122.84,121.74 v1(122.51,121.41)
  BOTTOM w0.102: v1(122.51,121.41) 122.29,121.63 122.29,121.86 122.07,122.08 121.55,122.08 120.83,121.36 118.43,121.36 118.27,121.52 118.27,121.56 118.26,121.58
  BOTTOM w0.14: 118.26,121.58 116.49,123.35 115.81,124.03 109.67,124.03 101.63,115.99 101.63,100.71 98.58,97.67 87.89,97.67 87.7,97.86 82.32,97.86 76.22,91.75 73.79,91.75 72.71,92.83 69.65,92.83 69.22,93.26 69,93.26 CG868.1
PEG_RXN14_C: length 8.1
  TOP w0.105: v2(63.9,96.3) 63.3,96.3 63.21,96.39 63.21,96.54 63.32,96.65 UG1.BG39
  BOTTOM w0.102: v2(63.9,96.3) 63.7,96.11 63.7,95.97 64.28,95.39 64.92,95.39 65.97,94.35 66.92,94.35 67.76,93.51 67.76,93.27 68.02,93.02 68.27,93.02 68.38,93.12 CG868.2
PEG_RXN15: length 81
  TOP w0.089: v1(121.21,122.98) 121.18,122.96 121.18,122.55 121.27,122.46 121.41,122.46 U3.D25
  BOTTOM w0.102: v1(121.21,122.98) 121.43,122.76 121.43,122.67 121.28,122.51 119.28,122.51 119.25,122.55 119.22,122.55
  BOTTOM w0.14: CG863.1 67.86,95.3 68.34,95.3 69.99,93.64 73.05,93.64 74.13,92.57 75.78,92.57 81.92,98.7 88.03,98.7 88.26,98.48 98.24,98.48 100.81,101.05 100.81,116.35 108.59,124.13 108.59,124.48 109.34,125.23 111.34,125.23 111.99,125.88 115.16,125.88 118.5,122.55 119.22,122.55
PEG_RXN15_C: length 3.6
  TOP w0.105: UG1.BG41 v2(64.61,96.31)
  BOTTOM w0.102: v2(64.61,96.31) 64.76,96.16 65.07,96.16 65.82,95.41 66.47,95.41 66.59,95.29 66.97,95.29 67.11,95.43 CG863.2
PEG_RXP0: length 101.2
  TOP w0.089: U3.F10 v1(122.51,110.39)
  BOTTOM w0.102: v1(122.51,110.39) 122.31,110.19 122.31,109.86 122.03,109.58 121.26,109.58 120.84,110 120.04,110 119.28,109.25 118.37,109.25 118.1,109.52 117.25,109.52 117.22,109.49 117.19,109.49
  BOTTOM w0.14: 117.19,109.49 116.88,109.49 116.83,109.44 116.83,109.4 115.84,108.42 115.84,103.29 113.52,100.97 113.52,91.68 110.69,88.85 110.69,87.4 104.75,81.46 104.55,81.46 103.02,79.94 101.79,79.94 100.79,80.93 97.65,80.93 97.14,80.42 97.14,78.79 96.05,77.7 95.85,77.7 95.23,77.07 95.23,76.88 94.28,75.93 89.04,75.93 87.23,77.74 56.99,77.74 52.4,82.34 CG891.1
PEG_RXP0_C: length 13.4
  TOP w0.105: UG1.BG26 v2(54.12,96.32)
  BOTTOM w0.102: 52.79,92.42 52.79,92.45 52.82,92.48 52.82,92.78 54.15,94.11 54.15,94.93 53.77,95.31 53.77,95.77 54.12,96.13 v2(54.12,96.32)
  BOTTOM w0.14: 52.79,92.42 52.79,88.49 52.5,88.2 52.5,84.57 CG891.2
PEG_RXP1: length 98.1
  TOP w0.095: U3.D11 121.54,111.68 121.39,111.83 121.28,111.83 121.21,111.76 v1(121.21,111.17)
  BOTTOM w0.102: 116.66,110.51 116.68,110.51 116.71,110.48 119.16,110.48 119.42,110.74 121.35,110.74 121.48,110.86 121.48,111.04 121.35,111.17 v1(121.21,111.17)
  BOTTOM w0.14: 116.66,110.51 116.33,110.51 114.76,108.94 114.76,103.74 112.44,101.42 112.44,92.25 109.38,89.19 109.38,87.65 107.6,85.87 105.02,85.87 104.59,86.31 102.47,86.31 100.61,84.45 97.87,84.45 96.48,83.06 96.48,81.28 96.06,80.87 96.06,79.24 95.6,78.78 95.1,78.78 94.15,77.83 94.15,77.32 93.84,77.02 89.52,77.02 87.69,78.85 57.44,78.85 53.96,82.32 53.96,82.71 54.12,82.87 CG897.1
PEG_RXP1_C: length 15.9
  TOP w0.102: UG1.BF26 54.42,97.35 54.32,97.25 54.32,97.04 54.4,96.96 54.73,96.96 v2(54.78,97.02)
  BOTTOM w0.102: 53.88,92.42 53.88,92.45 53.85,92.48 53.85,92.75 54.03,92.93 54.04,92.93 54.82,93.71 54.82,96.43 54.48,96.77 54.48,96.99 54.57,97.08 54.71,97.08 v2(54.78,97.02)
  BOTTOM w0.14: CG897.2 54.06,83.32 53.92,83.46 53.92,85.13 54.17,85.38 54.17,87.12 53.88,87.41 53.88,92.42
PEG_RXP2: length 95.3
  TOP w0.089: U3.F12 v1(122.51,111.96)
  BOTTOM w0.102: 116.66,111.06 116.68,111.06 116.71,111.09 117.75,111.09 117.98,111.32 119.73,111.32 120.04,111.62 121.63,111.62 121.69,111.57 122.12,111.57 v1(122.51,111.96)
  BOTTOM w0.14: CG889.1 54.73,83.88 54.73,82.34 57.68,79.39 82.17,79.39 89.38,86.6 93.22,86.6 94.82,85 100.36,85 102.22,86.85 107.58,86.85 108.77,88.04 108.77,89.47 111.85,92.55 111.85,101.6 114.22,103.97 114.22,109.17 116.11,111.06 116.66,111.06
PEG_RXP2_C: length 13.6
  TOP w0.105: UG1.BF27 v2(55.48,97.02)
  BOTTOM w0.102: 54.8,92.42 54.8,92.45 54.83,92.48 54.83,92.93 55.06,93.16 55.06,96.49 55.48,96.9 v2(55.48,97.02)
  BOTTOM w0.14: 54.8,92.42 54.8,92.38 54.43,92.01 54.43,87.83 54.71,87.54 54.71,84.57 CG889.2
PEG_RXP3: length 91.5
  TOP w0.089: U3.D13 121.54,113.07 v1(121.21,112.75)
  BOTTOM w0.102: v1(121.21,112.75) 121.38,112.92 121.38,113.07 121.27,113.19 120.38,113.19 119.02,111.83 118.3,111.83 118.18,111.96 116.77,111.96 116.75,111.94 116.71,111.94 116.67,111.89 116.66,111.89
  BOTTOM w0.14: 116.66,111.89 115.72,111.89 113.38,109.55 113.38,104.9 111.03,102.55 111.03,92.88 109.09,90.94 108.39,90.94 105.92,88.47 103.36,88.47 102.56,87.66 101.83,87.66 99.97,85.81 95.16,85.81 93.56,87.41 89.04,87.41 81.84,80.2 58.06,80.2 55.82,82.44 55.82,82.67 CG896.1
PEG_RXP3_C: length 14.2
  TOP w0.105: UG1.BG29 v2(56.22,96.32)
  BOTTOM w0.102: 55.64,92.42 55.64,92.43 55.68,92.47 55.68,92.7 56.13,93.15 56.13,95 55.87,95.26 55.87,95.79 56.22,96.15 v2(56.22,96.32)
  BOTTOM w0.14: CG896.2 55.91,83.61 55.91,86.24 55.64,86.51 55.64,92.42
PEG_RXP4: length 91.1
  TOP w0.095: v1(123.16,113.54) 123.16,113.6 U3.F14
  BOTTOM w0.102: 116.66,112.72 116.74,112.72 116.81,112.78 117.66,112.78 117.77,112.89 119.37,112.89 120.21,113.73 121.47,113.73 122.15,113.05 122.68,113.05 v1(123.16,113.54)
  BOTTOM w0.14: 116.66,112.72 115.33,112.72 112.57,109.96 112.57,106.43 112.08,105.94 112.08,104.74 110.21,102.87 110.21,95.99 107.7,93.48 107.7,92.77 104.21,89.28 103.03,89.28 102.22,88.48 101.38,88.48 99.53,86.62 95.49,86.62 93.89,88.23 88.71,88.23 81.5,81.02 59.2,81.02 56.88,83.34 56.88,83.89 CG887.1
PEG_RXP4_C: length 15.3
  TOP w0.105: UG1.BF29 v2(56.22,97.67)
  BOTTOM w0.102: 56.9,92.42 56.9,92.45 56.93,92.47 56.93,92.68 56.67,92.94 56.67,97.79 56.51,97.95 56.39,97.95 56.22,97.79 v2(56.22,97.67)
  BOTTOM w0.14: 56.9,92.42 56.9,89.98 56.53,89.61 56.53,86.84 57.18,86.19 57.18,84.69 56.95,84.46 CG887.2
PEG_RXP5: length 88.9
  TOP w0.089: U3.D15 121.64,114.82 121.79,114.82 121.86,114.75 v1(121.86,114.32)
  BOTTOM w0.102: v1(121.86,114.32) 121.86,114.42 121.75,114.53 121.52,114.53 121.24,114.25 120.03,114.25 119.09,113.32 118.36,113.32 118.1,113.58 116.69,113.58 116.66,113.54
  BOTTOM w0.14: 116.66,113.54 114.84,113.54 113.33,112.02 112,112.02 111.85,112.18 111.43,112.18 110,110.74 110,105.18 109.39,104.58 109.39,96.33 106.88,93.82 106.88,93.11 103.87,90.1 102.69,90.1 101.88,89.29 101.04,89.29 99.27,87.52 95.75,87.52 94.23,89.04 88.37,89.04 81.16,81.83 60.6,81.83 58.91,83.51 58.91,83.76 CG885.1
PEG_RXP5_C: length 14.2
  TOP w0.105: UG1.BF30 v2(57.58,97.02)
  BOTTOM w0.102: v2(57.58,97.02) 57.19,96.64 57.19,93.33 57.75,92.77 57.75,92.48 57.72,92.45 57.72,92.42
  BOTTOM w0.14: CG885.2 58.76,84.55 58.76,85.96 57.34,87.37 57.34,89.27 57.72,89.65 57.72,92.42
PEG_RXP6: length 89.5
  TOP w0.089: v1(123.16,115.9) 123.16,115.83 U3.F16
  BOTTOM w0.102: v1(123.16,115.9) 122.98,115.71 122.98,115.5 122.42,114.94 121.21,114.94 121.04,114.77 119.84,114.77 119.43,114.36 116.66,114.36
  BOTTOM w0.14: 116.66,114.36 114.51,114.36 113.02,112.87 112.3,112.87 111.81,113.36 109.66,113.36 109.13,112.83 109.13,105.47 108.58,104.92 108.58,96.66 107.64,95.73 107.04,95.73 106.07,94.76 106.07,93.45 103.53,90.91 102.35,90.91 101.54,90.1 100.69,90.1 98.92,88.33 96.09,88.33 94.57,89.85 88.03,89.85 80.83,82.64 61.41,82.64 60.7,83.35 60.7,83.88 CG883.1
PEG_RXP6_C: length 13.7
  TOP w0.105: v2(58.32,96.32) 58.65,96.65 UG1.BG32
  BOTTOM w0.102: 58.56,92.42 58.56,92.45 58.59,92.48 58.59,92.77 58.24,93.12 58.24,95.07 57.89,95.42 57.89,95.89 v2(58.32,96.32)
  BOTTOM w0.14: 58.56,92.42 58.56,88.73 59.16,88.12 59.16,87.25 60.66,85.75 60.66,84.55 CG883.2
PEG_RXP7: length 79.6
  TOP w0.095: U3.D17 121.54,116.46 121.45,116.54 121.3,116.54 121.21,116.46 v1(121.21,115.9)
  BOTTOM w0.102: v1(121.21,115.9) 121.33,115.78 121.33,115.66 121.21,115.55 120.85,115.55 120.78,115.48 119.51,115.48 119.12,115.09 118.14,115.09 117.76,115.47 116.71,115.47 116.68,115.5 116.66,115.5
  BOTTOM w0.14: 116.66,115.5 112.76,115.5 112.15,114.9 109.6,114.9 108.04,113.34 108.04,105.92 107.46,105.34 107.46,97.68 104.83,95.04 104.83,93.73 103.81,92.71 101.77,92.71 98.47,89.41 96.53,89.41 95.01,90.93 87.59,90.93 83.64,86.99 79.83,86.99 76.57,83.73 68.84,83.73 68.41,84.17 67.97,84.17 CG882.1
PEG_RXP7_C: length 21.4
  TOP w0.102: v2(58.98,97.02) 58.91,96.95 58.59,96.95 58.48,97.06 58.48,97.25 58.58,97.35 UG1.BF32
  BOTTOM w0.102: v2(58.98,97.02) 58.98,97.15 58.87,97.25 58.72,97.25 58.59,97.12 58.59,96.87 58.97,96.49 58.97,93.76 60,92.73 60,92.48 60.03,92.45 60.03,92.42
  BOTTOM w0.14: 60.03,92.42 60.03,88.83 60.24,88.61 60.24,87.7 62.45,85.49 62.45,84.34 62.97,83.82 66.48,83.82 66.63,83.97 67.25,83.97 67.39,84.11 CG882.2
PEG_RXP8: length 46
  TOP w0.089: U3.E18 122.14,117.03 122.14,116.79 122.25,116.68 v1(122.51,116.68)
  BOTTOM w0.102: 116.66,116.04 116.68,116.04 116.67,116.06 116.69,116.08 117.96,116.08 118.12,115.91 119.55,115.91 120.02,116.38 121.61,116.38 122.1,116.86 122.33,116.86 v1(122.51,116.68)
  BOTTOM w0.14: CG881.1 98.3,90.25 98.51,90.25 101.52,93.26 103.11,93.26 103.82,93.97 103.82,94.81 106.87,97.86 106.87,106.97 107.49,107.59 107.49,113.61 109.32,115.45 111.91,115.45 112.51,116.04 116.66,116.04
PEG_RXP8_C: length 52.3
  TOP w0.105: UG1.BF33 v2(59.68,97.02)
  BOTTOM w0.102: 60.64,92.42 60.64,92.45 60.67,92.48 60.67,92.6 59.28,94 59.28,96.63 v2(59.68,97.02)
  BOTTOM w0.14: 60.64,92.42 60.64,91.58 60.96,91.26 60.96,87.75 63.82,84.9 76.79,84.9 79.52,87.62 83.5,87.62 87.36,91.48 89.09,91.48 89.7,92.09 94.63,92.09 96.62,90.1 97.42,90.1 CG881.2
PEG_RXP9: length 44.9
  TOP w0.095: v1(121.86,117.47) 122.19,117.8 U3.E19
  BOTTOM w0.102: 117.27,117.05 117.3,117.05 117.33,117.09 117.95,117.09 118.58,116.46 119.2,116.46 119.6,116.85 121.36,116.85 121.65,117.15 121.65,117.27 v1(121.86,117.47)
  BOTTOM w0.14: CG879.1 98.26,91.72 98.81,91.72 101.16,94.07 101.93,94.07 106.03,98.17 106.03,107.55 106.67,108.2 106.67,114.08 109.76,117.17 111.17,117.17 111.29,117.29 114.46,117.29 114.7,117.05 117.27,117.05
PEG_RXP9_C: length 49.9
  TOP w0.105: UG1.BG35 60.75,96.65 v2(60.43,96.33)
  BOTTOM w0.102: v2(60.43,96.33) 59.99,95.89 59.99,95.35 60.34,94.99 60.34,93.8 61.52,92.63 61.52,92.48 61.48,92.45 61.48,92.42
  BOTTOM w0.14: CG879.2 97.44,91.6 96.27,91.6 94.97,92.9 89.36,92.9 88.76,92.29 87.03,92.29 83.17,88.43 79.16,88.43 76.44,85.71 64.29,85.71 62.17,87.83 62.17,89.7 61.78,90.08 61.78,91.59 61.48,91.89 61.48,92.42
PEG_RXP10: length 45.2
  TOP w0.089: U3.E20 122.1,118.56 122.1,118.35 122.19,118.26 v1(122.51,118.26)
  BOTTOM w0.102: v1(122.51,118.26) 122.01,118.26 121.65,117.9 120.14,117.9 119.73,117.49 118.48,117.49 118.07,117.9 117.87,117.9 117.84,117.87 117.83,117.87
  BOTTOM w0.14: CG870.1 98.23,93.33 99.26,93.33 100.82,94.88 101.6,94.88 105.2,98.49 105.2,108.25 105.85,108.89 105.85,114.43 109.41,117.99 110.84,117.99 110.96,118.11 115.15,118.11 115.38,117.87 117.83,117.87
PEG_RXP10_C: length 50
  TOP w0.102: v2(60.42,97.68) 60.56,97.68 60.75,97.49 UG1.BF35
  BOTTOM w0.102: v2(60.42,97.68) 60.59,97.84 60.73,97.84 60.88,97.7 60.88,94.03 62.36,92.55 62.36,92.48 62.33,92.45 62.33,92.42
  BOTTOM w0.14: CG870.2 97.31,93.32 96.41,93.32 96.01,93.71 89.03,93.71 88.53,93.21 84.82,93.21 80.86,89.25 78.81,89.25 76.08,86.52 64.69,86.52 63.37,87.84 63.37,91.16 62.33,92.2 62.33,92.42
PEG_RXP11: length 87.6
  TOP w0.095: v1(121.86,119.05) 122.19,119.37 U3.E21
  BOTTOM w0.102: v1(121.86,119.05) 121.19,118.37 119.58,118.37 119.25,118.04 118.61,118.04 117.91,118.75 117.84,118.75 117.81,118.72 117.79,118.72
  BOTTOM w0.14: CG876.1 63.25,92.65 63.39,92.51 63.39,92.29 64.67,91.01 65.3,91.01 65.79,90.52 65.79,88.13 66.58,87.34 75.75,87.34 78.46,90.06 80.52,90.06 85.4,94.93 90.75,94.93 91.16,94.52 99.31,94.52 100.48,95.7 101.23,95.7 103.57,98.04 103.57,98.79 104.37,99.58 104.37,114.81 109.73,120.16 110.38,120.16 110.57,119.97 114.63,119.97 115.88,118.72 117.79,118.72
PEG_RXP11_C: length 6.1
  TOP w0.105: UG1.BF36 61.45,97.35 v2(61.77,97.03)
  BOTTOM w0.102: CG876.2 63.25,93.24 63.25,93.52 63.08,93.69 61.86,93.69 61.39,94.17 61.39,96.64 v2(61.77,97.03)
PEG_RXP12: length 85
  TOP w0.089: U3.E22 122.19,120.16 v1(122.51,119.84)
  BOTTOM w0.102: v1(122.51,119.84) 122.51,119.93 122.39,120.06 122.15,120.06 121.6,119.51 120.23,119.51 119.86,119.13 118.37,119.13 117.93,119.57 117.84,119.57 117.81,119.54 117.79,119.54
  BOTTOM w0.14: 117.79,119.54 116.52,119.54 115.27,120.78 110.93,120.78 110.7,121.01 109.42,121.01 103.55,115.14 103.55,99.91 102.74,99.1 102.74,98.36 100.89,96.51 100.15,96.51 99,95.37 91.49,95.37 91.11,95.75 83,95.75 76.14,88.88 70.5,88.88 69.74,89.64 69.74,90.69 69.49,90.94 68.43,90.94 68.28,91.09 66.37,91.09 65.63,91.83 65.29,91.83 64.87,92.24 64.87,92.49 CG874.1
PEG_RXP12_C: length 5.6
  TOP w0.105: UG1.BG38 v2(62.51,96.31)
  BOTTOM w0.102: v2(62.51,96.31) 62.17,95.97 62.17,95.24 63.61,93.79 64.61,93.79 64.85,93.55 64.85,93.24 CG874.2
PEG_RXP13: length 81.9
  TOP w0.095: U3.E23 122.19,120.95 v1(121.86,120.62)
  BOTTOM w0.102: 117.79,120.46 117.8,120.44 117.85,120.44 118.68,119.61 119.51,119.61 119.85,119.95 121.42,119.95 121.64,120.17 121.64,120.4 v1(121.86,120.62)
  BOTTOM w0.14: 117.79,120.46 115.29,122.95 110.17,122.95 102.73,115.51 102.73,100.24 101.91,99.42 101.91,98.7 100.57,97.36 99.85,97.36 98.68,96.2 95.03,96.2 94.64,96.59 82.69,96.59 76.78,90.67 73.34,90.67 72.27,91.75 69.16,91.75 69.01,91.9 66.94,91.9 66.64,92.2 66.64,92.37 CG872.1
PEG_RXP13_C: length 9
  TOP w0.102: UG1.BF38 62.85,97.6 62.75,97.7 v2(62.55,97.7)
  BOTTOM w0.102: v2(62.55,97.7) 62.73,97.88 62.87,97.88 62.99,97.77 62.99,95.56 63.34,95.21 63.34,94.7 63.79,94.25 65.11,94.25 65.72,93.64 66.46,93.64 66.78,93.32 66.78,93.2 66.68,93.1 CG872.2
PEG_RXP14: length 79.2
  TOP w0.095: U3.E24 122.12,121.87 121.96,121.87 121.86,121.77 v1(121.86,121.41)
  BOTTOM w0.102: v1(121.86,121.41) 122.09,121.63 122.09,121.78 121.98,121.88 121.63,121.88 120.91,121.16 118.34,121.16 118.13,121.37 118.09,121.37 118.07,121.39
  BOTTOM w0.14: 118.07,121.39 115.7,123.76 109.78,123.76 101.89,115.88 101.89,100.6 98.69,97.4 87.78,97.4 87.59,97.59 82.43,97.59 76.33,91.49 73.68,91.49 72.6,92.56 69.54,92.56 69.11,93 68.97,93 68.83,92.86 CG877.1
PEG_RXP14_C: length 8.1
  TOP w0.105: UG1.BF39 v2(63.88,97.02)
  BOTTOM w0.102: v2(63.88,97.02) 63.5,96.65 63.5,95.89 64.2,95.19 64.84,95.19 65.88,94.15 66.83,94.15 67.56,93.42 67.56,93.19 67.93,92.81 68.24,92.81 CG877.2
PEG_RXP15: length 81
  TOP w0.089: v1(121.86,122.98) 122.19,122.66 U3.E25
  BOTTOM w0.102: v1(121.86,122.98) 121.64,122.76 121.64,122.59 121.36,122.31 119.28,122.31 119.25,122.28 119.22,122.28
  BOTTOM w0.14: CG866.1 67.56,94.89 67.7,95.03 68.23,95.03 69.88,93.37 72.94,93.37 74.02,92.3 75.89,92.3 82.03,98.44 87.92,98.44 88.15,98.21 98.35,98.21 101.08,100.94 101.08,116.24 108.86,124.02 108.86,124.37 109.45,124.96 111.45,124.96 112.1,125.62 115.05,125.62 118.39,122.28 119.22,122.28
PEG_RXP15_C: length 3.6
  TOP w0.105: UG1.BH41 64.66,95.95 v2(64.51,95.8)
  BOTTOM w0.102: v2(64.51,95.8) 64.66,95.95 64.98,95.95 65.73,95.2 66.39,95.2 66.51,95.08 66.86,95.08 CG866.2
PEG_TXN0: length 85.7
  TOP w0.105: v1(55.16,88.92) 54.97,88.74 54.82,88.74 54.71,88.85 54.71,91.83 55.69,92.81 55.69,93.5 55.52,93.68 55.52,93.77 55.49,93.8 55.48,93.99 55.36,94.13 UG1.BK27
  TOP w0.14: C90.1 112.76,107.75 112.54,107.75 112.24,107.45 111.92,107.45 v1(111.77,107.6)
  IN1 w0.086: v1(111.77,107.6) 111.58,107.4 110.97,107.4 110.13,106.56 110.13,105.39 109.07,104.33 109.07,96.11 108.18,95.22 108.18,94.81 107.32,93.96 107.32,93.53 102.01,88.21 88.2,88.21 81.49,81.5 61.28,81.5 55.77,87.01 55.77,88.46 55.51,88.72 55.36,88.72 v1(55.16,88.92)
PEG_TXN1: length 86.9
  TOP w0.105: UG1.BL29 56.42,93.58 56.21,93.36 56.21,93.24 56.21,92.65 55.88,92.32 55.88,90.73 55.65,90.5 55.44,90.5 v1(55.17,90.24)
  TOP w0.14: v1(111.76,108.25) 111.97,108.46 112.55,108.46 112.96,108.87 113.93,108.87 113.98,108.82 114.04,108.76 C89.1
  IN1 w0.086: v1(111.76,108.25) 111.76,108.41 111.64,108.52 111.47,108.52 111.2,108.25 110.34,108.25 109.74,107.65 109.74,105.66 108.68,104.6 108.68,96.28 107.78,95.38 107.78,94.98 106.92,94.11 106.92,93.68 101.85,88.6 88.04,88.6 81.33,81.9 61.44,81.9 56.17,87.17 56.17,89.37 55.81,89.72 55.81,90.37 55.65,90.53 55.33,90.53 55.17,90.37 v1(55.17,90.24)
PEG_TXN2: length 85.2
  TOP w0.105: UG1.BM30 57.09,92.99 57.09,91.35 56.94,91.2 56.94,91.05 56.97,91.02 56.85,90.9 56.49,90.9 v1(56.43,90.84)
  TOP w0.14: C86.1 112.86,110.39 112.68,110.39 111.96,109.67 111.53,109.67 111.39,109.81 111.39,109.95 v1(111.53,110.09)
  IN1 w0.086: v1(56.43,90.84) 56.68,91.08 56.88,91.08 57.08,90.88 57.08,90.13 56.75,89.8 56.75,87.37 61.67,82.45 81.1,82.45 87.8,89.16 101.61,89.16 106.23,93.78 106.23,95.26 106.81,95.84 107.45,95.84 108.12,96.51 108.12,104.83 109.18,105.89 109.18,107.93 110.55,109.3 111.07,109.3 111.32,109.55 111.32,109.88 v1(111.53,110.09)
PEG_TXN3: length 86
  TOP w0.105: UG1.BK30 57.25,94.3 57.6,93.95 57.6,93.59 57.8,93.39 57.8,91.04 57.52,90.76 57.52,88.34 57.63,88.24 57.9,88.24 v1(58.08,88.42)
  TOP w0.14: C85.1 113.91,111.2 113.69,111.2 113.56,111.07 112.51,111.07 v1(112.35,110.9)
  IN1 w0.086: v1(112.35,110.9) 112.12,111.13 110.91,111.13 110.34,110.56 110.34,109.88 108.62,108.16 108.62,106.18 107.56,105.12 107.56,97.38 105.59,95.41 105.59,93.95 101.36,89.72 87.41,89.72 80.7,83.01 61.91,83.01 57.37,87.55 57.37,87.95 57.63,88.21 57.88,88.21 v1(58.08,88.42)
PEG_TXN4: length 84.9
  TOP w0.105: v1(59.29,90.69) 59.07,90.48 58.59,90.48 58.32,90.75 58.32,93.36 58.53,93.58 58.53,93.73 UG1.BL32
  TOP w0.14: v1(110.3,112.89) 110.41,112.77 112.71,112.77 C82.1
  IN1 w0.086: v1(59.29,90.69) 58.93,90.34 58.83,90.34 58.62,90.13 58.62,88.85 59.18,88.28 59.18,86.75 62.37,83.56 77.01,83.56 80.77,87.33 83.17,87.33 86.12,90.27 99.69,90.27 102.05,92.63 103.42,92.63 104.97,94.18 104.97,95.57 107.01,97.61 107.01,107.36 109.77,110.13 109.77,110.78 110.96,111.97 110.96,112.46 110.78,112.65 110.54,112.65 v1(110.3,112.89)
PEG_TXN5: length 82.8
  TOP w0.105: UG1.BM33 59.2,93.15 59.06,93 59.06,92.5 59.99,91.57 59.99,90.28 60.11,90.16 60.23,90.16 v1(60.49,90.42)
  TOP w0.14: C81.1 113.96,113.69 113.81,113.69 113.68,113.55 113.02,113.55 112.87,113.7 112.68,113.7 v1(112.59,113.61)
  IN1 w0.086: v1(60.49,90.42) 60.16,90.09 59.99,90.09 59.78,89.88 59.78,87.75 62.83,84.71 76.57,84.71 79.75,87.88 82.89,87.88 85.83,90.83 99.46,90.83 101.82,93.19 102.68,93.19 103.69,94.2 103.69,95.08 106.45,97.84 106.45,107.59 109.19,110.33 109.19,113.04 109.72,113.57 112.14,113.57 112.29,113.72 112.49,113.72 v1(112.59,113.61)
PEG_TXN6: length 83.8
  TOP w0.105: UG1.BK33 59.35,94.55 59.68,93.99 59.68,93.61 59.92,93.38 59.92,92.53 61.12,91.33 61.12,88.75 61.31,88.55 61.47,88.55 v1(61.7,88.78)
  TOP w0.14: C78.1 112.82,115.43 111.39,115.43 110.78,114.82 110.78,114.36 v1(110.59,114.16)
  IN1 w0.086: v1(110.59,114.16) 110.81,114.38 110.81,114.59 110.58,114.82 109.92,114.82 108.63,113.52 108.63,110.56 105.9,107.82 105.9,98.07 99.39,91.56 95.75,91.56 95.11,92.2 86.08,92.2 84.08,90.2 82.65,90.2 81.1,88.66 79.73,88.66 76.34,85.26 63.4,85.26 60.88,87.78 60.88,88.13 61.12,88.37 61.28,88.37 v1(61.7,88.78)
PEG_TXN7: length 82.9
  TOP w0.105: UG1.BL35 60.59,93.69 60.58,93.56 60.42,93.4 60.42,92.75 61.66,91.51 61.66,90.5 62.36,89.8 62.36,88.91 62.59,88.68 62.79,88.68 62.9,88.78 v1(62.9,89.01)
  TOP w0.14: C77.1 114.04,116.35 113.91,116.48 113.52,116.48 113.11,116.08 112.21,116.08 111.95,116.34 111.74,116.34 v1(111.58,116.18)
  IN1 w0.086: v1(62.9,89.01) 62.9,88.79 62.75,88.64 62.49,88.64 62.2,88.35 62.2,87.62 64,85.82 75.26,85.82 78.8,89.36 80.55,89.36 83.95,92.76 95.34,92.76 95.99,92.12 99.15,92.12 105.34,98.3 105.34,108.06 108.07,110.79 108.07,114.16 110.51,116.6 110.98,116.6 111.16,116.43 111.33,116.43 v1(111.58,116.18)
PEG_TXN8: length 81.7
  TOP w0.105: v1(62.64,90.99) 62.64,90.78 62.49,90.63 62.3,90.63 62.15,90.78 62.15,91.74 61.06,92.82 61.06,93.13 61.18,93.25 61.35,93.25 UG1.BM36
  TOP w0.14: C75.1 112.76,117.68 111.8,117.68 111.08,118.4 111.08,118.84 110.94,118.98 110.85,118.98 v1(110.71,118.84)
  IN1 w0.086: v1(110.71,118.84) 110.71,119 110.82,119.11 111.05,119.11 111.16,119 111.16,118.48 107.35,114.67 107.35,111.08 104.62,108.36 104.62,98.6 99.5,93.48 83.48,93.48 80.32,90.32 78.75,90.32 74.96,86.54 64.76,86.54 63.64,87.66 63.64,90.29 63.3,90.64 62.75,90.64 62.64,90.75 v1(62.64,90.99)
PEG_TXN9: length 82.3
  TOP w0.105: v1(64.1,89.61) 63.94,89.44 63.64,89.44 63.54,89.55 63.54,91.05 62.02,92.57 62.02,93.44 61.78,93.69 61.78,93.99 UG1.BK36
  TOP w0.14: v1(112.5,119.5) 112.52,119.5 112.8,119.21 112.91,119.21 113.09,119.03 113.46,119.03 113.62,119.19 113.75,119.19 114.04,119.48 C72.1
  IN1 w0.086: v1(112.5,119.5) 112.32,119.31 112.2,119.31 111.24,120.27 109.77,120.27 109.3,119.81 109.3,117.41 106.76,114.87 106.76,111.29 104.06,108.59 104.06,99.57 103.55,99.05 103.55,98.32 99.27,94.04 81.67,94.04 74.73,87.1 65.25,87.1 64.7,87.65 64.7,89.13 64.44,89.39 64.32,89.39 v1(64.1,89.61)
PEG_TXN10: length 81.6
  TOP w0.105: UG1.BL38 63.17,93.85 63.24,93.78 63.24,93.62 63.14,93.51 62.72,93.51 62.51,93.3 62.51,92.79 64.75,90.55 64.75,89.56 64.85,89.45 65.15,89.45 65.25,89.56 v1(65.25,89.69)
  TOP w0.14: v1(110.43,121.75) 110.66,121.52 110.66,120.9 111.22,120.34 112.89,120.34 113.03,120.2 C71.1
  IN1 w0.086: v1(110.43,121.75) 110.7,121.48 110.7,121.32 110.39,121.01 109.55,121.01 108.74,120.2 108.74,117.64 106.2,115.1 106.2,111.51 103.51,108.82 103.51,99.92 102.99,99.41 102.99,98.55 99.04,94.6 91.02,94.6 90.48,95.13 81.73,95.13 74.25,87.66 66.55,87.66 65.98,88.23 65.98,89.18 65.78,89.38 65.56,89.38 v1(65.25,89.69)
PEG_TXN11: length 79.8
  TOP w0.105: v1(66.52,89.68) 66.52,89.51 66.32,89.31 66.14,89.31 65.89,89.56 65.89,90.89 65.53,91.25 64.75,91.25 63.32,92.69 63.32,92.92 UG1.BM39
  TOP w0.14: v1(112.68,122.16) 112.94,121.91 113.9,121.91 114.04,122.05 C68.1
  IN1 w0.086: v1(66.52,89.68) 66.82,89.39 67,89.39 67.18,89.2 67.18,88.58 67.54,88.23 74,88.23 81.54,95.76 90.75,95.76 91.36,95.15 98.81,95.15 102.43,98.78 102.43,99.68 102.95,100.19 102.95,109.07 105.64,111.77 105.64,115.33 108.13,117.81 108.13,121.4 109.15,122.41 111.31,122.41 111.64,122.08 112.23,122.08 112.38,121.93 112.56,121.93 112.68,122.05 v1(112.68,122.16)
PEG_TXN12: length 80.7
  TOP w0.105: v1(67.65,89.98) 67.48,89.81 67.25,89.81 67.15,89.92 67.15,90.76 66.54,91.37 66.15,91.37 65.76,91.76 64.99,91.76 64.09,92.66 64.09,93.49 63.88,93.7 63.88,93.99 UG1.BK39
  TOP w0.14: C67.1 112.82,122.83 112.49,122.83 112.37,122.95 110.97,122.95 110.52,123.4 110.52,124.3 v1(110.33,124.49)
  IN1 w0.086: v1(110.33,124.49) 110.56,124.26 110.56,124.15 110.04,123.63 109.37,123.63 107.42,121.67 107.42,118.04 103.83,114.45 103.83,110.74 102.39,109.31 102.39,100.45 101.88,99.94 101.88,99.01 98.58,95.71 91.64,95.71 90.98,96.37 81.33,96.37 73.75,88.79 68.55,88.79 68.3,89.05 68.3,89.52 68.11,89.7 67.92,89.7 v1(67.65,89.98)
PEG_TXN13: length 80
  TOP w0.105: UG1.BL41 65.08,93.98 65.23,93.98 65.31,93.9 65.31,93.58 65.2,93.48 64.75,93.48 64.7,93.42 64.61,93.34 64.61,92.91 65.31,92.22 65.99,92.22 66.37,91.84 66.87,91.84 67.19,91.51 67.91,91.51 68.27,91.15 68.27,89.92 68.37,89.82 68.49,89.82 v1(68.75,90.08)
  TOP w0.14: v1(112.36,125.15) 112.6,124.91 112.74,124.91 113.26,124.39 113.76,124.39 C63.1
  IN1 w0.086: v1(112.36,125.15) 112.36,124.98 112.27,124.89 112.05,124.89 111.86,125.08 109.46,125.08 106.76,122.38 106.76,118.17 103.05,114.46 103.05,110.75 101.83,109.53 101.83,100.71 98.79,97.67 98.79,96.86 98.39,96.46 94.38,96.46 93.85,96.99 81.14,96.99 73.49,89.35 70.25,89.35 69.82,89.78 69.04,89.78 v1(68.75,90.08)
PEG_TXN14: length 75.7
  TOP w0.105: v1(70.47,90.68) 70.22,90.43 70.07,90.43 69.96,90.54 69.96,90.86 69.3,91.52 68.63,91.52 68.14,92.01 67.42,92.01 67.1,92.33 66.62,92.33 66.16,92.78 65.66,92.78 65.54,92.9 65.54,93.04 UG1.BM42
  TOP w0.14: C61.1 113.03,125.37 112.74,125.66 111.9,125.66 111.59,125.96 111.59,126.15 v1(111.32,126.42)
  IN1 w0.086: v1(70.47,90.68) 70.76,90.39 71.4,90.39 71.88,89.91 73.14,89.91 80.84,97.6 97.9,97.6 101.28,100.97 101.28,109.76 102.47,110.96 102.47,114.67 106.13,118.32 106.13,122.53 109.26,125.67 111.27,125.67 111.59,125.99 111.59,126.15 v1(111.32,126.42)
PEG_TXN15: length 75.8
  TOP w0.105: UG1.BK42 66.01,93.93 66.01,93.6 66.78,92.83 67.25,92.83 67.64,92.43 68.38,92.43 68.82,91.99 70.55,91.99 70.9,91.64 70.9,91.11 71.14,90.87 71.69,90.87 v1(71.95,91.13)
  TOP w0.14: C57.1 113.85,127 113.46,127 v1(113.33,127.13)
  IN1 w0.086: v1(71.95,91.13) 72.18,90.9 72.49,90.9 73.33,91.75 74.2,91.75 80.61,98.16 97.63,98.16 100.7,101.23 100.7,109.97 101.91,111.18 101.91,115.09 105.38,118.56 105.38,122.6 109.88,127.11 112.79,127.11 113.02,126.88 113.07,126.88 v1(113.33,127.13)
PEG_TXP0: length 85.7
  TOP w0.105: UG1.BL27 55.31,93.69 55.31,93.59 55.49,93.42 55.49,92.9 54.5,91.91 54.5,88.77 54.74,88.53 55.04,88.53 55.16,88.41 v1(55.16,88.26)
  TOP w0.14: C91.1 112.79,107.48 112.65,107.48 112.35,107.18 112.02,107.18 v1(111.77,106.93)
  IN1 w0.086: v1(111.77,106.93) 111.77,107.07 111.6,107.24 111.04,107.24 110.29,106.49 110.29,105.32 109.23,104.26 109.23,96.04 108.34,95.15 108.34,94.75 107.49,93.89 107.49,93.46 102.08,88.05 88.27,88.05 81.56,81.34 61.21,81.34 55.61,86.94 55.61,88.39 55.45,88.55 55.31,88.55 55.16,88.4 v1(55.16,88.26)
PEG_TXP1: length 86.9
  TOP w0.105: v1(55.17,90.97) 55.44,90.71 55.57,90.71 55.67,90.82 55.67,92.4 56,92.73 56,93.24 56,93.45 56.22,93.67 56.22,93.99 UG1.BK29
  TOP w0.14: C88.1 113.89,109.13 112.85,109.13 112.44,108.73 111.92,108.73 v1(111.75,108.9)
  IN1 w0.086: v1(55.17,90.97) 55.45,90.69 55.72,90.69 55.98,90.43 55.98,89.79 56.33,89.43 56.33,87.24 61.51,82.06 81.26,82.06 87.97,88.77 101.78,88.77 106.75,93.75 106.75,94.18 107.62,95.05 107.62,95.45 108.51,96.34 108.51,104.67 109.57,105.73 109.57,107.72 110.27,108.41 111.13,108.41 111.4,108.68 111.53,108.68 v1(111.75,108.9)
PEG_TXP2: length 85.1
  TOP w0.105: UG1.BM29 56.89,92.81 56.89,91.44 56.78,91.33 56.67,91.33 v1(56.43,91.57)
  TOP w0.14: C87.1 113.03,109.99 112.89,110.13 112.79,110.13 112.07,109.4 111.42,109.4 111.12,109.71 111.12,109.85 110.92,110.05 v1(110.86,110.05)
  IN1 w0.086: v1(110.86,110.05) 110.92,110.05 111.15,109.81 111.15,109.62 111,109.46 110.48,109.46 109.02,108 109.02,105.96 107.96,104.9 107.96,96.58 107.38,96 106.74,96 106.07,95.33 106.07,93.85 101.55,89.33 87.74,89.33 81.03,82.62 61.74,82.62 56.91,87.44 56.91,89.73 57.24,90.07 57.24,90.95 56.95,91.25 56.75,91.25 v1(56.43,91.57)
PEG_TXP3: length 86
  TOP w0.105: UG1.BL30 57.19,93.85 57.1,93.76 57.1,93.62 57.21,93.51 57.39,93.51 57.6,93.3 57.6,91.12 57.32,90.84 57.32,88.25 57.54,88.03 57.96,88.03 58.08,87.9 v1(58.08,87.68)
  TOP w0.14: v1(112.39,111.55) 112.6,111.33 113.45,111.33 113.58,111.46 113.91,111.46 114.04,111.6 C84.1
  IN1 w0.086: v1(58.08,87.68) 58.08,87.9 57.94,88.05 57.7,88.05 57.53,87.88 57.53,87.62 61.98,83.17 80.64,83.17 87.34,89.88 101.29,89.88 105.43,94.02 105.43,95.48 107.4,97.45 107.4,105.19 108.46,106.25 108.46,108.23 110.18,109.95 110.18,110.63 110.84,111.3 112.28,111.3 112.39,111.4 v1(112.39,111.55)
PEG_TXP4: length 85
  TOP w0.105: v1(59.29,89.96) 58.98,90.27 58.51,90.27 58.11,90.67 58.11,93.45 58.32,93.66 58.32,94.22 UG1.BK32
  TOP w0.14: C83.1 112.85,112.51 110.57,112.51 v1(110.3,112.24)
  IN1 w0.086: v1(110.3,112.24) 110.54,112.48 110.71,112.48 110.8,112.4 110.8,112.04 109.61,110.85 109.61,110.2 106.84,107.43 106.84,97.68 104.81,95.64 104.81,94.25 103.35,92.8 101.98,92.8 99.62,90.44 86.05,90.44 83.1,87.49 80.7,87.49 76.94,83.73 62.44,83.73 59.35,86.82 59.35,88.35 58.78,88.92 58.78,90.06 58.89,90.17 59.07,90.17 v1(59.29,89.96)
PEG_TXP5: length 82.8
  TOP w0.105: UG1.BM32 58.65,93.15 58.85,92.95 58.85,92.41 59.78,91.48 59.78,90.19 60.02,89.95 60.23,89.95 v1(60.49,89.69)
  TOP w0.14: C80.1 114.04,114.3 113.57,113.82 113.13,113.82 112.69,114.26 v1(112.59,114.26)
  IN1 w0.086: v1(112.59,114.26) 112.07,113.74 109.65,113.74 109.02,113.11 109.02,110.4 106.29,107.66 106.29,97.91 103.52,95.15 103.52,94.27 102.61,93.35 101.75,93.35 99.39,90.99 85.76,90.99 82.82,88.05 79.68,88.05 76.5,84.87 62.9,84.87 59.95,87.82 59.95,89.81 60.06,89.92 60.26,89.92 v1(60.49,89.69)
PEG_TXP6: length 83.8
  TOP w0.105: UG1.BL33 59.06,93.85 58.95,93.74 58.95,93.54 59.04,93.46 59.54,93.46 59.71,93.29 59.71,92.44 60.91,91.24 60.91,88.67 61.23,88.35 61.59,88.35 61.7,88.24 v1(61.7,88.05)
  TOP w0.14: C79.1 113.03,115.03 112.89,115.17 111.5,115.17 111.05,114.71 111.05,114.3 111.19,114.16 v1(111.27,114.16)
  IN1 w0.086: v1(61.7,88.05) 61.55,88.21 61.19,88.21 61.04,88.06 61.04,87.85 63.47,85.43 76.27,85.43 79.66,88.82 81.03,88.82 82.58,90.37 84.02,90.37 86.02,92.37 95.18,92.37 95.82,91.73 99.32,91.73 105.73,98.14 105.73,107.89 108.46,110.63 108.46,113.59 109.85,114.98 110.65,114.98 110.97,114.66 110.97,114.35 111.15,114.16 v1(111.27,114.16)
PEG_TXP7: length 82.9
  TOP w0.105: v1(62.9,88.27) 62.7,88.47 62.5,88.47 62.15,88.82 62.15,89.72 61.46,90.41 61.46,91.43 60.22,92.67 60.22,93.49 60.38,93.65 60.4,93.95 60.42,93.98 60.6,94.29 UG1.BK35
  TOP w0.14: C76.1 113.89,116.75 113.4,116.75 113,116.35 112.32,116.35 112.06,116.61 111.79,116.61 v1(111.58,116.83)
  IN1 w0.086: v1(111.58,116.83) 111.34,116.59 111.23,116.59 111.05,116.77 110.45,116.77 107.91,114.23 107.91,110.85 105.17,108.12 105.17,98.37 99.09,92.28 96.05,92.28 95.41,92.92 83.89,92.92 80.48,89.52 78.73,89.52 75.19,85.98 64.07,85.98 62.36,87.69 62.36,88.28 62.56,88.48 62.69,88.48 v1(62.9,88.27)
PEG_TXP8: length 81.7
  TOP w0.105: UG1.BM35 60.86,93.04 60.86,92.73 61.94,91.65 61.94,90.7 62.21,90.43 62.47,90.43 v1(62.64,90.25)
  TOP w0.14: v1(110.71,119.49) 110.96,119.24 111.05,119.24 111.35,118.95 111.35,118.51 111.91,117.95 112.8,117.95 C74.1
  IN1 w0.086: v1(62.64,90.25) 62.86,90.47 63.23,90.47 63.48,90.22 63.48,87.6 64.7,86.38 75.03,86.38 78.82,90.16 80.39,90.16 83.54,93.32 99.56,93.32 104.78,98.53 104.78,108.29 107.51,111.01 107.51,114.6 111.33,118.41 111.33,119.07 111.12,119.27 110.93,119.27 v1(110.71,119.49)
PEG_TXP9: length 82.3
  TOP w0.105: v1(64.1,88.88) 64.1,89.07 63.94,89.24 63.56,89.24 63.33,89.46 63.33,90.97 61.81,92.49 61.81,93.36 61.64,93.53 61.49,93.53 61.38,93.63 61.38,93.78 UG1.BL36
  TOP w0.14: v1(112.5,118.85) 112.6,118.94 112.79,118.94 112.98,118.76 113.57,118.76 113.73,118.92 113.93,118.92 C73.1
  IN1 w0.086: v1(112.5,118.85) 112.5,118.95 112.31,119.15 112.13,119.15 111.17,120.11 109.84,120.11 109.47,119.74 109.47,117.34 106.93,114.8 106.93,111.22 104.23,108.52 104.23,99.5 103.71,98.99 103.71,98.25 99.33,93.87 81.74,93.87 74.8,86.93 65.18,86.93 64.53,87.58 64.53,89.07 64.38,89.22 64.2,89.22 64.1,89.13 v1(64.1,88.88)
PEG_TXP10: length 81.6
  TOP w0.105: UG1.BK38 62.5,94.2 62.5,93.59 62.3,93.39 62.3,92.7 64.54,90.46 64.54,89.47 64.77,89.25 64.96,89.25 v1(65.25,88.96)
  TOP w0.14: C70.1 112.79,120.6 111.33,120.6 110.92,121.01 110.92,121.59 v1(111.08,121.75)
  IN1 w0.086: v1(65.25,88.96) 65.51,89.21 65.72,89.21 65.82,89.11 65.82,88.16 66.48,87.49 74.32,87.49 81.79,94.97 90.42,94.97 90.95,94.43 99.11,94.43 103.16,98.48 103.16,99.34 103.67,99.85 103.67,108.75 106.37,111.45 106.37,115.03 108.91,117.57 108.91,120.13 109.62,120.85 110.46,120.85 110.86,121.25 110.86,121.53 v1(111.08,121.75)
PEG_TXP11: length 79.9
  TOP w0.105: v1(66.52,88.95) 66.37,89.1 66.05,89.1 65.68,89.47 65.68,90.8 65.44,91.04 64.67,91.04 63.11,92.6 63.11,92.89 UG1.BM38
  TOP w0.14: C69.1 113.75,121.64 112.81,121.64 v1(112.68,121.52)
  IN1 w0.086: v1(112.68,121.52) 112.43,121.76 112.31,121.76 112.16,121.91 111.57,121.91 111.25,122.24 109.21,122.24 108.3,121.33 108.3,117.75 105.81,115.26 105.81,111.7 103.11,109.01 103.11,100.13 102.6,99.61 102.6,98.71 98.88,94.99 91.29,94.99 90.68,95.6 81.61,95.6 74.07,88.06 67.47,88.06 67.02,88.51 67.02,89.13 66.93,89.22 66.79,89.22 v1(66.52,88.95)
PEG_TXP12: length 80.7
  TOP w0.105: v1(67.65,89.24) 67.65,89.44 67.49,89.6 67.17,89.6 66.94,89.83 66.94,90.68 66.46,91.16 66.07,91.16 65.67,91.56 64.91,91.56 63.88,92.58 63.88,93.41 63.78,93.51 63.57,93.51 63.46,93.62 63.46,93.76 UG1.BL39
  TOP w0.14: C65.1 113.03,123.21 112.91,123.09 112.6,123.09 112.48,123.22 111.08,123.22 110.79,123.51 110.79,124.31 v1(110.98,124.49)
  IN1 w0.086: v1(67.65,89.24) 67.94,89.54 68.05,89.54 68.13,89.45 68.13,88.98 68.49,88.62 73.82,88.62 81.4,96.2 90.91,96.2 91.57,95.54 98.65,95.54 102.04,98.94 102.04,99.87 102.56,100.38 102.56,109.24 103.99,110.67 103.99,114.38 107.59,117.97 107.59,121.61 109.44,123.46 110.11,123.46 110.73,124.08 110.73,124.25 v1(110.98,124.49)
