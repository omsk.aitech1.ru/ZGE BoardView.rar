# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_FET: length 4.1
  TOP w0.14: PU25.9 46.09,32.19 46.37,31.9 v1(46.38,31.9) 46.75,31.9 46.99,32.14 PR354.2
  TOP w0.178: PR354.2 47.61,32.14 47.65,32.18 47.9,32.18 PR352.1 PR350.1
VBUS_FET_EN: length 385.9
  TOP w0.14: R517.1 81.18,17.37 81.48,17.67 81.88,17.67 82.26,17.29 v1(82.26,16.86) ; v1(253.71,19.9) 253.71,20.43 253.26,20.88 U23.14
  IN2 w0.089: v1(92.91,62.82) 92.91,62.82 92.91,62.8 92.07,61.96 92.07,60.55 91.71,60.19 91.71,58.69 91.12,58.1 91.12,55.36 90,54.24 81.53,54.24 80.59,53.31 78.94,53.31 77.38,51.75 76.35,51.75 75.84,51.24 74.34,51.24 73.63,51.95 71.66,51.95 71.32,51.61 66.83,51.61 63.67,48.45 61.97,48.45 v1(61.65,48.14)
  IN3 w0.089: v1(109.43,94.48) 109.13,94.17 109.13,93.72 109.63,93.22 109.63,88.83 106.95,86.15 106.95,76.83 107.77,76.01 107.77,74.87 106.86,73.96 104.88,73.96 104.74,73.83 101.24,73.83 97.72,70.31 97.72,68.39 96.03,66.7 96.03,65.3 94.05,63.33 94.05,62.93 93.7,62.58 93.15,62.58 v1(92.91,62.82) ; v1(67.15,29.91) 67.15,29.85 67.02,29.73 67.02,29.11 67.24,28.9 67.24,28.16 69.03,26.37 69.03,23 70.07,21.96 71.44,21.96 77.35,16.05 81.33,16.05 81.86,16.58 81.98,16.58 v1(82.26,16.86) 82.37,16.76 83.1,16.76 83.36,16.5 83.36,15.9 83.52,15.74 86.55,15.74 87.01,16.2 87.99,16.2 88.41,15.79 89.49,15.79 90.15,16.45 93.52,16.45 94,16.93 95.48,16.93 95.5,16.91 98.97,16.91 99.21,16.68 100.58,16.68 101.76,17.86 101.76,20.13 104.95,23.33 110.69,23.33 111.19,22.82 114.37,22.82 115.21,21.99 115.21,21.38 117.8,18.79 131.82,18.79 134.33,21.3 144.41,21.3 144.76,21.66 148.48,21.66 151.08,19.06 158.49,19.06 159.72,17.82 165.75,17.82 166.43,18.5 172.64,18.5 173.67,17.47 174.01,17.47 176.59,14.89 178.46,14.89 180.48,16.91 185.11,16.91 188.32,13.69 188.32,12.19 189.35,11.16 190.87,11.16 191.57,11.86 194.82,11.86 195.4,11.29 197.09,11.29 199.3,9.08 203.95,9.08 204.58,9.71 205.82,9.71 206.45,9.08 223.89,9.08 226.1,11.29 232.78,11.29 236.28,14.79 237.81,14.79 238.57,14.02 242.19,14.02 243.56,15.4 244.88,15.4 245.45,15.96 245.45,16.32 245.56,16.44 246.25,16.44 249.11,19.3 253.1,19.3 v1(253.71,19.9)
  IN4 w0.086: v1(67.15,29.91) 67.15,29.99 66.36,30.77 65.68,30.77 65.13,31.33 65.13,33.92 63.31,35.74 63.31,37.75 64.42,38.86 64.42,42.04 61.1,45.36 61.1,47.59 v1(61.65,48.14) ; v1(109.43,94.48) 109.47,94.51 109.47,94.88 109.05,95.3 109.05,104.41 109.57,104.93 109.57,110.57 109.01,111.13 109.01,125.32 109.36,125.68 109.36,143.4 108.93,143.83 v1(108.93,144.59)
  BOTTOM w0.203: PR472.2 107.77,141.45 108.93,142.61 v1(108.93,143.78) v1(108.93,144.59)
VBUS_PWR_EN: length 400.4
  TOP w0.14: v1(248.76,24.73) 249.01,24.73 249.47,24.28 U23.24 ; v1(98.65,157.06) 98.65,156.86 PR87.1 ; v1(81.71,17.19) 81.53,17.01 80.74,17.01 80.49,16.76 R518.1
  IN2 w0.089: v1(61.61,46.85) 61.94,46.85 63.16,48.07 63.83,48.07 66.99,51.23 71.48,51.23 71.78,51.53 73.52,51.53 74.19,50.85 77.58,50.85 77.97,51.25 77.97,51.74 78.37,52.14 79.92,52.14 80.19,52.42 86.67,52.42 87.43,53.18 89.48,53.18 91.5,55.2 91.5,57.94 92.21,58.66 92.62,58.66 92.82,58.86 92.82,59.97 92.45,60.34 92.45,61.81 92.87,62.23 93.97,62.23 v1(94.39,62.66)
  IN3 w0.089: v1(94.39,62.66) 94.39,63.4 96.22,65.22 96.22,66.63 97.91,68.31 97.91,70.23 101.31,73.64 104.82,73.64 104.96,73.77 106.94,73.77 107.96,74.79 107.96,76.09 107.14,76.91 107.14,86.07 109.82,88.75 109.82,93.87 v1(109.77,93.92) ; v1(67.43,29.32) 67.43,28.24 69.22,26.45 69.22,23.08 70.15,22.15 71.52,22.15 77.43,16.24 80.76,16.24 v1(81.71,17.19) 81.83,17.31 83.36,17.31 84.66,16.01 86.55,16.01 86.94,16.39 88.07,16.39 88.48,15.98 89.41,15.98 91.39,17.96 92.55,17.96 92.87,17.64 95.37,17.64 95.72,17.29 99.13,17.29 99.33,17.09 100.45,17.09 101.38,18.02 101.38,20.29 104.8,23.71 110.85,23.71 111.35,23.21 114.53,23.21 115.59,22.15 115.59,21.54 117.95,19.17 131.64,19.17 134.15,21.68 144.25,21.68 144.61,22.04 148.64,22.04 151.24,19.44 158.65,19.44 159.88,18.2 165.6,18.2 166.27,18.88 171.63,18.88 171.82,19.07 173.93,19.07 174.27,18.73 174.27,17.75 176.75,15.27 178.3,15.27 180.33,17.29 185.26,17.29 188.67,13.88 188.76,13.8 188.76,12.29 189.51,11.54 190.72,11.54 191.42,12.24 194.98,12.24 195.55,11.67 197.25,11.67 199.46,9.46 203.79,9.46 204.43,10.09 205.97,10.09 206.61,9.46 223.73,9.46 225.95,11.68 232.63,11.68 236.18,15.23 241.72,15.23 243.68,17.19 244.75,17.19 244.99,16.95 246.22,16.95 248.76,19.49 v1(248.76,24.73)
  IN4 w0.086: v1(109.77,93.92) 109.51,93.67 109.14,93.67 108.86,93.94 108.86,104.49 109.38,105.01 109.38,110.49 108.82,111.05 108.82,125.4 109.18,125.76 109.18,143.32 103.89,148.61 103.14,148.61 101.03,150.71 101.03,152.06 98.65,154.45 v1(98.65,157.06) ; v1(61.61,46.85) 61.61,45.12 64.61,42.12 64.61,38.79 63.5,37.67 63.5,35.82 65.32,33.99 65.32,31.4 65.76,30.96 66.44,30.96 67.09,30.31 67.36,30.31 67.55,30.12 67.55,29.44 v1(67.43,29.32)
  BOTTOM w0.14: v1(248.76,24.73) TP106.1
VCC0P9_CIO: length 2.8
  TOP w0.203: U7.R12 v2(261.42,51.41) 261.74,51.72 U7.R11 261.68,51.75 v2(261.4,52.03) 261.42,52.03 261.74,52.34 U7.R9 v2(261.41,52.72) U7.R8
VCC0P9_DP:
  vias: v2(260.11,52.07) v2(260.1,51.43) v2(260.73,51.43) v2(263.37,53.36) v2(263.38,52.74) v2(263.39,51.42) v2(264.01,53.38)
VCC0P9_LVR: length 6.5
  TOP w0.203: U7.H11 265.31,51.43 265.31,48.64 265.31,48.64 265.31,48.63 265.31,48.36 265.31,48.35 v2(265.31,48.17) ; U7.H11 264.66,51.42 v2(264.66,51.42) U7.J11 ; U7.H11 v2(265.32,52.08) ; v2(265.31,48.17) U7.F18 v2(265.98,48.15) ; v2(265.31,48.17) U7.H18
  vias: v1(265.38,51.4)
VCC0P9_PCIE:
  vias: v2(262.74,50.12) v2(262.75,49.47) v2(262.7,48.2) v2(263.36,48.23) v2(264.01,48.22)
VCC0P9_SVR: length 9.2
  TOP w0.203: U7.E13 266.61,50.77 v2(266.61,50.77) U7.E12 U7.F11 U7.F12 265.67,51.1 v2(265.98,50.79) ; U7.E13 265.98,50.75 v2(265.98,50.79) ; U7.E13 v2(265.96,50.12) ; U7.E13 266.61,50.13 v2(266.62,50.13) ; v2(265.96,50.12) 265.96,50.12 U7.F15 ; v2(265.96,50.12) U7.F13 v2(265.98,50.79) ; v2(262.71,52.72) 263.04,52.4 U7.M9 ; U7.L9 263.69,52.34 264.01,52.02 v2(264.02,52.02) 264.02,52.08 U7.J9 264.64,52.09 v2(264.64,52.03)
  BOTTOM w0.203: v2(264.02,52.02) 264.02,52.44 C725.2 ; C719.2 262.53,52.9 v2(262.71,52.72) ; v2(264.64,52.03) 264.77,52.16 C724.2
  vias: v1(277.13,58.46) v1(277.13,57.7) v1(277.89,58.46) v1(277.89,57.7) v1(278.66,58.46) v1(278.66,57.7) v1(279.42,58.46) v1(279.42,57.7)
VCC0P9_SVR_IND:
  vias: v1(271.19,56.83)
VCC0P9_USB:
  vias: v2(261.41,49.47)
VCC3V3_FLASH: length 29.5
  TOP w0.381: v1(245.81,38.57) 245.61,38.57 244.77,39.41 U12.8
  IN2 w0.381: v1(245.81,38.57) 245.29,39.09 245.29,42.06 247.77,44.53 247.77,45.92 248.69,46.85 249.15,46.85 249.75,47.44 249.75,48.74 248.68,49.82 v1(248.68,51.03)
  IN3 w0.381: v1(245.81,38.57) 245.81,39.31 246.4,39.89 247.13,39.89 248.86,41.62 252.42,41.62 253.26,42.46 v1(253.26,42.64)
  BOTTOM w0.203: R822.1 C781.2 253.29,42.67 v1(253.26,42.64)
  vias: v1(249.32,30.42)
VCCIO_VCCSENSE: length 1.5
  TOP w0.254: v1(124.71,113.4) U3.H14
  BOTTOM w0.254: TP63.1 124.94,113.18 v1(124.71,113.4)
VCCMPHY_SENSE: length 7.3
  TOP w0.102: 227.62,41.05 227.48,41.05 227.42,41.11 227.25,41.11 227.1,41.26 U14.K47
  TOP w0.14: TP27.1 232.12,40.62 228.39,40.62 227.96,41.05 227.62,41.05
VCCPHVLDO_1P8:
  vias: v1(211.92,33.32) v1(212.4,33.94) v1(212.67,33.34)
VCCSA_VCCSENSE: length 13.8
  TOP w0.203: PR120.1 127.41,141.93 PR121.1 128.01,141.71 127.62,141.33 v1(127.49,141.33) ; U3.M38 126.96,131.56 126.96,132.19 127.68,132.91 v1(127.89,132.91)
  IN4 w0.203: v1(127.49,141.33) 126.95,141.33 126.18,140.55 126.18,135.32 127.4,134.1 127.4,133.4 v1(127.89,132.91)
VCCSA_VSSSENSE: length 17
  TOP w0.203: PR119.1 127.68,143.45 127.45,143.22 PR118.1 127.13,143.7 v1(127.37,143.94) ; v1(127.89,132.24) 127.63,132.24 127.27,131.88 127.27,131.22 U3.M37
  IN4 w0.203: v1(127.89,132.24) 127.71,132.24 127.09,132.86 127.09,133.98 125.88,135.19 125.88,140.68 126.99,141.8 126.99,143.56 v1(127.37,143.94)
VCCSENSE: length 14.9
  TOP w0.203: v1(133.06,137.02) 133.06,137.35 PR129.1 132.81,138.21 PR123.2 ; R32.1 v1(137.34,137.69)
  TOP w0.254: v1(138.42,133.9) 138.65,133.67 138.65,132.15 138.32,131.82 138.32,131.27 U3.AG37
  IN1 w0.203: v1(133.06,137.02) 133.88,137.84 137.19,137.84 v1(137.34,137.69) 137.65,137.69 138.42,136.92 v1(138.42,133.9)
VCCST_PWRGD: length 26.4
  TOP w0.089: v1(123.79,112.75) U3.H13
  TOP w0.14: EC2.2 104.55,101.54 105.43,102.42 R107.1 106.51,102.42 107.08,102.99 107.08,105.32 108.01,106.25 v1(110.7,106.25)
  IN3 w0.089: v1(123.79,112.75) 122.55,112.75 122.06,113.23 120.33,113.23 118.71,111.62 117.82,111.62 112.45,106.25 v1(110.7,106.25)
VSS_GPU_SENSE: length 146.1
  TOP w0.105: UG1.BL45 67.75,93.74 69,92.49 71.7,92.49 71.96,92.23 71.96,92.21 71.99,92.18 71.99,92.13 72,92.12
  TOP w0.127: 72,92.12 72.51,91.61 72.51,91.61 72.72,91.41 79.24,91.41 79.42,91.23 v1(79.42,90.95)
  IN3 w0.127: v1(79.42,90.95) 79.42,91.77 80.11,92.46 85.32,92.46 85.6,92.18 85.6,80.21 90.99,74.82 92.85,74.82 93.46,75.43 94.31,75.43 94.75,75 94.75,74.04 93.94,73.23 93.94,69.62 91.18,66.86 91.18,62.4 90.09,61.31 90.09,60.81 88.03,58.75 88.03,56.99 87.07,56.03 87.07,55.13 86.17,54.23 81.75,54.23 80.82,53.31 79.26,53.31 79.15,53.2 77.87,53.2 77.45,53.62 76.86,53.62 75.45,52.22 71.33,52.22 70.19,51.08 67.08,51.08 64.3,48.29 62.94,48.29 61.5,49.74 61.44,49.74 61.03,50.14 59.44,50.14 57.65,51.93 55.44,51.93 53.89,50.38 50.96,50.38 50.25,49.66 50.25,43.08 48.72,41.55 48.16,41.55 46.66,40.05 44.83,40.05 43.86,39.08 38.8,39.08 38.31,39.57 37.11,39.57 35.2,41.48 35.2,47.41 36.54,48.76 37.23,48.76 37.69,49.22 37.69,49.77 37.36,50.1 36.4,50.1 v1(36.18,49.88)
  BOTTOM w0.127: v1(36.18,49.88) 36,50.05 PR515.2
VSSIO_VCCSENSE: length 3.5
  TOP w0.254: U3.J14 125.3,114.39 v1(125.42,114.39)
  BOTTOM w0.254: v1(125.42,114.39) 125.42,114.01 125.9,113.53 127.15,113.53 TP64.1
VSSMPHY_SENSE: length 10.3
  TOP w0.102: U14.K46 225.63,41.03 226.97,41.03 227.1,40.91 227.3,40.91 227.44,40.77 227.61,40.77
  TOP w0.14: TP26.1 233.73,41.45 233.01,40.73 232.63,40.73 232.24,40.34 228.33,40.34 227.9,40.77 227.61,40.77
VSSSENSE: length 17.1
  TOP w0.203: v1(131.01,137.02) 131.01,137.27 PR128.1 131.34,138.19 PR122.2 ; R31.1 v1(138.36,137.7)
  TOP w0.254: U3.AG38 139.06,131.85 139.06,133.67 v1(139.26,133.87)
  IN1 w0.203: v1(139.26,133.87) 138.73,134.41 138.73,137.33 v1(138.36,137.7) 137.91,138.15 133.76,138.15 133.09,137.48 131.46,137.48 v1(131.01,137.02)
1P35V_BOOT: length 5.3
  TOP w0.203: 155.39,21.05 v4(155.59,21.25) 156.1,21.76 PU27.18
  TOP w0.254: 155.39,21.05 155.16,20.82 153.53,20.82 PR414.2
1P35V_CS: length 1.9
  TOP w0.203: PU27.13 153.96,24.1 153.33,23.46 PR405.2
1P35V_FB: length 3.9
  TOP w0.203: PR370.1 159.58,27.12 159.45,26.99 PR389.1 158.6,26.57 v1(158.57,26.54) 157.73,25.7 PU27.6
1P35V_LGATE: length 9.9
  TOP w0.762: PQ36.8 148.7,16.92 v3(147.51,16.92)
  IN2 w0.635: v3(153.59,22.6) 153.4,22.6 147.72,16.92 v3(147.51,16.92)
1P35V_PGOOD: length 2.8
  TOP w0.203: PU27.10 155.3,26.16 155.09,26.37 154.06,26.37 v1(153.9,26.53) 153.6,26.83 PR373.2
1P35V_PHASE: length 12.7
  TOP w0.508: v3(153.57,21.75) 153.17,21.75 PC266.1
  TOP w0.762: PR425.1 147.86,9.78 147.66,9.98 146.64,9.98
  IN1 w0.762: v3(153.57,21.75) 149.28,17.45 149.28,15.78 v3(148.03,14.53)
  vias: v1(154.07,15.41)
1P35V_S3: length 7.1
  TOP w0.14: PR364.2 158.64,29.38 v1(158.51,29.51)
  TOP w0.203: PU27.7 156.5,26.56 156.81,26.86 PR376.1 156.95,27.44 PC238.1 157.79,27.22 PR374.2 158.82,27.22 158.92,27.32 158.92,28.44 159.31,28.82 PR364.2
1P35V_S5: length 5.7
  TOP w0.14: v1(157.19,29.51) 156.8,29.12 156.8,28.86 156.66,28.73 PR365.2
  TOP w0.203: PU27.8 156.1,26.79 155.48,27.41 ; 155.48,27.41 155.97,27.41 156.09,27.3 PR376.2 156.36,28.03 PR367.2 156.36,28.41 156.34,28.43 156.34,28.7 PR365.2 ; 155.48,27.41 PC239.1
1P35V_TON: length 2.5
  TOP w0.203: PR372.2 155.09,26.78 155.58,26.78 155.7,26.65 PU27.9
1P35V_UGATE: length 16.4
  TOP w0.762: PQ36.1 148.59,11.43 v1(147.59,11.43)
  IN2 w0.762: v3(154.43,21.4) 154.43,21.26 154.68,21 154.68,15.21 152.53,13.05 149.21,13.05 v1(147.59,11.43)
1P35V_VDD: length 2.6
  TOP w0.203: PU27.12 153.49,24.5 153.29,24.3 PC257.1 153.05,24.92 PR394.2
1P35V_VDDQ: length 12.9
  TOP w0.203: PR401.2 149.52,24.24 v1(149.52,23.77) ; PR389.2 158.66,25.79 v1(158.46,25.59) 158.39,25.52 158.39,25.01 158.27,24.9 PU27.5
  IN4 w0.203: v1(149.52,23.77) 149.62,23.66 152.6,23.66 154.53,25.59 v1(158.46,25.59)
1P35V_VID: length 4.8
  TOP w0.203: v1(152.22,28.16) 152.64,27.74 PR375.2 152.64,26.86 152.55,26.78 PR388.2 152.55,25.95 152.75,25.75 153,25.75 153.85,24.9 PU27.11
2ND_MBCLK: length 259
  TOP w0.14: R246.1 76.55,38.66 76.55,36.88 v1(76.34,36.67) 76.23,36.56 U18.115 ; v1(60.06,15.75) 60.06,15.03 59.67,14.63 Q46.3 ; Q55.6 212.67,10.08 212.3,10.45 R1157.2 211.47,9.94 v1(211.47,9.9)
  IN4 w0.086: v1(243.66,22.11) 244.09,21.68 244.09,21.06 243.43,20.4 243.43,15.54 241.75,13.86 238.68,13.86 237.06,12.25 229.98,12.25 229.05,11.32 226.1,11.32 223.55,8.77 213.02,8.77 211.89,9.9 v1(211.47,9.9) 210.66,9.08 206.56,9.08 205.93,9.71 204.64,9.71 204.01,9.08 196.93,9.08 193.21,12.79 191.38,12.79 189.55,14.63 189.19,14.63 184.95,18.87 178.17,18.87 176.92,17.62 173.37,17.62 172.12,18.87 167.46,18.87 166.8,18.2 159.68,18.2 158.72,19.17 151.76,19.17 149.18,21.74 138.99,21.74 137.55,23.18 133.41,23.18 131.05,20.82 127.45,20.82 125.47,18.84 118.06,18.84 113.49,23.41 104.16,23.41 102.04,21.29 102.04,17.52 100.91,16.4 99.36,16.4 98.85,16.91 94.8,16.91 92.81,14.91 91.68,14.91 90.17,13.4 89.19,13.4 88.43,12.64 83.72,12.64 83.24,13.12 80.26,13.12 80.21,13.17 67.58,13.17 66.68,14.06 61.43,14.06 60.06,15.43 v1(60.06,15.75)
  BOTTOM w0.14: R948.1 243.7,25.76 243.7,24.82 v1(243.85,24.67) 243.85,23.67 244.1,23.42 244.1,22.56 v1(243.66,22.11) ; v1(60.06,15.75) 60.39,16.08 60.39,16.73 60.89,17.23 60.89,18.04 61.53,18.68 62.3,18.68 62.38,18.6 63.34,18.6 63.69,18.94 64.91,18.94 65.63,19.67 65.63,20.2 66.26,20.83 66.26,22.99 67.38,24.11 67.81,24.11 69.33,25.63 69.33,33.46 70.71,34.84 74.58,34.84 76.29,36.56 76.29,36.62 v1(76.34,36.67)
2ND_MBDATA: length 261.1
  TOP w0.14: Q55.3 214.55,11.38 214.29,11.12 214.29,9.72 213.89,9.31 211.09,9.31 210.81,9.59 v1(210.81,9.9) 210.81,10.08 210.97,10.23 R1156.2 ; U18.116 75.83,36.3 75.69,36.44 v1(75.69,36.7) 75.69,37.06 76.25,37.62 76.25,38.78 R245.1 ; Q46.6 60.71,15.95 60.32,16.35 v1(59.94,16.35)
  IN4 w0.086: v1(243.64,21.39) 243.64,21.24 242.99,20.59 242.99,15.72 241.57,14.3 238.49,14.3 236.88,12.69 229.79,12.69 228.87,11.76 225.92,11.76 223.38,9.22 213.19,9.22 212.07,10.34 211.26,10.34 v1(210.81,9.9) 210.45,9.53 206.74,9.53 206.11,10.16 204.46,10.16 203.82,9.52 197.11,9.52 193.4,13.23 191.57,13.23 189.73,15.07 189.37,15.07 185.13,19.31 177.99,19.31 176.74,18.06 173.56,18.06 172.31,19.31 167.23,19.31 166.56,18.64 159.87,18.64 158.9,19.61 151.94,19.61 149.37,22.19 139.17,22.19 137.74,23.62 133.23,23.62 130.87,21.26 127.27,21.26 125.29,19.28 118.25,19.28 113.67,23.86 103.98,23.86 101.59,21.47 101.59,17.71 100.73,16.84 99.54,16.84 99.03,17.35 94.62,17.35 92.63,15.36 91.5,15.36 89.98,13.84 89.01,13.84 88.25,13.08 83.9,13.08 83.43,13.56 80.44,13.56 80.39,13.61 67.76,13.61 66.86,14.5 61.72,14.5 60.51,15.72 60.51,15.94 60.09,16.35 v1(59.94,16.35)
  BOTTOM w0.14: R958.1 244.19,25.18 244.34,25.03 244.34,24.01 244.64,23.71 v1(244.64,23.29) 244.64,22.39 v1(243.64,21.39) ; v1(59.94,16.35) 59.94,16.97 60.65,17.69 60.65,18.32 61.42,19.09 63.14,19.09 63.48,19.43 64.7,19.43 65.14,19.87 65.14,20.32 65.01,20.46 65.01,21 65.77,21.76 65.77,23.2 67.18,24.61 67.6,24.61 68.83,25.84 68.83,33.66 70.5,35.33 74.28,35.33 75.65,36.7 v1(75.69,36.7)
3ND_MBCLK: length 266.4
  TOP w0.14: v1(11.07,67.35) 11.06,67.36 Q19.4 ; Q33.4 92.21,34.4 v1(90.7,35.92) 90.54,36.07 90.01,36.07 88.92,34.98 87.41,34.98 87.24,35.15 86.48,35.15 86.01,34.68 86.01,34.27 R312.1 86.03,34.05 86.29,33.79 86.29,33.06 85.85,32.62 U18.94
  IN1 w0.086: v1(14.44,77.75) 14.08,78.11 14.08,83.34 v1(13.51,83.91) ; v1(90.7,35.92) 90.7,36.17 90.72,36.2 90.72,36.51 89.65,37.58 86.35,37.58 85.83,38.1 82.54,38.1 82.1,38.54 81.15,38.54 80.62,38.01 79.24,38.01 79.14,38.12 77.97,38.12 77.67,38.42 76.11,38.42 75.86,38.67 74.26,38.67 73.95,38.98 71.4,38.98 70.36,40.02 69.17,40.02 68.62,39.47 66.99,39.47 66.73,39.73 64.03,39.73 63.66,39.36 58.04,39.36 56.74,40.67 56.74,43.96 56.55,44.14 56.55,44.41 56.29,44.68 53.96,44.68 52.58,43.3 52.58,42.6 51.41,41.43 48.11,41.43 47.95,41.27 46.12,41.27 45.65,41.74 43.7,41.74 42.74,40.78 34.97,40.78 34.27,41.48 32.12,41.48 30.68,42.93 28.05,42.93 25.81,45.16 25.04,45.16 24.84,45.36 22.82,45.36 21.22,46.96 20.13,46.96 20.01,46.84 18.89,46.84 16.99,48.74 16.99,51.14 16.25,51.88 16.25,53.56 14.1,55.72 11.84,55.72 11.3,56.26 11.3,58.53 10.45,59.38 10.45,62.23 11.38,63.16 11.38,64.42 10.71,65.1 10.71,66.99 v1(11.07,67.35) 8.22,67.35 7.89,67.68 7.89,69.51 8.66,70.28 9.22,70.28 9.87,70.93 9.87,71.71 11.48,73.32 11.48,74.99 10.88,75.59 10.88,77.28 11.28,77.69 11.28,78.2 11.7,78.62 11.7,85.35 13.52,87.16 15.23,87.16 15.61,87.54 15.61,88.57 14.46,89.72 14.46,93.21 14.5,93.25 14.5,98.05 11.45,101.11 7.41,101.11 6.59,101.93 6.59,140.7 7.27,141.39 9.69,141.39 10.97,142.67 12.84,142.67 15.51,145.34 18.49,145.34 v1(20.97,147.82)
  BOTTOM w0.14: v1(13.51,83.91) 13.51,83.87 12.71,83.07 10.74,83.07 10.6,83.21 QG20.3 ; v1(20.97,147.82) 20.6,148.2 20.6,149.88 R1154.2 21.25,150.15 21.76,149.63 21.76,149.57 21.94,149.39 22.79,149.39 23.17,149.01 23.93,149.01 24.07,148.87 24.57,148.87 24.71,149.01 24.71,149.46 24.68,149.49 24.68,149.56 24.46,149.79 23.56,149.79 Q61.3 ; v1(11.07,67.35) 10.69,67.35 9.42,68.62 9.42,71.92 8.25,73.09 8.25,75.41 9.45,76.62 9.45,77.52 11,79.07 Q65.3 11.91,79.08 12.97,78.01 14.17,78.01 v1(14.44,77.75)
3ND_MBCLK_C: length 6.4
  TOP w0.14: R122.1 9.05,66.49 Q19.3 9.28,67.36 9.53,67.61 9.53,70.71 10.11,71.29 U4.4
3ND_MBCLK_THM: length 7.4
  BOTTOM w0.14: v1(24.25,149.29) 23.23,149.29 22.74,149.78 Q61.4 21.95,149.78 21.8,149.93 21.8,149.98 21.35,150.43 21.35,150.66 21.09,150.93 R1154.1 20.86,152.15 R669.2 21.41,152.7 22.12,152.7 U38.8
3ND_MBDATA: length 261.8
  TOP w0.14: U18.95 85.85,33.02 86.05,33.21 86.05,33.65 85.87,33.82 85.39,33.82 R307.1 85.32,34.11 85.52,34.31 85.52,34.7 86.29,35.47 88.72,35.47 89.81,36.57 90.85,36.57 91.24,36.18 91.24,36.12 v1(91.44,35.93) ; Q19.1 9.05,68.53 v1(8.4,69.18) ; Q33.1 96.22,33.4 96.59,33.77 96.59,34.57 v1(96.58,34.59)
  IN1 w0.086: v1(21.96,155.01) 21.96,153.76 20.95,152.75 20.95,151.48 21.16,151.26 21.37,151.26 v1(21.53,151.1) 21.53,150.3 20.88,149.65 20.88,148.89 21.53,148.23 21.53,146.78 21.18,146.42 20.2,146.42 18.68,144.9 15.69,144.9 13.02,142.23 11.16,142.23 9.88,140.95 7.46,140.95 7.03,140.52 7.03,102.11 7.59,101.55 11.63,101.55 14.95,98.24 14.95,93.1 14.9,93.05 14.9,89.91 16.05,88.75 16.05,87.36 15.41,86.72 13.7,86.72 12.14,85.16 12.14,78.44 11.73,78.02 11.73,77.5 11.32,77.1 11.32,75.77 11.92,75.18 11.92,73.14 10.31,71.53 10.31,70.75 9.33,69.76 8.99,69.76 v1(8.4,69.18) 9.85,69.18 10.31,69.64 11.7,69.64 12.33,69.01 12.33,66.2 11.83,65.7 11.83,62.98 10.89,62.04 10.89,59.56 11.78,58.67 11.78,56.4 12.03,56.16 14.29,56.16 16.7,53.75 16.7,52.1 17.43,51.37 17.43,48.93 19.08,47.28 19.83,47.28 19.99,47.44 21.36,47.44 23,45.8 25.02,45.8 25.22,45.6 26,45.6 28.23,43.37 30.86,43.37 32.3,41.93 34.45,41.93 35.15,41.23 42.56,41.23 43.52,42.19 45.83,42.19 46.31,41.71 47.63,41.71 47.79,41.87 51.23,41.87 52.14,42.78 52.14,43.48 53.77,45.12 56.47,45.12 57,44.6 57,44.32 57.18,44.14 57.18,40.85 58.22,39.81 63.48,39.81 63.85,40.17 66.91,40.17 67.17,39.91 68.44,39.91 68.98,40.46 70.55,40.46 71.59,39.42 74.14,39.42 74.44,39.11 76.04,39.11 76.29,38.86 77.85,38.86 78.16,38.56 79.32,38.56 79.43,38.45 80.43,38.45 80.97,38.98 82.28,38.98 82.72,38.54 86.01,38.54 86.53,38.02 89.83,38.02 91.24,36.61 91.24,36.12 v1(91.44,35.93)
  IN3 w0.089: v1(96.58,34.59) 96.45,34.71 93.18,34.71 91.97,35.93 v1(91.44,35.93)
  BOTTOM w0.14: Q61.6 21.85,150.78 v1(21.53,151.1) ; QG20.6 9.3,80.98 9.47,80.8 9.96,80.8 10.09,80.68 10.09,80.5 9.96,80.37 Q65.6 8.8,80.37 8.25,79.82 8.25,78.12 7.31,77.19 7.31,73.29 6.95,72.93 6.95,70.07 7.84,69.18 v1(8.4,69.18) ; R1155.2 21.73,154.77 v1(21.96,155.01)
3ND_MBDATA_C: length 6.6
  TOP w0.14: R123.1 9.92,66.62 9.92,68.06 10.22,68.36 Q19.6 10.4,68.53 10.03,68.9 10.03,70.63 10.51,71.11 U4.5
3ND_MBDATA_THM: length 98
  IN1 w0.086: v1(102.91,145.99) 102.91,147.51 102.59,147.84 102.59,149.94 95.33,157.2 93.72,157.2 92.52,158.4 92.01,158.4 91.9,158.29 90.34,158.29 90.04,158.58 89.69,158.58 88.71,157.6 87.02,157.6 86.88,157.74 81.5,157.74 81.26,157.5 76.02,157.5 75.22,156.7 64.51,156.7 64.15,157.06 61.63,157.06 60.95,157.74 47.26,157.74 46.72,157.19 40.2,157.19 39.36,158.04 35.56,158.04 34.72,157.19 31.21,157.19 31.02,157 29.27,157 28.56,156.3 25.99,156.3 25.76,156.07 24.47,156.07 23.56,155.16 v1(23.56,154.78)
  BOTTOM w0.14: Q61.1 23.55,151.21 23.06,151.71 U38.7 23.06,153.64 23.56,154.14 v1(23.56,154.78) 22.79,155.55 R1155.1 ; R673.2 v1(102.91,145.99)
5650_BSIN1: length 14.4
  TOP w0.178: PR357.2 43.27,31.31 v1(43.27,31.46) 43.27,31.66 43.49,31.87 PU25.3 ; PR345.2 PR347.2 48.8,33.79 PR350.2 49.27,32.84 49.27,31.74 48.71,31.18 v1(48.71,31.03)
  IN1 w0.178: v1(43.27,31.46) 43.71,31.03 44.39,31.03 45.08,30.34 47.55,30.34 47.77,30.56 48.24,30.56 v1(48.71,31.03)
  BOTTOM w0.178: v1(43.27,31.46) 43.07,31.66 PC421.2
5650_BSIN2: length 10
  TOP w0.178: v1(47.82,31.08) 47.88,31.14 48.05,31.14 48.8,31.89 PR352.2 ; PU25.6 44.69,31.7 44.89,31.5 v1(44.89,31.49) 44.89,31.49 45.03,31.49 45.52,31 46.38,31 PR358.2
  IN1 w0.178: v1(44.89,31.49) 44.89,31.49 45.08,31.49 45.92,30.65 47.46,30.65 47.82,31.01 v1(47.82,31.08)
  BOTTOM w0.178: PC420.2 44.09,32.22 44.82,31.49 v1(44.89,31.49)
5650_BSIN3: length 2
  TOP w0.178: PU25.11 46.54,33.86 46.7,33.7 47.16,33.7 PR347.1
5650_BSIN4: length 1.8
  TOP w0.178: PU25.14 47.09,35.06 v1(47.14,35.01) 47.72,35.01 PR345.1
5650_BSOK: length 3.9
  TOP w0.178: 41.01,32.68 40.88,32.82 40.88,33.07 41.67,33.86 PU25.30 ; 41.01,32.68 v1(41.07,32.63) ; 41.01,32.68 40.76,32.68 PR353.2
  BOTTOM w0.178: v1(41.07,32.63) 40.51,32.07 PR557.1
5650_BSREF: length 6.2
  TOP w0.178: PU25.24 42.69,36.89 v1(42.32,37.26) 42.12,37.45 PC227.1 41.39,38.04 PR340.1 41.29,38.14 40.78,38.14 PR335.2 PR337.1
  BOTTOM w0.178: PC419.1 43.33,36.24 42.52,37.04 42.52,37.05 v1(42.32,37.26)
5650_CMREF_IN: length 5.4
  TOP w0.178: PR333.1 44.12,40.03 43.58,39.49 PR336.2 43.59,39.17 44.27,38.49 PC226.1 44.39,38.28 44.39,37.78 v1(44.18,37.57) 43.49,36.88 PU25.22
5650_EN: length 9.2
  TOP w0.178: PU25.28 41.24,34.66 v1(41.04,34.46) 41.04,34.22 40.52,33.7 PR349.2
  BOTTOM w0.14: PQ55.3 38.88,37.69 38.88,36.54 38.77,36.43 38.77,35.8 40.11,34.46 v1(41.04,34.46)
  BOTTOM w0.178: PR555.2 42.47,34.15 42.16,34.46 v1(41.04,34.46)
5650_MODE: length 3.2
  TOP w0.14: v1(40.95,36.19) 40.61,36.54 PR343.1
  TOP w0.178: PU25.26 41.47,35.46 40.95,35.97 v1(40.95,36.19)
  BOTTOM w0.14: PR552.1 41.17,35.86 40.95,36.07 v1(40.95,36.19)
5650_MUX: length 2.4
  TOP w0.178: PR351.1 40.25,33.02 40.51,33.29 40.6,33.29 41.57,34.26 PU25.29
5650_REFOUT: length 7.4
  TOP w0.178: PR335.1 42.8,39.17 PR336.1 43.58,38.08 43.53,38.03 43.53,37.64 v1(43.53,37.64) 43.53,37.4 43.09,36.96 PU25.23
  BOTTOM w0.178: PC418.1 44.34,36.24 43.88,36.69 43.88,37.29 v1(43.53,37.64)
5650_SH01: length 4
  TOP w0.178: PR363.2 PC229.2 v1(41.23,31.98) 41.73,31.98 42.09,32.33 PU25.32
5650_SH02: length 3.3
  TOP w0.178: PU25.7 45.09,32.04 45.64,31.48 v1(45.88,31.48)
  BOTTOM w0.178: PC422.2 PR556.2 45.99,31.59 v1(45.88,31.48)
5650_SHN1: length 2.3
  TOP w0.178: PU25.1 42.69,32.16 41.67,31.15 PR359.2
5650_SHN2: length 2.3
  TOP w0.178: PU25.4 43.89,31.36 44.71,30.53 PR361.2
5650_SHN3: length 9.8
  TOP w0.14: PR344.1 48.23,35.91 v1(48.38,35.76)
  TOP w0.178: PU25.15 46.57,35.46 46.62,35.5 47.3,35.5 47.62,35.82 PR344.1 46.94,35.91 46.89,35.86 PU25.16 ; PU25.13 46.62,34.66 46.9,34.37 v1(46.9,34.2) 46.89,34.2 46.84,34.26 PU25.12
  BOTTOM w0.14: v1(46.9,34.2) 47.15,34.44 47.15,34.95 48.07,35.87 48.27,35.87 v1(48.38,35.76)
  BOTTOM w0.178: v1(46.9,34.2) 46.89,34.19 46.14,34.19 46.11,34.17 PR554.2
5650_SHP1: length 2.2
  TOP w0.178: PR360.1 42.63,30.72 v1(42.63,31.34) 42.63,31.55 43.09,32.01 PU25.2
5650_SHP2: length 2.9
  TOP w0.178: PR362.1 45.49,30.53 45.02,31 44.69,31 44.29,31.41 PU25.5
5650_SKIP: length 7.7
  TOP w0.178: PU25.25 41.7,35.86 41.52,36.04 v1(41.52,36.52) 41.5,36.52 41.16,36.85 40.76,36.85 40.38,37.24 PR341.1
  BOTTOM w0.14: v1(41.52,36.52) 41.35,36.68 40.79,36.68 40.49,36.38 40.49,36 40.49,35.71 v1(40.05,35.27) 40.05,35.11 40.19,34.97 PR553.1
5650_VCC: length 2.7
  TOP w0.178: PU25.27 41.42,35.06 41.2,35.27 PC228.1 40.27,35.11 PR346.2
8068EN1_1.8V: length 5.3
  TOP w0.254: PU12.5 6.7,83.66 v1(6.5,83.86) 6.61,83.98 6.61,85.25 PC124.1 7.28,85.66 7.54,85.91 7.54,86.98 PR143.2
8068EN_1.8V: length 2.7
  TOP w0.178: PU30.5 174.37,21.02 174.88,20.5 PC270.1 174.8,19.78 174.51,19.49 PR417.1
8068FB1_1.8V: length 5.3
  TOP w0.254: PU12.6 7.13,80.66 v1(6.67,80.2) 6.67,81.6 v1(6.83,81.75)
  BOTTOM w0.254: PC338.2 PR481.2 6.83,82.3 v1(6.83,81.75) 6.83,81.28 PR482.1
8068FB1_1.8V_S: length 9.4
  BOTTOM w0.203: PC338.1 7.07,84.24 7.07,85.09 v1(6.98,85.18) 6.94,85.22 6.11,86.05 6.11,90.42 6.39,90.69 PR480.2
  BOTTOM w0.254: PC338.1 PR481.1
8068FB_1.8V: length 6.1
  TOP w0.178: 177.06,21.78 177.06,22.39 176.88,22.57 PR407.2 175.79,22.57 PC265.2 175.58,22.51 175.37,22.71 174.98,23.1 174.98,23.61 PU30.6 ; 177.06,21.78 v1(177.06,21.76) ; 177.06,21.78 176.9,21.78 176.65,22.04 176.16,22.04 PR413.1
8068FB_1.8V_S: length 4
  TOP w0.178: PR383.1 177.01,25.95 177.01,23.52 PR407.1 176.17,23.35 176.11,23.29 PC265.1
8068LX1_1.8V:
  vias: v1(10.57,83.62)
8068LX_1.8V: length 0.8
  TOP w0.254: PR418.1 170.12,20.37
  vias: v1(171.3,21.71)
8068NC1_1.8V: length 2.5
  TOP w0.203: PU12.7 8.05,80.28 7.83,80.06 7.52,80.06 7.26,79.8 v1(7.18,79.8)
  BOTTOM w0.254: PC339.1 7.59,80.08 7.31,79.8 v1(7.18,79.8)
8068NC_1.8V: length 2.4
  TOP w0.203: PU30.7 173.87,24.58 174.09,24.81 175.43,24.81 PC255.1
8068PG1_1.8V: length 1.3
  TOP w0.203: PU12.4 8.05,84.08 PR145.1
8068PG_1.8V: length 2.4
  TOP w0.178: PR415.2 172.29,20.09 172.54,20.34 173.45,20.34 173.87,20.76 PU30.4
8068SVIN1_1.8V: length 3.5
  TOP w0.254: PR147.2 7.82,79.29 v1(7.82,79.52) 7.95,79.52 8.55,80.12 PU12.8
  BOTTOM w0.254: v1(7.82,79.52) 7.35,79.06 PC340.1
8068SVIN_1.8V: length 11.3
  TOP w0.203: v1(171.32,26.23) 170.56,26.99 PR368.2 ; PU30.8 173.37,24.58 173.94,25.15 175.3,25.15 v1(175.49,25.35) 176.15,25.35 PC253.1 176.17,25.73 v1(175.9,26)
  IN4 w0.203: v1(175.9,26) 175.9,25.58 175.5,25.18 173.69,25.18 172.64,26.23 v1(171.32,26.23)
8816ABOOT1: length 4.3
  TOP w0.203: v1(15.51,174.16) 15.78,173.89 15.78,173.25 ; PU1.1 14.94,170.73 15.14,170.93 15.14,172.61 15.78,173.25 ; 15.78,173.25 PC3.2
8816ABOOT2: length 2.6
  TOP w0.203: PC27.2 15.52,165.74 15.52,166.94 v1(15.33,167.12) 15.21,167.12 14.8,167.53 PU1.15
8816AEN: length 4.7
  TOP w0.203: PU1.3 13.73,171.36 13.58,171.52 v1(13.58,172.03) 13.58,172.46 PR8.1 14.11,172.61 14.15,172.58 PC2.1
  BOTTOM w0.14: v1(13.58,172.03) 13.58,172.41 13.1,172.89 PR428.2
8816ALGATE1: length 18.2
  TOP w0.762: PQ3.8 25.6,167.28 v3(26.37,168.05)
  IN1 w0.762: v3(26.37,168.05) 26.37,172.72 v3(26.84,173.18)
  IN4 w0.762: v3(26.37,168.05) 26.35,168.06 21.23,168.06 20.35,168.94 20.35,169.96 19.41,170.89 17.55,170.89 v3(16.88,170.22)
  vias: v1(26.69,173.9)
8816ALGATE2: length 23.4
  TOP w0.762: v3(16.78,155.49) 17.34,156.05 PQ7.8 ; PQ6.8 11.63,156.91 v3(12.54,156.91)
  IN1 w0.762: v3(12.54,156.91) 13.33,156.91 13.61,156.63 15.64,156.63 v3(16.78,155.49)
  IN3 w0.762: v3(16.78,155.49) 16.78,157.14 19.81,160.16 19.81,163.69 18.43,165.07 18.43,167.67 17.78,168.32 v3(16.78,168.32)
  vias: v1(17.42,167.94)
8816APG: length 4.6
  TOP w0.14: PR41.1 14.5,164.12 v1(14.75,163.87)
  TOP w0.203: PU1.13 13.73,166.69 14.6,165.82 PR35.1 14.27,165.77 14.17,165.67 14.17,164.99 PR41.1
8816APHASE1: length 13.7
  IN4 w0.762: v3(16.3,170.96) 17.85,172.51 20.87,172.51 21.82,173.46 24.21,173.46 26.71,170.96 v3(27.93,170.96)
  vias: v1(28.64,173.42)
8816APHASE2: length 20
  TOP w0.203: 15.86,167.44 15.86,166.19 16.41,165.63 PC27.1
  IN4 w0.762: v3(16.42,167.24) 15.87,166.69 15.87,166.24 14.45,164.81 14.45,163.57 13.68,162.81 12.19,162.81 11.7,162.32 11.7,161.3 12.36,160.64 12.36,158.18 9.85,155.67 v3(9.57,155.67)
  BOTTOM w0.508: v3(9.57,155.67) 9.48,155.76 PR115.2
  vias: v1(7.31,154.37)
8816APSI: length 3.6
  TOP w0.203: PU1.4 13.33,171.27 12.9,171.71 v1(12.9,171.87) PR7.2 PR6.2 PR5.1
8816APVCC: length 5.3
  TOP w0.203: PR11.2 18.04,170.83 PC10.1 18.04,170.38 17.42,169.75 v1(17.42,169.56) 16.99,169.13 PU1.18
8816AREFIN: length 6.6
  TOP w0.203: PU1.7 v1(10.38,169.53) 10.05,169.2 PR27.1 9.82,168.75 9.62,168.54 9.62,168.14 9.37,167.89 PR26.1 8.71,167.89 PC17.1 8.23,168.6 PR21.1
8816ARGDN: length 28.1
  TOP w0.127: PC23.2 11.75,167.07 PC19.1 12.26,167.55 v1(12.31,167.61) 12.13,167.78 PU1.10
  BOTTOM w0.127: PR461.1 28.94,157.9 28.4,158.45 28.4,159.14 27.98,159.56 27.98,160.34 26.56,161.76 20.93,161.76 19.78,162.91 19.78,163.68 18.66,164.81 18.66,168.63 17.9,169.38 15.87,169.38 13.83,167.34 12.57,167.34 v1(12.31,167.61)
8816ASS: length 3.3
  TOP w0.203: PU1.12 13.33,166.5 13.63,166.21 PR571.1 13.33,165.85 13.1,166.08 PC26.1 12.98,166.08 PR572.1
8816ATON: length 5.1
  TOP w0.203: PU1.9 11.4,168.73 v1(10.99,168.32) 10.89,168.32 10.19,167.61 PR573.1 10.19,166.77 10.18,166.76 PC33.1 10.1,166.54 9.72,166.16 8.99,166.16 PR45.1
8816AUGATE1: length 4.3
  TOP w0.762: v1(16.71,173.65) 17.02,173.65 17.25,173.42 PR3.1
  IN4 w0.762: v1(16.71,173.65) 16.27,173.65 v3(14.47,171.85)
8816AUGATE1_1: length 9.4
  TOP w0.762: PQ3.1 20.36,167.41 v1(19.68,168.09) ; PQ2.1 20.38,173.73 v1(20.34,173.78) 19.49,173.78 PR3.2
  IN1 w0.762: v1(20.34,173.78) 20.34,168.75 v1(19.68,168.09)
8816AUGATE2: length 6.4
  TOP w0.762: v3(10.51,164.06) 10.29,163.85 10.29,163.19 PR62.1
  IN4 w0.762: v3(14.85,166.56) 13.86,166.56 11.36,164.06 v3(10.51,164.06)
8816AUGATE2_1: length 9.4
  TOP w0.762: v1(12.59,162.73) 12.57,162.7 v3(12.57,161.87) 11.63,161.87 PQ6.1 11.49,162.01 11.49,163.14 PR62.2
  TOP w1.016: PQ7.1 v3(17.34,162.91)
  IN1 w0.762: v3(12.57,161.87) 16.31,161.87 v3(17.34,162.91)
8816AVREF: length 4.9
  TOP w0.203: PU1.8 11.09,169.13 10.26,168.3 PR27.2 10.05,168.04 9.24,167.22 v1(9.14,167.22) 8.38,167.22 PC21.1
8816AVSNS: length 5.5
  TOP w0.127: PU1.11 12.93,166.65 12.52,166.24 PC26.2 12.26,166.08 PR34.1 11.98,165.22 12.27,164.94 PC30.1 11.83,164.63 11.64,164.44 PR574.1 11.9,164 PC43.1
9336ADJ: length 5.7
  TOP w0.508: PU10.5 94.63,94.23 94.13,94.72 PR133.1 94.07,96.49 v1(94.07,97.24) 94.32,97.24 95.34,96.22 PR134.2
9336DRV: length 9.1
  TOP w0.508: PU10.6 96.21,95.18 PR135.1 97.45,94.49 v1(97.74,94.2) 98.15,94.2 PQ17.4 98.48,93.51 98.04,93.51 97.55,93.03 97.55,91.47 96.85,90.77 PD2.1
9512_5VCC: length 7.6
  TOP w0.14: PU24.12 43.19,44.26 43.22,44.23 43.27,44.23 43.33,44.17 43.46,44.05 43.46,43.67 43.33,43.54 43.33,43.21 43.56,42.97 43.56,42.46 44.22,41.8 44.57,41.8 PC220.1
  TOP w0.203: PC220.1 44.76,41.85 44.97,42.05 45.4,42.05 45.49,41.96 45.74,41.96 v1(45.89,41.81) 46.17,41.54 46.17,41.1 46.88,40.39 PR331.2
9512_ADDR: length 6.2
  TOP w0.14: PU24.26 39.95,49.12 39.85,49.22 39.85,49.76 40.12,50.04 40.94,50.04 41.4,50.5 PR267.1 41.91,50.5 42.08,50.34 42.08,49.86 42.22,49.72 v1(42.43,49.72) 42.59,49.88 42.59,50.39 PR268.2
9512_CH_OC: length 2.4
  TOP w0.14: PU24.3 39.15,42.57 38.87,42.29 38.87,42.29 38.65,42.08 38.41,42.08 v1(38.2,41.87) 38.19,41.86 PR321.2
9512_COMP: length 3.2
  TOP w0.14: PU24.30 38.35,48.78 v1(37.53,49.61) 37.51,49.63 PR274.2 PC197.2
9512_CSNSUM: length 6.2
  TOP w0.14: PU24.21 42.26,48.26 42.47,48.05 43.09,48.05 43.81,48.77 v1(43.81,48.97) 44.05,49.21 44.52,49.21 44.88,49.57 44.99,49.57 45.58,50.16 46.47,50.16 46.68,49.95 PR279.1
9512_CSP1: length 10.5
  TOP w0.14: PU24.20 43.04,47.46 44.06,48.48 v1(44.24,48.48) 44.48,48.48 PR283.2 44.8,49.09 45,49.29 45.1,49.29 45.69,49.88 46.1,49.88 46.37,49.61 46.37,49.32 46.58,49.11 PC203.1
  BOTTOM w0.14: PC203.1 46.58,49.46 46.19,49.84 45.25,49.84 44.53,49.13 44.53,48.78 v1(44.24,48.48) 43.57,48.48 PR519.2
9512_CSP2: length 9.1
  TOP w0.14: PR290.2 46.58,48.2 46.13,48.64 45.68,48.64 45.41,48.38 44.94,48.38 44.8,48.24 PR288.2 44.65,47.79 v1(44.19,47.79) 43.46,47.06 PU24.19
  BOTTOM w0.14: PR290.2 46.58,48.2 46.08,48.7 v1(45.55,48.7) 44.65,47.79 v1(44.19,47.79) 44.17,47.77 PR522.2
9512_CSP3: length 7.7
  TOP w0.14: PU24.18 43.84,46.66 44.09,46.9 44.09,46.98 44.16,47.05 v1(44.16,47.08) 44.8,47.08 PR300.2 44.8,46.82 44.94,46.68 45.44,46.68 45.75,46.99 46.51,46.99 PC206.1
  BOTTOM w0.14: PR524.2 43.69,46.98 43.79,47.08 v1(44.16,47.08) 44.67,47.08 44.76,46.99 46.51,46.99 PC206.1
9512_CSP4: length 7.6
  TOP w0.14: PC208.1 46.43,46.05 45.77,46.05 45.54,45.82 44.98,45.82 44.8,45.99 PR307.2 44.76,46.26 v1(44.08,46.26) PU24.17
  BOTTOM w0.14: PC208.1 46.43,46.05 v1(45.47,46.05) 44.34,46.05 44.12,46.26 v1(44.08,46.26) 43.57,46.26 PR526.2
9512_CSP5: length 7.9
  TOP w0.14: PU24.16 43.46,45.86 43.48,45.84 43.89,45.84 v1(44.21,45.51) 44.65,45.51 PR309.2 44.8,45.1 44.94,44.96 45.44,44.96 45.61,45.12 46.37,45.12 PC210.1
  BOTTOM w0.14: PR528.2 43.6,45.51 v1(44.21,45.51) 44.6,45.12 46.42,45.12 46.58,45.28 PC210.1
9512_CSP6: length 8.2
  TOP w0.14: PU24.15 43.49,45.46 43.72,45.23 43.73,45.23 v1(44.21,44.75) 44.47,44.49 PR313.2 44.8,44.23 44.94,44.09 45.44,44.09 45.54,44.19 46.31,44.19 PC212.1
  BOTTOM w0.14: PR533.2 43.63,44.75 v1(44.21,44.75) 44.77,44.19 v1(45.31,44.19) 46.31,44.19 PC212.1
9512_CSP7: length 9
  TOP w0.14: PC213.1 46.08,43.23 45.06,43.23 44.8,43.49 PR316.1 44.37,43.63 44.22,43.48 v1(44.19,43.48) 44.19,44.1 43.75,44.54 43.75,44.76 43.46,45.06 PU24.14
  BOTTOM w0.14: PC213.1 46.08,43.23 44.44,43.23 v1(44.19,43.48) 43.84,43.83 PR537.2
9512_CSP8: length 9.7
  TOP w0.14: PU24.13 43.24,44.66 43.47,44.43 43.47,44.43 43.73,44.16 43.73,43.56 43.62,43.45 43.62,43.3 44.05,42.88 v1(44.05,42.85) 44.08,42.85 44.16,42.76 PR318.1 44.8,42.51 44.95,42.36 45.53,42.36 45.59,42.3 45.96,42.3 46.58,42.92 PC215.1
  BOTTOM w0.14: PR539.2 43.85,43.04 v1(44.05,42.85) 44.46,42.43 v1(45.14,42.43) 45.19,42.43 45.34,42.28 45.95,42.28 46.58,42.92 PC215.1
9512_CSPSUM: length 8.1
  TOP w0.14: PR256.1 46.63,51.46 46.43,51.25 46.43,50.57 46.3,50.44 45.2,50.44 v1(44.88,50.12) 44.88,49.97 44.41,49.49 43.47,49.49 43.16,49.18 43.16,48.88 42.88,48.6 42.5,48.6 42.26,48.84 42.26,48.84 42.14,48.97 41.76,48.97 41.64,48.84 41.58,48.78 41.58,48.45 41.55,48.42 PU24.22
9512_DAC: length 7.3
  TOP w0.14: PU24.28 39.15,49.01 39.27,49.13 39.27,49.87 39.03,50.11 39.03,51.17 PC188.2 37.88,52.31 v1(37.88,52.4)
  BOTTOM w0.14: v1(37.88,52.4) 37.88,52.51 38.34,52.97 38.85,52.97 39.05,52.77 PC411.2 39.05,52.2 39.08,52.17 PR511.2
9512_EAP: length 2.2
  TOP w0.14: PR275.1 38.5,49.98 38.8,49.68 v1(38.8,49.54) 38.8,49.13 38.75,49.08 PU24.29
9512_EN: length 8.3
  TOP w0.14: v1(36.5,45.66) 36.57,45.66 36.78,45.46 PU24.36 ; v1(32.49,44.19) 32.72,44.41 PQ28.3
  IN2 w0.089: v1(32.49,44.19) 32.64,44.34 34.41,44.34 35.7,45.63 36.47,45.63 v1(36.5,45.66)
  BOTTOM w0.14: PR531.2 31.82,44.47 PR535.2 31.87,44.19 v1(32.49,44.19)
9512_EN_1: length 6.2
  TOP w0.14: PC217.1 29.73,41.44 29.96,41.21 PR320.1 ; PC217.1 29.13,41.85 v1(28.85,41.57) ; PC217.1 30.03,41.85 30.7,41.18 PQ31.2 31.06,40.73 PD7.2 32.39,39.97 32.51,39.85 PR332.2
9512_EN_S: length 91.3
  TOP w0.14: v1(29.48,53.76) 29.99,53.25 33.42,53.25 33.85,53.69 35.53,53.69 36.07,53.14 39.4,53.14 39.42,53.13 ; v1(29.48,53.76) 29.48,54.38 PR222.1 ; v1(29.48,53.76) 28.89,53.17 22.4,53.17 21.91,53.66 21.63,53.66 21.51,53.79 20.57,53.79 19.95,54.4 PR219.1 ; 67.98,53.81 68.07,53.73 72.88,53.73 73.43,53.18 73.8,53.18 74.24,53.62 74.59,53.62 74.82,53.39 74.82,52.93 76.12,51.63 77.1,51.63 78.08,52.62 78.37,52.62 ; 67.98,53.81 66.84,53.81 66.55,53.52 63.18,53.52 62.99,53.71 59.11,53.71 PR231.2 58.03,54.02 57.42,54.02 56.64,53.23 56.36,53.23 55.77,53.81 55.06,53.81 54.45,53.2 53.71,53.2 53.54,53.38 49.01,53.38 48.76,53.14 ; 67.98,53.81 68.07,53.9 PR234.2 ; PR240.2 87.37,53.66 86.64,52.93 81.28,52.93 80.84,53.37 79.23,53.37 79.04,53.18 79.04,52.9 78.76,52.62 78.37,52.62 ; PR225.2 39.11,54.22 39.45,53.88 39.45,53.16 39.42,53.13 ; 48.76,53.14 48.75,53.13 42.72,53.13 42.13,53.71 40.76,53.71 40.18,53.13 39.42,53.13 ; 48.76,53.14 PR228.2 ; 78.37,52.62 78.41,52.66 78.41,53.88 77.9,54.4 PR237.2
  IN1 w0.14: v1(29.48,53.76) 29.99,53.25 30.75,53.25 31.13,52.87 31.13,49.06 32.39,47.8 v1(32.39,47.08)
  BOTTOM w0.14: v1(32.39,47.08) 32.38,47.08 31.9,46.6 31.9,46.11 PR531.1
9512_FB: length 6.5
  TOP w0.14: PU24.31 37.35,47.66 37.35,48.71 37.13,48.93 PR284.2 36.65,48.93 36.39,49.19 35.35,49.19 PR281.1 35.3,50.05 v1(35.34,50.09) 35.34,50.48 34.95,50.86 PR260.2 35.31,51.08 35.37,51.02 PR262.2
9512_FBRTN: length 30.3
  TOP w0.14: v1(36.21,41.84) 36.21,40.63 36.98,39.86 36.98,39.46 36.67,39.16 36.08,39.16 PC225.2 35.1,39.2 34.31,39.2 PR334.2 33.84,40.89 PC221.2 ; v1(36.62,52.56) 36.92,52.86 38.11,52.86 PC188.1 ; PC205.1 35.75,48.3 PC204.2 36.76,47.94 v1(36.79,47.96) 36.83,47.92 36.83,47.27 37.04,47.06 PU24.32
  IN3 w0.089: v1(36.21,41.84) 36.72,42.36 36.72,43.35 37.05,43.68 37.05,47.7 v1(36.79,47.96)
  BOTTOM w0.14: v1(36.62,52.56) 36.06,53.13 34.54,53.13 33.87,52.46 33.87,50.2 34.43,49.65 34.82,49.65 PR515.1 35.23,49.58 35.2,49.55 PR517.1 35.2,48.96 35.48,48.68 36.07,48.68 v1(36.79,47.96)
9512_IMON: length 6.5
  TOP w0.14: PU24.25 40.35,49.39 v1(40.4,49.44) ; v1(43.07,49.83) 43.18,49.83 43.77,50.41 PR273.1
  IN1 w0.14: v1(43.07,49.83) 42.74,50.16 40.84,50.16 40.4,49.72 v1(40.4,49.44)
  BOTTOM w0.14: PR273.1 43.66,50.41 v1(43.07,49.83)
9512_LPC: length 7.9
  TOP w0.14: PR261.1 45.26,50.89 45.16,50.79 PR264.2 44.21,50.16 v1(44.21,49.95) ; PU24.24 40.75,49.14 41.17,49.55 v1(41.17,49.57)
  IN2 w0.14: v1(41.17,49.57) 42.18,48.56 43.07,48.56 44.21,49.7 v1(44.21,49.95)
9512_PGOOD: length 4.2
  TOP w0.14: PR312.1 35.26,44.65 36.05,44.65 v1(36.1,44.6) 36.23,44.48 36.86,44.48 37.04,44.66 PU24.38
  BOTTOM w0.14: PR527.2 35.17,45.35 35.92,44.6 v1(36.1,44.6)
9512_PSI: length 8.4
  TOP w0.14: v1(36.65,44.95) 36.65,44.95 36.77,45.06 PU24.37 ; PR311.1 34.15,45.19 34.4,45.19 34.72,45.51 PR308.1 34.72,45.77 35.01,46.06 35.96,46.06 v1(35.98,46.04)
  BOTTOM w0.14: v1(35.98,46.04) 36.18,46.24 36.62,46.24 36.97,45.89 36.97,45.26 36.65,44.95 v1(36.65,44.95) 36.65,44.41 36.37,44.14 35.54,44.14 35.17,44.51 PR532.2
9512_PWM1: length 4.8
  TOP w0.14: PU24.11 42.75,43.39 43.28,42.86 43.28,42.34 43.89,41.74 43.89,41.52 v1(44.21,41.19) 44.53,40.87 PR330.2
  BOTTOM w0.14: v1(44.21,41.19) 44.44,40.97 PR548.2
9512_PWM1_S: length 54.5
  TOP w0.14: v1(86.1,55.53) 86.1,55.84 86.05,55.89 PU21.34
  IN3 w0.14: v1(86.1,55.53) 85.69,55.12 82.48,55.12 82.22,55.37 81.23,55.37 80.95,55.09 76.09,55.09 75.87,54.87 73.27,54.87 71.98,53.59 70.13,53.59 69.15,54.58 63.34,54.58 62.51,53.75 59.76,53.75 59.25,54.26 55.74,54.26 54.43,52.94 53.61,52.94 53.23,53.33 50.33,53.33 49.83,52.83 49.83,50.23 49.47,49.87 49.47,45.61 48.9,45.04 48.9,43.89 48.45,43.44 v1(48.22,43.44)
  BOTTOM w0.14: PR548.1 45.96,41.6 47.03,41.6 47.47,42.04 47.47,42.87 48.04,43.44 v1(48.22,43.44)
9512_PWM2: length 4.2
  TOP w0.14: PU24.10 41.95,42.72 42.12,42.54 42.66,42.54 v1(42.8,42.4) 42.8,42.34 43.35,41.79 PR328.2
  BOTTOM w0.14: v1(42.8,42.4) 42.8,42.34 43.35,41.79 PR328.2
9512_PWM2_S: length 47.2
  TOP w0.14: v1(76.47,55.54) 76.4,55.61 PU20.34 ; v1(43.22,40.07) 43.35,40.19 PR328.1
  IN3 w0.14: v1(43.22,40.07) 43.17,40.12 43.17,40.32 43.62,40.76 44.8,40.76 47.59,43.55 47.59,45.29 49.11,46.81 49.11,50.09 49.52,50.5 49.52,52.86 50.25,53.59 53.48,53.59 53.8,53.27 54.41,53.27 55.64,54.5 59.81,54.5 60.32,53.99 62.41,53.99 63.24,54.82 69.25,54.82 70.23,53.83 71.81,53.83 73.09,55.12 75.71,55.12 76.13,55.54 v1(76.47,55.54)
9512_PWM3: length 3.2
  TOP w0.14: PU24.9 41.55,42.57 41.76,42.36 41.91,42.36 v1(42.41,41.85) 42.61,41.65 PR327.2
  BOTTOM w0.14: v1(42.41,41.85) 42.61,41.65 PR327.2
9512_PWM3_S: length 38.9
  TOP w0.14: v1(42.55,40.07) 42.61,40.13 PR327.1 ; v1(66.82,55.54) 66.75,55.61 PU19.34
  IN3 w0.14: v1(42.55,40.07) 42.49,40.12 42.49,40.32 44.12,41.94 44.43,41.94 44.43,41.94 45.64,41.94 47.34,43.65 47.34,48.12 48.07,48.85 48.07,49.46 47.13,50.4 47.13,51.23 47.61,51.71 47.61,52.68 48.3,53.37 48.3,54.06 48.63,54.39 50.21,54.39 50.49,54.12 53.77,54.12 54.4,54.74 57.61,54.74 57.98,55.12 66.4,55.12 v1(66.82,55.54)
9512_PWM4: length 2.9
  TOP w0.14: PU24.8 41.15,42.5 41.64,42.01 v1(41.64,41.86) 41.88,41.62 PR326.2
  BOTTOM w0.14: v1(41.64,41.86) 41.88,41.62 PR326.2
9512_PWM4_S: length 29.3
  TOP w0.14: PR326.1 41.88,40.07 v1(41.88,40.07) ; PU18.34 57.1,55.55 v1(57.17,55.48)
  IN3 w0.14: v1(41.88,40.07) 41.88,40.12 43.93,42.18 44.33,42.18 45.37,43.22 46.32,43.22 47.09,43.99 47.09,49.71 46.65,50.15 46.65,51.18 47.09,51.63 47.09,52.64 48.06,53.61 48.06,54.16 48.68,54.78 50.27,54.78 50.61,54.44 53.76,54.44 54.42,55.11 56.8,55.11 v1(57.17,55.48)
9512_PWM5: length 3
  TOP w0.14: PU24.7 40.75,42.24 v1(40.91,42.08) 40.91,41.41 PR325.2
  BOTTOM w0.14: PR325.2 40.91,41.41 v1(40.91,42.08)
9512_PWM5_S: length 20.8
  TOP w0.14: v1(41.21,40.07) 41.14,40.13 PR325.1 ; v1(47.52,55.54) 47.44,55.61 PU17.34
  IN3 w0.14: v1(47.52,55.54) 46.58,54.6 46.58,51.56 46.17,51.15 46.17,50.28 46.58,49.88 46.58,45.43 46.23,45.08 45.58,45.08 45.23,44.73 45.23,43.91 44.86,43.54 44.86,43.06 44.23,42.42 43.79,42.42 42.56,41.19 42.06,41.19 41.21,40.34 v1(41.21,40.07)
9512_PWM6: length 2.7
  TOP w0.14: PR324.2 40.4,41.72 40.29,41.83 v1(40.29,41.86) 40.29,42.21 40.35,42.27 PU24.6
  BOTTOM w0.14: v1(40.29,41.86) 40.29,41.83 40.4,41.72 PR324.2
9512_PWM6_S: length 19.5
  TOP w0.14: v1(40.55,40.07) 40.55,40.59 PR324.1 ; v1(37.86,55.54) 37.79,55.61 PU16.34
  IN3 w0.14: v1(40.55,40.07) 40.55,40.38 39.87,41.06 38.78,41.06 38.12,41.72 38.12,46.52 39.08,47.49 39.08,54.32 v1(37.86,55.54)
9512_PWM7: length 2.8
  TOP w0.14: PU24.5 39.95,42.47 39.59,42.1 v1(39.59,41.94) 39.67,41.85 PR323.2
  BOTTOM w0.14: v1(39.59,41.94) 39.67,41.85 PR323.2
9512_PWM7_S: length 27
  TOP w0.14: PU15.34 28.14,55.61 v1(28.21,55.54) ; v1(39.9,40.06) 39.9,40.5 PR323.1
  IN3 w0.14: v1(28.21,55.54) 29.13,55.54 31.18,53.48 33.22,53.48 34.87,51.83 38.47,51.83 38.84,51.46 38.84,47.59 37.88,46.62 37.88,41.62 38.68,40.82 39.48,40.82 39.9,40.4 v1(39.9,40.06)
9512_PWM8: length 4.3
  TOP w0.14: PU24.4 39.55,42.57 38.94,41.95 v1(38.94,41.71) 38.93,41.7 PR322.2
  BOTTOM w0.14: v1(38.94,41.71) 38.57,42.08 v1(38.25,42.08) 38.25,41.57 38.63,41.19 PR322.2
9512_PWM8_S: length 37.7
  TOP w0.14: v1(39.25,40.06) 39.25,40.41 PR322.1 ; PU14.34 18.49,55.89 19.37,55.01 19.37,53.86 19.93,53.31 21.06,53.31 21.23,53.14 v1(21.72,53.14)
  IN3 w0.14: v1(39.25,40.06) 38.74,40.58 38.58,40.58 37.64,41.52 37.64,46.72 38.6,47.69 38.6,51.36 38.37,51.59 34.77,51.59 33.15,53.2 27.78,53.2 27.2,53.79 27.2,54.09 26.74,54.55 24.97,54.55 23.93,53.51 23.18,53.51 23.04,53.36 21.89,53.36 21.72,53.19 v1(21.72,53.14)
9512_REFADJ: length 2.5
  TOP w0.14: PR315.2 35.35,43.67 v1(36.31,43.67) 36.88,43.67 37.06,43.86 PU24.40
9512_REFIN: length 5.8
  TOP w0.14: PU24.1 37.88,43.06 37.29,42.47 v1(36.85,42.47) 36.12,42.47 PR319.2 35.56,41.44 35.59,41.41 PR329.2 35.59,40.44 36.35,39.68 PC225.1
9512_REFOUT: length 9.5
  TOP w0.14: v1(47.77,50.71) PR278.1 ; v1(42.69,49.06) 42.51,49.24 41.5,49.24 41.15,48.9 PU24.23
  IN1 w0.14: v1(42.69,49.06) 42.94,49.06 43.63,49.75 43.63,50.11 44.97,51.44 47.04,51.44 v1(47.77,50.71)
9512_SCL: length 2.7
  TOP w0.14: PR305.1 36.39,46.52 37.05,45.86 PU24.35
9512_SDA: length 2.9
  TOP w0.14: PR297.1 35.72,46.86 35.92,46.86 35.93,46.88 35.95,46.88 v4(35.96,46.89) 35.97,46.88 35.99,46.88 36.04,46.83 36.48,46.83 37.05,46.26 PU24.34
9512_TSENSE: length 3.4
  TOP w0.14: PU24.33 37.04,46.66 36.4,47.31 v1(36.31,47.31)
  BOTTOM w0.14: PR520.1 35.17,47.7 35.56,47.31 v1(36.31,47.31)
9512_VID: length 3.9
  TOP w0.14: PU24.39 37.04,44.26 36.91,44.14 35.48,44.14 35.27,44.35 34.62,44.35 34.13,43.86 PR314.2
9512_VINMON: length 3.4
  TOP w0.14: PU24.27 39.55,50.02 39.49,50.08 PR265.1 PR266.1
9512_VREF: length 7
  TOP w0.14: PR317.2 35.68,43.05 v1(37.15,43.05) ; PU24.2 38.75,42.57 38.54,42.36 37.71,42.36 37.46,42.1 PC223.1 37.1,41.19 36.86,41.42 v1(36.86,41.8)
  BOTTOM w0.14: v1(37.15,43.05) 36.86,42.76 v1(36.86,41.8)
9619_BST1: length 3.2
  TOP w0.14: v1(84.22,53.64) 85.07,54.48 PR216.1 85.62,55.23 85.62,55.73 85.6,55.75 PU21.33
9619_BST2: length 1.9
  TOP w0.14: PU20.33 75.95,55.82 75.94,55.81 75.94,55.76 75.96,55.73 75.96,55.23 PR215.1
9619_BST3: length 1.8
  TOP w0.14: PR210.1 66.31,55.28 66.31,55.73 66.3,55.75 PU19.33
9619_BST4: length 1.9
  TOP w0.14: PR214.1 56.66,55.23 56.66,55.73 56.63,55.76 56.63,55.81 56.65,55.82 PU18.33
9619_BST5: length 2.9
  TOP w0.14: PU17.33 46.99,55.75 47.01,55.73 47.01,55.23 PR213.1 46.46,53.68 v1(46.5,53.64)
9619_BST6: length 2.9
  TOP w0.14: v1(36.85,53.64) 36.81,53.68 PR212.1 37.36,55.23 37.36,55.73 37.34,55.75 PU16.33
9619_BST7: length 1.9
  TOP w0.14: PR211.1 27.7,55.23 27.7,55.73 27.69,55.75 PU15.33
9619_BST8: length 5.8
  TOP w0.254: PU14.33 18.04,55.46
  TOP w0.508: 18.04,55.46 v1(18.04,55.09) 18.04,55.05 17.48,54.49 17.48,53.81 16.98,53.3 16.98,52.51 16.13,51.66 PR257.1
9619_PHASE1: length 1.9
  TOP w0.14: v1(85.15,55.54) PU21.32
  BOTTOM w0.14: v1(85.15,55.54) 85.37,55.33 PC403.2
9619_PHASE2: length 3.7
  TOP w0.14: v1(75.5,55.54) PU20.32
  BOTTOM w0.14: PC404.2 75.28,54.58 74.95,54.91 74.95,56.05 v1(75.2,56.3) 75.2,55.84 v1(75.5,55.54)
9619_PHASE3: length 3.5
  TOP w0.14: v1(65.85,55.54) PU19.32
  BOTTOM w0.14: PC402.2 65.3,55.19 65.3,56.05 v1(65.55,56.3) 65.85,56.01 v1(65.85,55.54)
9619_PHASE4: length 3.6
  TOP w0.14: PU18.32 v1(56.2,55.54)
  BOTTOM w0.14: PC405.2 56,54.68 55.64,55.03 55.64,55.92 v1(56.03,56.3) 56.03,55.71 v1(56.2,55.54)
9619_PHASE5: length 3.6
  TOP w0.14: v1(46.54,55.54) PU17.32
  BOTTOM w0.14: v1(46.54,55.54) 46.54,56.01 v1(46.25,56.3) 45.99,56.05 45.99,55.16 46.46,54.69 PC406.2
9619_PHASE6: length 3.6
  TOP w0.14: v1(36.89,55.54) PU16.32
  BOTTOM w0.14: PC407.2 36.81,54.69 36.34,55.16 36.34,55.92 v1(36.72,56.3) 36.72,55.71 v1(36.89,55.54)
9619_PHASE7: length 3.7
  TOP w0.14: v1(27.24,55.54) PU15.32
  BOTTOM w0.14: v1(27.24,55.54) 27.24,56.01 v1(26.94,56.3) 26.69,56.05 26.69,54.91 26.92,54.68 PC408.2
9619_PHASE8: length 3.8
  TOP w0.254: PU14.32 17.59,55.82 17.35,55.59 17.35,55.38
  TOP w0.508: 17.35,55.38 17.35,55.28 16.81,54.73 v1(16.81,54.1) 16.17,53.45 PC184.2
9619_SW1:
  vias: v1(83.08,62.86)
9619_SW2:
  vias: v1(73.39,62.89)
9619_SW3:
  vias: v1(63.85,62.78)
9619_SW4:
  vias: v1(53.94,62.92)
9619_SW5:
  vias: v1(44.55,62.84)
9619_SW6:
  vias: v1(34.84,62.73)
9619_SW7:
  vias: v1(25.3,62.89)
9619_SW8:
  vias: v1(22.13,62.05)
9619_VOS1: length 17.7
  TOP w0.203: PR160.1 91.3,71.57 v1(91.46,71.42) 91.08,71.03 v1(90.7,71.03) ; PU21.1 89.15,56.92 v1(89.5,57.27)
  IN1 w0.203: v1(89.5,57.27) 91.18,58.95 91.18,60.54 91.61,60.98 91.61,62.3 91.13,62.78 91.13,70.6 v1(90.7,71.03)
9619_VOS2: length 18.6
  TOP w0.203: v1(82.31,71.16) 81.9,71.57 PR159.1 ; PU20.1 79.6,56.92 79.61,56.94 80.49,56.94 v1(80.61,56.82)
  IN1 w0.203: v1(80.61,56.82) 80.61,58.56 80.8,58.75 80.8,65.31 83.33,67.85 83.33,70.15 v1(82.31,71.16)
9619_VOS3: length 19.1
  TOP w0.203: v1(71.09,56.91) 69.96,56.91 69.94,56.92 PU19.1 ; v1(72.79,71.42) 72.63,71.57 PR158.1
  IN1 w0.203: v1(72.79,71.42) 74.06,70.15 74.06,68.23 70.97,65.14 70.97,57.02 v1(71.09,56.91)
9619_VOS4: length 18.9
  TOP w0.203: PU18.1 61.33,56.92 v1(61.36,56.89) ; PR157.1 62.68,71.57 v1(62.99,71.26)
  IN1 w0.203: v1(61.36,56.89) 61.18,57.07 61.18,65 64.03,67.85 64.03,70.22 v1(62.99,71.26)
9619_VOS5: length 19.2
  TOP w0.203: v1(51.77,56.91) 51.03,56.91 51.02,56.92 PU17.1 ; v1(53.56,71.21) 53.2,71.57 PR156.1
  IN1 w0.203: v1(53.56,71.21) 54.51,70.26 54.51,67.99 51.53,65 51.53,57.16 v1(51.77,56.91)
9619_VOS6: length 19.7
  TOP w0.203: v1(43.94,71.37) 43.73,71.57 PR155.1 ; PU16.1 42.12,56.92 v1(42.15,56.89)
  IN1 w0.203: v1(42.15,56.89) 41.89,57.15 41.89,65.15 45.09,68.35 45.09,70.65 44.37,71.37 v1(43.94,71.37)
9619_VOS7: length 18.8
  TOP w0.203: v1(32.36,56.81) 32.24,56.92 PU15.1 ; PR154.1 33.64,71.57 v1(34.05,71.16)
  IN1 w0.203: v1(34.05,71.16) 35.07,70.15 35.07,68.24 32.48,65.65 32.48,57.24 32.36,57.12 v1(32.36,56.81)
9619_VOS8: length 17.1
  TOP w0.203: v1(23.39,70.78) PR153.1 ; PU14.1 21.53,56.92 21.68,57.08 22.54,57.08 v1(22.7,57.24) 23.15,57.7 v1(23.15,58.86)
  IN1 w0.203: v1(23.15,58.86) 23.17,58.86 22.24,59.78 22.24,69.64 v1(23.39,70.78)
24780_ACDET: length 7.5
  TOP w0.178: PU23.6 96.2,52.33 96.74,51.79 v1(97.15,51.79) 97.4,51.79 PR258.2 97.48,51.14 97.48,49.93 97.3,49.75 97.3,48.92 97.12,48.75 PR282.2
  BOTTOM w0.14: PR499.2 v1(96.69,52.62) 96.97,52.34 96.97,51.96 v1(97.15,51.79)
24780_ACDRV: length 2.1
  TOP w0.178: PR270.2 95.47,51.1 95.62,51.25 95.65,51.28 95.65,51.96 95.4,52.22 PU23.4
24780_ACN: length 134.5
  TOP w0.14: PR69.2 105.24,161.45 104.98,161.19 v1(104.98,159.65)
  TOP w0.178: v1(89.51,49.09) 89.98,49.57 89.98,50.43 90.25,50.7 PC199.1 91.34,50.7 91.5,50.86 PC196.2 91.85,51.08 93.09,52.32 94.02,52.32 94.2,52.49 PU23.1
  IN2 w0.089: v1(89.51,49.09) 89.51,49.3 91.2,50.99 92.39,50.99 93.4,52.01 93.73,52.01 94.8,53.08 94.8,56.1 95.32,56.62 95.82,56.62 96.1,56.89 96.1,58.73 94.89,59.93 94.89,61.38 95.68,62.17 95.68,64.53 95.53,64.69 95.53,68.57 100.87,73.92 100.87,75.74 101.39,76.27 101.39,77.46 102.64,78.7 103.75,78.7 106.09,81.04 106.09,83.65 106.7,84.26 106.7,85.89 105.12,87.47 105.12,88.83 103.99,89.96 103.99,92.44 103.75,92.69 103.75,97 105.55,98.81 105.55,110.93 106.22,111.6 106.22,144.06 102.57,147.71 102.57,150.55 103.27,151.25 103.27,157.48 104.52,158.73 104.52,159.19 v1(104.98,159.65)
24780_ACP: length 134.9
  TOP w0.14: v1(105.02,158.96) 105.45,159.39 PR70.2
  TOP w0.178: PU23.2 94.6,52.33 94.57,52.3 94.25,51.98 93.3,51.98 92.63,51.32 PC196.1 92.94,50.55 PC200.2 92.21,49.16 91.61,49.16 90.9,48.45 90.2,48.45 90.02,48.63 v1(90.02,48.65)
  IN2 w0.089: v1(105.02,158.96) 103.46,157.4 103.46,151.17 102.76,150.47 102.76,147.79 106.42,144.13 106.42,111.52 105.74,110.85 105.74,98.73 103.94,96.92 103.94,92.86 104.18,92.62 104.18,90.04 105.31,88.91 105.31,87.55 106.89,85.97 106.89,84.18 106.28,83.57 106.28,80.96 103.83,78.51 102.72,78.51 101.58,77.38 101.58,76.19 101.06,75.66 101.06,73.84 95.72,68.49 95.72,65.13 95.87,64.97 95.87,62.07 95.09,61.29 95.09,60 96.29,58.81 96.29,56.81 95.9,56.43 95.4,56.43 94.99,56.02 94.99,53 93.81,51.82 93.48,51.82 92.46,50.79 91.27,50.79 90.02,49.55 v1(90.02,48.65)
