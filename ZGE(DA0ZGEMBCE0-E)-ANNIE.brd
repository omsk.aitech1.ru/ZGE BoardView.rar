# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N25255394: length 1.5
  TOP w0.508: PR310.2 PC207.1
N25255413: length 2.1
  TOP w0.14: PC183.2 89.86,53.25 v1(89.63,53.49) 89.63,54.06 PR243.2
N25255423: length 3.6
  TOP w0.14: PR70.1 106.08,160.88 108.59,160.88 108.73,160.74 108.73,160.12
N25255465: length 2.8
  TOP w0.508: PQ32.4 63.77,45.39 63.9,45.51 PC209.2 63.41,45.7 PR303.1
N25255510: length 1.5
  TOP w0.14: v1(98.23,54.82) 98.19,54.78 PU23.11
  BOTTOM w0.14: v1(98.23,54.82) 98.23,54.94 PR497.2
N25255512: length 2.7
  TOP w0.14: v1(98.74,55.21) 98.64,55.32 97.94,55.32 97.8,55.18 PU23.12
  BOTTOM w0.14: PR498.2 97.86,55.94 98.59,55.21 v1(98.74,55.21)
N25255513: length 2
  TOP w0.178: PU23.7 96.6,52.47 96.77,52.29 97.02,52.29 97.37,52.63 PR254.2
N25255515: length 1.1
  TOP w0.178: PU23.9 98.16,53.98 98.17,53.97 PR252.2
N25255534: length 1.7
  TOP w0.178: PR263.2 96.28,51.78 95.8,52.26 PU23.5
N25255538: length 3.9
  TOP w0.152: PU23.15 96.6,57 96.75,57.15 96.96,57.15 97,57.12 97.74,57.12 97.75,57.12 97.87,57.12 98.23,57.48 98.23,57.93 98.53,58.24 PR183.2 PR184.2
N25255547: length 1.5
  TOP w0.178: PR253.2 98.46,53.17 98.23,52.93 98.04,52.93 PU23.8
N25272043: length 1.3
  TOP w0.254: PC271.1 168.16,19.47 168.22,19.54 PR418.2
N25430953: length 3.4
  TOP w0.508: PR91.2 177.71,154.73 v1(178.6,153.84) PQ9.3
N25430988: length 2.9
  TOP w0.508: PQ8.3 178.09,156.57 177.58,156.06 v1(177.44,156.06) 176.87,156.06 PR80.2
N25430994: length 2.3
  BOTTOM w0.14: PQ51.3 v1(218.2,54.52) 217.43,54.52 PR496.2
N25431520: length 1.5
  TOP w0.508: PR109.2 178.36,148.76 PQ11.3
N25506822: length 1.7
  TOP w0.254: PR421.2 164.2,18.04 PC278.1
N25506978: length 119.2
  TOP w0.14: PQ19.2 181.22,57.45 v1(181.22,56.43) 181.22,56.15 180.86,55.79 PR217.1 181.31,55.46 181.52,55.25 PR195.2 182.38,55.21 183.2,55.21 183.85,54.55 PQ21.2 183.85,53.65 183.46,53.25 181.8,53.25 181.41,52.87 181.41,52.28 PQ23.3 182.09,52.63 v1(182.09,52.79)
  IN1 w0.086: v1(234.23,43.6) 234.23,42.92 234.82,42.33 234.82,41.65 234.16,40.99 234.16,39.62 235.09,38.69 235.09,36.71 234.19,35.82 234.19,34.23 235.51,32.91 235.51,30.88 237.52,28.87 237.52,27.82 237.57,27.77 237.57,27.02 237.87,26.72 237.87,26.59 239.49,24.96 240.32,24.96 240.58,24.71 240.58,23.99 240.89,23.69 243.81,23.69 244.18,23.32 244.18,22.71 244.6,22.29 245.23,22.29 245.61,21.91 245.61,20.59 v1(245.08,20.06)
  IN3 w0.089: v1(182.09,52.79) 182.09,52.26 184.18,50.18 186.74,50.18 187.78,49.14 188.39,49.14 189.19,49.94 189.19,54.6 188.25,55.54 188.25,56.06 192.42,60.23 193.2,60.23 194.13,59.3 194.13,58.43 197.69,54.88 197.69,53.53 198.49,52.72 200.7,52.72 201.54,51.88 208.13,51.88 209.54,50.47 214.08,50.47 215.89,52.28 217.29,52.28 220.52,49.05 221.84,49.05 223.65,47.24 228.5,47.24 230.65,45.09 232.34,45.09 233.37,44.06 233.77,44.06 v1(234.23,43.6)
  BOTTOM w0.14: v1(245.08,20.06) 245.46,20.06 246.13,19.38 PQ57.2
N25507004: length 8.8
  TOP w0.14: PR172.2 179.27,61.04 179.27,59.75 PQ19.3 182.23,59.1 183.33,60.2 183.33,60.93 v1(182.49,61.76)
N25507051: length 16.5
  TOP w0.203: PR420.2 172.13,18.76 170.81,20.08 v1(170.81,20.64) ; PR382.2 161.64,25.49 v1(161.87,25.26)
  IN1 w0.203: v1(170.81,20.64) 170.31,20.14 167.16,20.14 166.95,19.93 166.08,19.93 165.22,20.79 165.22,23.31 163.72,24.81 162.32,24.81 v1(161.87,25.26)
N25932926: length 1.5
  TOP w0.14: v1(221.43,31.89) 221.43,31.62 U14.AL37
  BOTTOM w0.14: v1(221.43,31.89) 220.99,32.34 TP97.1
N25932929: length 1.5
  TOP w0.14: U14.AN35 220.63,29.84 v1(220.63,29.63)
  BOTTOM w0.14: TP102.1 220.63,29.81 v1(220.63,29.63)
N27414743: length 3.2
  TOP w0.14: R90.1 164.36,114.17 R88.1 164.39,114.78 v1(164.63,115.02) 165.39,115.02 Q10.2
N27414752: length 9.1
  TOP w0.14: Q10.3 169.33,113.71 170.23,112.81 170.23,110.77 v1(170.17,110.71) 168.58,109.12 R96.2 167.91,109.54 167.94,109.57 Q12.2
N28089072: length 1
  TOP w0.203: PR66.2 167.47,162.55 167.42,162.61 PU4.30
N28585230: length 1
  TOP w0.203: PU6.30 156.61,162.56 156.68,162.63 PR65.2
N28673613: length 15.6
  TOP w0.203: PR76.1 171.06,159.57 v1(171.06,157.73) 171.06,152.24 169.23,150.41 166.13,150.41 165.5,149.77 PR111.1
N31399389: length 7.1
  TOP w0.14: R290.1 96.18,35.42 C276.1 96.72,35.91 96.11,35.91 95.9,36.11 95.9,36.82 96.06,36.97 Q30.2 97.55,36.97 97.93,37.36 v1(97.93,37.59) 97.9,37.62 Q30.3
N31399469: length 6.6
  TOP w0.14: R260.1 96.67,38.01 96.03,38.01 95.62,37.61 95.62,35.91 95.68,35.85 R290.2 95.55,35.47 95.17,35.86 93.87,35.86 93.82,35.81 R286.1
N31810763: length 4.1
  TOP w0.14: R106.1 179.48,103.47 179.19,103.17 178.8,103.17 178.37,103.6 Q17.3 177.68,103.6 177.38,103.91 v1(177.38,104.09) 177.38,104.48 Q15.2
N31810778: length 5.2
  TOP w0.14: R94.1 v1(179.94,110.15) 179.6,110.15 179.4,110.35 Q13.3 179.4,112.32 Q11.2
N32113508: length 3
  BOTTOM w0.14: CN15.56 197.86,39.25 198.24,39.64 198.24,40.48 TP72.1
N32113521: length 2.2
  BOTTOM w0.14: TP76.1 198.86,39.76 197.86,38.75 CN15.58
N32686297: length 2.9
  TOP w0.14: R401.1 67.19,26.65 67.37,26.47 67.62,26.47 68.07,26.03 v1(68.07,25.91) 68.15,25.82 U18.20
N32913947: length 5.2
  TOP w0.14: R432.1 202.83,23.28 U14.BE1 U14.BD1 203.79,24.54 U14.BE2
N32915328: length 8
  TOP w0.14: v1(206.01,24.74) 205.81,24.55 205.69,24.55 U14.BE5
  BOTTOM w0.14: R978.1 199.79,23.88 202.94,23.88 203.34,24.28 204.83,24.28 205.28,24.74 v1(206.01,24.74)
N32915331: length 6.3
  TOP w0.14: v1(205.46,23.77) 205.25,23.77 U14.BE4
  BOTTOM w0.14: v1(205.46,23.77) 205.19,24.04 203.44,24.04 202.82,23.42 v1(200.96,23.42) 200.14,23.42 R990.1
N33266977: length 4.7
  TOP w0.14: v1(66.54,28.28) 66.98,27.84 R389.2 67.44,27.63 67.53,27.54 68.52,27.54 68.55,27.51 68.64,27.42 U18.16
  BOTTOM w0.14: R925.2 65.69,28.11 66.38,28.11 v1(66.54,28.28)
N33344868: length 3.8
  TOP w0.089: U3.A37 119.3,130.66 118.96,130.66 118.08,131.54
  TOP w0.14: R43.2 117.92,131.69 118.08,131.54
N33344911: length 5.2
  TOP w0.089: U3.BT2 160.72,104.95 161.85,104.95 162.83,105.93 162.83,106.17 163.92,107.26 TP10.1
N33344918: length 6.3
  TOP w0.089: TP11.1 165.27,105.91 163.09,105.91 161.93,104.75 159.79,104.75 U3.BR1
N33344928: length 3.9
  TOP w0.089: U3.A36 119.55,130.19 119.27,130.48 118.84,130.48 118.11,131.21 117.75,131.21
  TOP w0.14: 117.75,131.21 116.79,131.21 R48.2
N33355782: length 2.2
  TOP w0.102: v1(227.88,27.34) 227.68,27.54 226.67,27.54 U14.AW48
  BOTTOM w0.14: TP104.1 227.88,27.18 v1(227.88,27.34)
N33357387: length 3.3
  TOP w0.14: U14.BB24 214.82,25.93 215.34,26.45 v1(215.35,26.45)
  BOTTOM w0.14: TP107.1 214.78,24.7 214.78,25.89 215.34,26.45 v1(215.35,26.45)
N33880969: length 1.4
  TOP w0.254: U14.BG5 205.44,22.95 205.41,22.92 v1(205.41,22.61)
  BOTTOM w0.508: v1(205.41,22.61) 205.71,22.9 C887.2
N35021669: length 6.9
  TOP w0.14: U18.106 79.83,35.84 79.93,35.93 79.93,37.41 80.15,37.63 C256.1 80.33,37.93 v1(80.79,38.4) 81.04,38.65 81.95,38.65 R235.1
N36113444: length 13.8
  TOP w0.14: v1(29.98,44.66) 29.98,45.44 30.41,45.87 PQ28.2 31.44,45.16 31.44,44.01 31.92,43.53 31.92,42.92 PQ31.3
  BOTTOM w0.14: PR536.1 30.12,44.21 29.98,44.35 v1(29.98,44.66) 29.98,44.78 31.39,46.2 31.39,46.79 30.95,47.24 29.39,47.24 29.1,46.95 29.1,46.36 v1(29.28,46.18) 29.28,45.94 PR529.2
N36113446: length 7.5
  TOP w0.14: PR284.1 36.35,48.48 PC204.1 34.65,48.72 34.44,48.94 PC202.1 34.28,49.25 34.34,49.31 34.34,49.77 34.08,50.03 34.08,50.42 v1(34.43,50.76) 34.43,50.95 PC193.2
  BOTTOM w0.14: PR506.1 35.08,51.88 PR513.1 34.86,51.19 v1(34.43,50.76)
N36113486: length 5.4
  TOP w0.14: PR262.1 35.99,51.47 PC197.1 36.72,51.52 PC194.1 35.96,52.28 v1(35.96,52.49)
  BOTTOM w0.14: PR514.1 36.33,51.19 v1(36.21,51.32) 35.96,51.56 v1(35.96,52.49)
N36113506: length 4.2
  TOP w0.14: PR315.1 34.72,43.4 34.78,43.34 34.79,43.34 PR317.1 34.44,42.93 34.39,42.99 v1(33.97,42.99) 33.67,42.69 PC221.1 34.7,41.83 PR319.1
N36113657: length 0.6
  TOP w0.14: PR255.1 43.88,51.2 43.86,51.17 PR273.2
N36113663: length 1.3
  TOP w0.14: PR334.1 34.81,39.85 PR329.1
N36113681: length 2.7
  TOP w0.14: PR275.2 38.15,50.74 38.01,50.88 38.01,51.08 v1(38,51.09)
  BOTTOM w0.14: v1(38,51.09) 38.36,51.09 38.63,51.36 PR511.1 38.6,51.81 PC411.1
N36113701: length 0.9
  TOP w0.14: PC194.2 37.42,51.23 37.51,51.14 PR274.1
N36113708: length 2.4
  TOP w0.14: PC193.1 34.52,52.2 34.65,52.07 34.92,52.07 35.1,52.25 v1(35.32,52.25) 35.32,51.9 PR260.1
N36119320: length 1.9
  TOP w0.14: PC112.1 19.49,96.02 19.94,95.56 PU11.12
N36119321: length 4.6
  TOP w0.14: PU11.4 20.34,92.4 20.59,92.14 v1(20.59,92.07)
  BOTTOM w0.14: v1(20.59,92.07) 20.57,92.04 20.52,92.04 20.13,91.65 19.74,91.65 19,92.4 PC335.2 18.23,93.29 PR479.1
N36119343: length 3.7
  TOP w0.14: v1(19.93,92.12) 19.94,92.12 PU11.3
  BOTTOM w0.14: v1(19.93,92.12) 19.93,93.02 PC334.1 19.29,94.16 PR477.1
N36119360: length 37.6
  TOP w0.14: v1(91.69,91.61) 91.66,91.58 PR142.1 92.46,90.89 92.58,90.77 PD2.2 ; PQ16.3 113.63,93.06 v1(111.82,94.87) 111.17,95.52 109.29,95.52 108.97,95.2 107.28,95.2 v1(107.22,95.25)
  IN3 w0.089: v1(107.22,95.25) 107.45,95.02 107.51,95.02 109.19,93.34 109.19,91.5 108.72,91.03 108.47,91.03 107.21,89.76 106.22,89.76 105.67,90.31 105.67,91.94 104.37,93.23 99.6,93.23 97.58,91.22 94.44,91.22 94.23,91.01 93.75,91.01 93.51,91.25 93.51,91.85 93.27,92.08 92.04,92.08 91.69,91.73 v1(91.69,91.61)
N36119368: length 8.8
  TOP w0.203: PR140.1 108.92,91.37 108.8,91.25 PR139.2 108.3,91.43 108.19,91.54 108.19,92.17 108.04,92.32 PQ15.3 v1(108.04,94.27) 108.46,94.69 108.9,94.69 109.3,95.09 109.97,95.09 110.18,94.88 PQ14.2 111.03,94.88 111.63,94.28 PQ16.2
N36119381: length 1.5
  TOP w0.203: PU10.3 91.57,93.28 91.31,93.54 PR136.1
N36119386:
  vias: v1(107.28,96)
N36119389: length 23
  TOP w0.203: v1(108.69,91.84) 108.72,91.84 109.21,92.33 PQ15.2
  TOP w0.254: v1(93.92,91.58) 94.1,91.76 PR138.1 94.34,92.22 94.57,91.99 94.93,91.99 PC122.1 94.93,92.6 95.3,92.97 PU10.4
  IN3 w0.089: v1(108.69,91.84) 108.69,91.51 107.13,89.95 106.3,89.95 105.86,90.39 105.86,92.02 104.45,93.42 99.52,93.42 97.51,91.41 94.09,91.41 v1(93.92,91.58)
N36119409: length 1
  TOP w0.508: PC121.1 PR135.2
N36196173: length 2.3
  TOP w0.14: R420.1 67.55,24.13 68.49,24.13 68.58,24.22 U18.24
N36196312: length 4.5
  TOP w0.14: U18.77 86.71,25.82 86.89,26 87.51,26 87.65,26.14 87.65,26.36 87.66,26.37 87.66,26.59 v1(88.15,27.09) R395.1
N36202008: length 5.6
  TOP w0.14: R326.2 66.49,35.25 66.65,35.41 D40.1 66.65,36.97 C259.2 66.37,37.01 66.16,36.8 66.16,35.6 65.66,35.11 R298.2
N36430440: length 4.9
  TOP w0.102: R195.2 200.54,44.76 201.16,44.14 202.03,44.14 202.37,43.8 203.27,43.8 203.4,43.67 203.76,43.67 203.91,43.81 U14.F3
N36430441: length 6.3
  TOP w0.102: U14.G3 204.37,43.32 203.98,43.32 203.92,43.25 203.21,43.25 203.12,43.34 202.25,43.34 201.86,43.73 200.83,43.73 200.5,44.06 199.36,44.06 R202.2
N36765623: length 1.3
  BOTTOM w0.14: R694.2 176.13,106.35 175.79,106.02 U40.3
N36980981: length 5.5
  TOP w0.14: U18.28 68.57,22.62 67.72,21.77 65.73,21.77 65.5,21.53 v1(65.32,21.53) 64.86,21.07 R458.1
N37464977: length 3.8
  TOP w0.14: R421.2 87.98,23.87 87.74,23.87 C404.1 87.03,23.16 86.33,23.16 86.19,23.02 U18.70
N37522596: length 10.9
  TOP w0.203: 233.67,54.37 233.77,54.27 PR251.2
  TOP w0.508: PR185.2 v1(240.3,59.25)
  IN4 w0.508: v1(240.3,59.25) 240.2,59.25 239.29,58.33 237.74,58.33 237.1,58.97 234.61,58.97 233.55,57.9 v1(233.55,56.35)
  vias: v1(230.93,55.39) v1(231.84,57.24) v1(231.84,56.58) v1(232.89,56.35)
N37522685: length 1
  TOP w0.254: PC180.2 PR218.1
N37551635: length 4.4
  BOTTOM w0.508: PQ47.2 228.06,56.26 v1(227.73,55.92) 227.23,55.92 PR491.1 226.84,56.31 PR485.2 PC379.2
N37551639:
  vias: v1(227.73,59.86)
N37551712: length 2.7
  BOTTOM w0.508: PQ48.3 224.41,57.08 v1(225.19,56.3) PR491.2
N37551735: length 2.7
  BOTTOM w0.14: PQ48.2 222.75,56.54 v1(222.75,55.79) PR495.2 PR494.2
N37571887: length 2.7
  TOP w0.14: U18.25 68.32,23.82 v1(67.81,23.3) 67.67,23.44 R430.1
N41128552: length 2.4
  TOP w0.14: R365.2 87.13,30.27 86.57,29.71 85.95,29.71 85.84,29.82 U18.87
N41320915: length 4.8
  TOP w0.14: U18.15 67.76,27.82 v1(66.39,29.19) 66.29,29.29 66.29,29.84 66.24,29.89 R367.2
N45447309: length 4.8
  TOP w0.14: R259.2 70.46,38.06 71.35,38.06 72.2,37.21 72.2,36.26 71.83,35.89 U18.126
N45637747: length 2.7
  BOTTOM w0.14: PR474.2 21.11,97.08 v1(21.08,97.04) 20.97,96.94 PQ44.3
N45637749: length 5.1
  BOTTOM w0.14: PQ44.2 18.35,95.86 17.75,95.27 16.49,95.27 PQ45.3 15.48,96.27 PR476.1 PR475.2
N46045575: length 3.5
  BOTTOM w0.14: PQ50.2 92.07,55.31 92.25,55.31 92.49,55.07 PR493.1 92.21,54.65 90.96,54.65 PQ52.3
N46045583: length 2.6
  BOTTOM w0.14: PR484.1 92.32,57.42 92.02,57.73 v1(92.02,58.11) 91.64,58.11 PQ50.3
N46625301: length 0.9
  BOTTOM w0.14: R746.1 267.97,57.14 TP66.1
N46636605: length 1.9
  TOP w0.14: T6.1 244.65,43.7 244.37,43.7 244.22,43.85 U10.27
N46636606: length 3.3
  TOP w0.14: U10.26 243.82,43.85 244.25,43.43 244.52,43.43 244.75,43.19 244.75,42.33 T7.1
N46636609: length 3
  TOP w0.14: U10.29 246.01,45.21 v1(246.09,45.13)
  BOTTOM w0.14: v1(246.09,45.13) 246.47,44.75 R818.1 246.95,44.8 R813.1
N46636612: length 1.8
  TOP w0.14: T5.1 246.99,47.61 U10.35
N46636613: length 1.7
  TOP w0.14: v1(243.57,51.31) 243.82,51.05 U10.3
  BOTTOM w0.14: T15.1 243.49,51.31 v1(243.57,51.31)
N46636614: length 1.8
  TOP w0.14: U10.38 246.81,48.81 T4.1
N47097166: length 8
  TOP w0.14: PR277.1 100.07,48.68 100.07,50.01 99.82,50.26 PQ25.2 99.23,49.85 98.9,49.52 98.48,49.52 v1(97.21,48.25)
  BOTTOM w0.14: v1(97.21,48.25) 97.21,48.39 v1(96.65,48.96) 96.19,49.41 PQ53.3
N47097174: length 1.2
  TOP w0.14: PQ25.3 98.58,47.96 PR291.1
N47371767: length 3.1
  BOTTOM w0.14: CN18.58 197.63,13.7 198.9,12.44 TP124.1
N47371769: length 4.4
  BOTTOM w0.14: CN18.56 197.99,14.2 199.55,12.64 199.55,12.22 TP123.1
N48020127: length 2.6
  TOP w0.14: U14.AE44 224.45,34.25 v1(224.45,34.64)
  BOTTOM w0.14: v1(224.45,34.64) 225.05,35.25 225.81,35.25 TP87.1
N48033744: length 12.8
  TOP w0.14: v1(216.49,27.81) 216.08,27.81 U14.AU26
  BOTTOM w0.102: 219.96,20.77 219.96,20.92 219.89,20.99 219.89,21.37 218.71,22.55 218.71,23.97 217.91,24.77 217.91,25.49 217.79,25.61 217.79,26.9 217.15,27.54 216.76,27.54 v1(216.49,27.81)
  BOTTOM w0.14: R1094.2 220.11,17.55 220.05,17.61 220.05,18.83 219.96,18.92 219.96,20.77
N48064173: length 3.3
  TOP w0.203: PU2.38 180.9,168.51 181.24,168.85 v1(181.4,168.85)
  BOTTOM w0.203: PR442.1 180.64,168.11 181.38,168.85 v1(181.4,168.85)
N48064421: length 3.2
  TOP w0.203: v1(181.38,168.08) 180.89,168.08 180.85,168.11 PU2.37
  BOTTOM w0.203: PR445.1 180.69,167.4 181.37,168.08 v1(181.38,168.08)
N48064522: length 3.3
  TOP w0.203: v1(181.37,167.39) 181.05,167.71 PU2.36
  BOTTOM w0.203: PR446.1 180.68,166.69 v1(181.37,167.39)
N48064592: length 2.9
  TOP w0.203: PU2.29 180.94,164.91 181.12,164.74 v1(181.35,164.74)
  BOTTOM w0.203: PR450.1 180.68,164.56 180.85,164.74 v1(181.35,164.74)
N48064619: length 2.9
  TOP w0.203: v1(181.35,165.38) 180.85,165.38 180.78,165.31 PU2.30
  BOTTOM w0.203: v1(181.35,165.38) 180.85,165.38 180.74,165.27 PR449.1
N48064646: length 3.2
  TOP w0.203: v1(181.35,166.03) 180.47,166.91 PU2.34
  BOTTOM w0.203: PR448.1 180.8,165.98 180.85,166.03 v1(181.35,166.03)
N48066678: length 1.6
  TOP w0.203: PR56.1 180.71,164.51 PU2.28
N48066698: length 1.7
  TOP w0.191: PU2.27 180.35,164.11
  TOP w0.203: 180.35,164.11 PR61.1
N48067217: length 3.6
  TOP w0.203: PU2.25 178.83,163.03 179.43,162.42 v1(179.52,162.42)
  BOTTOM w0.203: v1(179.52,162.42) 179.52,163.54 178.96,164.1 PR451.1
N48072604: length 2.6
  TOP w0.203: PU4.3 165.18,164.49 164.92,164.75 PC39.1 PR47.1
N48095174: length 3.8
  BOTTOM w0.14: Q73.3 v1(88.79,35.54) 88.52,35.81 88.17,35.81 87.97,36.01 R869.2
N48597124: length 5.2
  TOP w0.14: PR282.1 96.85,49.67 v1(96.82,49.7)
  BOTTOM w0.14: PQ54.3 92.98,50.21 92.99,50.22 93.88,50.22 93.94,50.28 96.24,50.28 v1(96.82,49.7)
N48623264: length 2.8
  TOP w0.254: PD6.3 86.35,49.66 v1(87.04,50.35) PR259.2
N48777312: length 21.3
  TOP w0.254: v1(138.1,26.8) 138.1,28.44 137.85,28.69 131.97,28.69 129.53,31.13 127.45,31.13 126.79,30.47 125.9,30.47 123.04,27.61 PR377.2
  BOTTOM w0.14: PR563.2 138.43,26.35 138.1,26.68 v1(138.1,26.8)
N48782284: length 26.7
  TOP w0.254: PR396.2 99.36,25.24 102.89,28.77 111.02,28.77 111.83,29.58 111.83,31.56 112.52,32.25 112.96,32.25 115.71,29.51 118.03,29.51 v1(118.6,28.93) 119.47,28.06 PR380.1
N48825927: length 2.1
  TOP w0.14: R103.2 R104.2 105.91,104.15 106.33,103.73 Q16.5
N49080261: length 1.5
  BOTTOM w0.14: R925.1 65.11,27.91 65.37,27.91 TP103.1
N49312089: length 2.6
  TOP w0.14: PQ24.4 186.97,47.18 v1(186.46,47.18) 186.35,47.3 PR289.2 PR285.2
N49317148: length 2.1
  TOP w0.14: v1(51.07,48.5) 51.02,48.56 R175.1
  BOTTOM w0.14: CN16.64 v1(51.07,48.5)
N49321163: length 4.9
  TOP w0.14: R565.1 8.53,14.78 R587.2 8.56,14.27 v1(9.72,14.27) 10.88,13.11 R594.1
N49321219: length 4.9
  TOP w0.14: Q54.2 9.96,11.01 9.23,11.01 8.83,11.4 Q53.3 8.83,12.26 v1(8.36,12.73) 7.73,12.73 R604.2
N49355730: length 5.8
  BOTTOM w0.14: TP128.1 48.23,38.17 48.61,38.56 48.61,39.59 48.1,40.1 48.1,41.27 48.41,41.57 48.71,41.57 49.14,42 CN16.38
N49355733: length 3.2
  BOTTOM w0.14: TP129.1 47.55,41.33 48.12,41.9 48.5,41.9 49.11,42.5 CN16.40
N49355736: length 4.6
  BOTTOM w0.14: CN16.42 49.13,43 48.31,42.19 48.02,42.19 47.09,41.27 46.45,41.27 TP130.1
N49704554: length 2.8
  TOP w0.14: R500.2 70.52,18.3 71.52,18.3 71.83,18.62 U18.35
N49976193: length 2
  TOP w0.14: Q8.6 167.71,118.96 v1(167.71,118.68) 167.71,118.54 167.57,118.39 LED1.1
N51039131: length 3.3
  TOP w0.14: R460.1 195.82,20.46 195.82,20.93 v1(195.57,21.18) 195.42,21.18 194.99,20.74 Q35.2 194.35,20.74 194.23,20.87 194.23,21.1 194.37,21.24 Q35.3
N51040469: length 3.2
  TOP w0.14: R498.1 195.56,19.06 v1(194.68,19.06) Q38.3 193.51,19.06 193.39,18.94 193.39,18.66 193.49,18.56 Q38.2
N52895575: length 1.4
  TOP w0.14: PR304.2 PR293.2 PR292.1
N52967177: length 19.5
  BOTTOM w0.14: RG155.1 16.37,97.23 15.25,98.35 14.61,98.35 12.39,100.58 11.75,100.58 11.35,100.98 10.44,100.98 v1(9.95,101.47) 8.33,103.09 8.33,104.69 QG18.2 8.28,105.29 8.1,105.48 7.4,105.48 6.91,105.96 6.91,107.94 7.25,108.27 7.79,108.27 8.28,107.78 QG18.5
N52967400: length 12.6
  BOTTOM w0.14: QG24.2 30.13,76.36 29.51,75.73 27.86,75.73 QG25.2 27.23,78.16 27.79,78.72 28.98,78.72 29.65,79.39 RG188.2 30.31,79.56 30.68,79.94 30.68,80.29 30.37,80.6 QG22.3
N52967406: length 8.3
  TOP w0.14: QG10.5 24.38,86 23.81,86.58 RG43.1 23.5,86.16 23.84,85.82 v1(23.89,85.82) ; QG10.2 v1(28.16,86)
  BOTTOM w0.14: v1(28.16,86) 24.08,86 v1(23.89,85.82)
N52973214: length 3.8
  BOTTOM w0.14: UG9.5 43.84,78.89 CG900.2 43.87,77.89 RG192.1 44.62,77.66 44.8,77.49 45.43,77.49 45.64,77.69 RG191.1
N52973339: length 4.3
  TOP w0.14: RG79.2 34.36,79.4 CG83.2 34.4,79.42 35.01,78.81 QG16.2 36.06,78.81 36.24,78.63 36.24,78.36 36.04,78.16 QG16.3
N52973345: length 3.7
  TOP w0.14: DG4.3 39.68,78.53 RG77.2 38.97,78.39 38.45,78.91 37.95,78.91 37.85,78.81 QG16.5
N53198850: length 13.4
  BOTTOM w0.14: R645.2 41.93,160.75 v1(41.91,160.77) 41.81,160.87 40.98,160.87 40.26,161.59 38.45,161.59 36.87,163.16 32.72,163.16 31.85,162.29 31.85,161.22 CN8.7
N53212830: length 1.7
  TOP w0.203: U17.1 33.61,33.89 33.79,34.07 34.15,34.07 34.34,33.88 C285.1
  vias: v1(35.52,33.87)
N53212844: length 2.7
  TOP w0.203: U17.53 35.14,31.16 35.35,31.36 35.35,31.66 36.37,32.68 R344.1
N53212868: length 1.3
  TOP w0.14: R302.2 33.21,34.22 U17.2
N53212870: length 1.3
  TOP w0.14: R301.2 32.81,34.36 U17.3
N53212886: length 2.4
  TOP w0.14: U17.7 31.21,34.2 v1(31.27,34.26)
  BOTTOM w0.14: v1(31.27,34.26) 31.8,33.73 R886.2
N53212908: length 2.4
  TOP w0.203: C398.1 34.42,25.04 33.61,25.85 U17.42
N53213011: length 3.7
  TOP w0.203: U17.27 26.87,27.56 26.21,26.9 26.09,26.9 v1(25.64,26.46) 25.06,25.87 C370.2
N53213017: length 4.5
  TOP w0.203: C396.2 25.82,24.22 26.25,24.64 26.25,25.02 26.65,25.42 C371.2 26.92,25.86 v1(26.92,26.4) 26.92,26.95 27.12,27.16 U17.28
N53213083: length 7.1
  TOP w0.203: U17.41 33.21,25.55 33.5,25.26 33.5,24.83
  TOP w0.254: 33.5,24.83 33.5,23.55 33.88,23.17 34.53,23.17 C420.1 C421.1 37.24,22.4 R439.1
N53213106: length 3.5
  TOP w0.203: U17.43 34.61,25.78 v1(34.87,25.51) 35.02,25.36 35.02,24.67 C398.2
N53213110: length 2.6
  TOP w0.203: C355.2 36.5,27.53 36.09,27.12 35.59,27.12 35.14,27.56 U17.44
N53213208: length 2.8
  TOP w0.14: R294.1 27.53,35.47 27.91,35.09 27.91,34.75 28.81,33.85 U17.13
N53213261: length 4
  TOP w0.203: C336.1 37.53,30.46 C331.1 36.46,31.16 36.06,30.76 U17.52
N53213275: length 3.2
  TOP w0.203: U17.39 32.41,25.19 32.33,25.11 v1(32.33,24.83)
  BOTTOM w0.203: C879.1 C880.1 32.4,24.76 v1(32.33,24.83)
N53214493: length 2.1
  TOP w0.381: C389.2 R419.2 R427.1
N53214499: length 2
  TOP w0.381: R419.1 37.61,24.81 v1(37.26,24.45) 36.98,24.72 C381.1
N53214581: length 1.9
  TOP w0.254: U20.10 41.61,25.72 40.79,24.91 C389.1
N53214870: length 1.3
  TOP w0.381: C361.1 37.49,25.95 R407.1
N53217570: length 2.7
  TOP w0.381: R423.2 18.57,24.04 R428.2 18.11,24.05 17.72,23.66 C401.2
N53217572: length 2.7
  TOP w0.381: R415.2 18.57,25.19 R409.1 18.37,25.18 18,24.81 C388.2
N53217576: length 1.1
  TOP w0.381: C385.1 21.57,25.19 R415.1
N53217580:
  vias: v1(11.19,21.95)
N53217584:
  vias: v1(10.85,25.71)
N53217761: length 1.1
  TOP w0.381: R423.1 C399.1
N53218533: length 2.9
  TOP w0.381: v1(22.04,23.41) 22.1,23.35 C417.2
  BOTTOM w0.381: R1003.1 22.5,22.95 v1(22.04,23.41) 22.04,23.68 R973.2
N53218537: length 1.1
  BOTTOM w0.381: R973.1 22.6,25.97 C864.1
N53218575: length 1.5
  TOP w0.254: C418.1 23.57,21.11 U25.9
N53218614: length 2.7
  TOP w0.254: U25.5 24.02,16.25 24.16,16.11 v1(24.16,15.86)
  IN1 w0.305: v1(24.23,14.55) 24.08,14.7 24.08,15.77 v1(24.16,15.86)
N53218722: length 1.2
  BOTTOM w0.381: C863.1 23.87,25.71 R974.1
N53255970: length 4.4
  BOTTOM w0.14: U44.29 243.34,14.52 243.99,15.17 v1(243.99,15.56) 243.99,15.61 243.48,16.12 243.48,17.31 R1072.2
N53256180: length 1.5
  BOTTOM w0.14: R1067.2 239.43,18.09 U44.19
N53256182: length 1.3
  BOTTOM w0.14: U44.21 240.43,18.35 R1066.2
N53257589: length 2.1
  TOP w0.14: R352.2 253.66,32.15 v1(253.56,32.25) 253.04,32.77 U13.16
N53257617: length 2.9
  TOP w0.14: U13.31 250.99,39.08 v1(251.15,39.23)
  BOTTOM w0.14: v1(251.15,39.23) 251.15,39.11 250,37.95 TP77.1
N53257780: length 2.3
  TOP w0.14: v1(244.79,32.8) 245.16,33.17 U13.54
  BOTTOM w0.14: v1(244.79,32.8) 245.05,33.06 TP94.1
N53257796: length 2.7
  TOP w0.14: v1(245,32.12) 245,32.35 245.42,32.77 U13.55
  BOTTOM w0.14: TP98.1 245.76,32.12 v1(245,32.12)
N53257902: length 3.9
  TOP w0.14: v1(250.19,30.8) U13.10
  BOTTOM w0.14: R916.1 250.19,28.86 R920.2 249.95,29.62 249.95,30.56 v1(250.19,30.8)
N53257904: length 4.3
  TOP w0.14: U13.6 248.59,30.89 v1(248.74,30.75)
  BOTTOM w0.14: R917.1 248.07,28.86 R918.2 248.4,30.75 v1(248.74,30.75)
N53276765: length 0.8
  BOTTOM w0.381: RG127.1 42.89,104.66 v2(42.89,104.66)
N53276791:
  vias: v2(42.28,106) v2(42.89,106.76) v2(42.9,106.14)
N53276837: length 1.2
  TOP w0.105: UG1.AM6 v2(40.12,107.48)
  BOTTOM w0.14: RG123.1 40.02,107.37 v2(40.12,107.48)
N53276839: length 1.3
  TOP w0.102: v2(39.41,107.5) 39.75,107.17 UG1.AM5
  BOTTOM w0.14: RG121.1 39.04,107.13 v2(39.41,107.5)
N53327588: length 2.3
  TOP w0.14: R569.1 246.09,13.71 246.44,13.37 v1(246.51,13.37) 246.78,13.64 246.78,13.94 247.07,14.23 U28.3
N53369186:
  vias: v1(276.09,38.22) v1(276.73,37.86)
N53388643: length 3.9
  TOP w0.178: PR338.2 45.82,37.75 v1(45.61,37.75) 45.6,37.75 45.26,37.41 44.77,37.41 44.29,36.93 PU25.20
  BOTTOM w0.178: v1(45.61,37.75) 46.06,38.2 PR550.1
N53388645: length 4.5
  TOP w0.178: PR339.2 46.43,37.59 46.43,37.38 v1(46.4,37.35) 45.94,37.35 45.67,37.09 44.9,37.09 44.69,36.88 PU25.19
  BOTTOM w0.14: PR549.1 46.4,37.48 v1(46.4,37.35)
N53388683: length 0.9
  BOTTOM w0.14: PR550.2 45.46,38.65 PC417.1
N53388705: length 2.1
  BOTTOM w0.14: PC416.1 47.05,40.09 v1(47.51,39.63) 47.51,39.43 47.39,39.31 47.39,38.92 PR549.2
N53389227: length 6.3
  TOP w0.14: PQ33.2 36.25,36.31 37.11,35.45 37.11,35.22 37.7,34.63 37.7,33.88 39.24,32.34 v1(39.24,32.01)
  BOTTOM w0.178: PR557.2 39.31,32.07 v1(39.24,32.01)
N53389243: length 2.6
  TOP w0.178: PR337.2 39.25,38.9 v1(38.42,38.9) 37.72,38.9 PQ33.3
N53564514: length 25.5
  IN3 w0.089: v1(196.2,58.44) 197.78,56.86 201.39,56.86 202.71,55.54 203.24,55.54 203.7,56 203.7,59.05 v1(202.09,60.65)
  BOTTOM w0.14: v1(202.09,60.65) 202.09,61.36 201.33,62.13 CN12.2 ; Q68.3 194.33,56.12 194.63,56.42 R748.1 R747.2 196.34,56.42 C707.1 197.12,57.52 v1(196.2,58.44)
N53564570: length 2.2
  BOTTOM w0.14: R733.2 191.38,61.02 v1(191.6,61.24) 191.8,61.44 Q67.2
N53565581: length 2.6
  TOP w0.14: R174.2 10.05,47.48 v1(10.11,47.42) 10.17,47.42 10.92,48.17 Q25.2
N53565628: length 16.2
  TOP w0.14: v1(9.71,53.6) 9.82,53.49 Q24.3
  BOTTOM w0.14: C697.1 10.04,51.99 R731.1 R735.2 9.04,52.93 v1(9.71,53.6) 9.03,54.28 9.03,57.9 10.14,59.01 10.14,61.93 9.77,62.3 CN11.2
N53620392: length 2.9
  TOP w0.14: U5.14 280.19,51.08 279.8,50.69 279.11,50.69 v1(278.9,50.48) 278.54,50.84 R163.1
N53620394: length 3.1
  TOP w0.14: R155.1 279.24,53.38 v1(279.36,53.27) 279.36,52.94 279.31,52.89 279.31,52.61 279.64,52.28 279.76,52.28 280.16,51.88 U5.12
N53638085:
  vias: v1(17.42,18.66) v1(17.47,17.97) v1(17.55,19.29)
N53716064: length 12.1
  TOP w0.14: PQ22.2 239.75,51.07 238.7,51.07 v1(238.39,50.75)
  BOTTOM w0.14: PR512.1 232.89,52.33 PR510.1 233.95,53.05 v1(234.28,53.38) 235.45,53.38 236.01,53.94 237.15,53.94 238.25,52.85 238.25,50.89 v1(238.39,50.75)
N53716070: length 33.4
  TOP w0.14: v1(214.22,60.24) 214.22,60.57 213.89,60.89 PQ18.2 ; v1(237.25,53.15) 238.04,52.37 PQ22.3
  IN4 w0.086: v1(237.25,53.15) 236.87,52.77 227.35,52.77 222.8,57.32 216.3,57.32 214.93,58.69 214.93,59.43 214.22,60.13 214.22,60.2 214.22,60.2 v1(214.22,60.24)
  BOTTOM w0.14: v1(237.25,53.15) 237.25,52.58 PR508.1 236.7,52.63 236.7,53.05 236.37,53.38 v1(236.24,53.38) 235.48,52.62 PR509.2
N53720378: length 1.4
  TOP w0.508: PR146.2 12.81,82.57 12.6,82.36 PC129.1
N53720386: length 5.4
  TOP w0.254: PR144.2 6.94,88.73 6.94,88.02 7.2,87.76 7.47,87.76 7.93,87.31 7.93,85.75 7.33,85.14 7.07,85.14 7.01,85.08 PR145.2
N53728040: length 1.7
  BOTTOM w0.14: U41.38 178.33,95.88 T10.1
N53728042: length 1.3
  BOTTOM w0.14: U41.35 177.13,95.77 T11.1
N53728044: length 1.9
  BOTTOM w0.14: U41.3 180.77,93.1 T14.1
N53728285: length 1.6
  BOTTOM w0.14: T12.1 172.84,93.87 173.21,93.5 U41.27
N53728287: length 1.5
  BOTTOM w0.14: T13.1 172.65,92.86 173.24,92.86 173.49,93.1 U41.26
N53788150: length 5.3
  TOP w0.203: PR1.1 8.09,173.64 8.36,173.91 9.1,173.91 9.37,173.64 PR2.2 9.37,173.12 9.58,172.91 9.58,172.52 PQ1.2 9.18,172.52 8.73,172.97 v1(8.73,173.4)
  BOTTOM w0.254: PQ38.3 8.5,173.17 v1(8.73,173.4)
N53788267: length 2.6
  TOP w0.203: PR12.1 PR16.1 10.59,170.38 v1(10.43,170.22)
  BOTTOM w0.203: PQ38.2 10.19,170.47 v1(10.43,170.22)
N53788269: length 3.3
  TOP w0.203: PR32.2 8.43,165.19 8.3,165.32 PC38.1 7.13,165.99 v1(7.13,166.13) 7.38,166.39 PR45.2
N53788361: length 28.7
  TOP w0.14: PC29.2 11.53,165.27 PR34.2 11.53,166.39 PC23.1 12.01,166.47 v1(12.41,166.87)
  BOTTOM w0.14: PR464.2 28.64,157.6 PR459.1 28.51,157.96 28.14,158.34 28.14,159.03 27.72,159.45 27.72,160.23 26.45,161.5 20.83,161.5 19.52,162.81 19.52,163.02 19.52,163.57 18.4,164.7 18.4,164.91 18.4,168.52 17.79,169.12 15.98,169.12 13.94,167.08 12.63,167.08 v1(12.41,166.87)
N53788407: length 2.1
  TOP w0.203: PR21.2 8.86,169.36 v1(9.09,169.59) 9.09,169.96 PQ1.3
N53788559: length 6
  BOTTOM w0.254: PQ40.2 11.08,170.44 10.86,170.66 PQ39.3 10.38,171.36 9.8,171.95 PR427.2 10.23,172.61 10.99,172.61 PR426.1
N53788585: length 1.4
  TOP w0.508: PR4.1 36.9,173.27 37.08,173.45 PC1.1
N53788806: length 1.2
  BOTTOM w0.508: PC95.1 7.78,154.47 PR115.1
N53789031: length 1.5
  BOTTOM w0.254: PQ40.3 11.58,167.04 PR444.2
N53789209: length 1.1
  BOTTOM w0.14: PQ39.2 11.99,172.12 PR428.1
N53799610: length 2.4
  BOTTOM w0.14: PR469.2 178.94,152.69 v1(179.1,152.52) 179.1,152.19 PQ42.3
N54130914: length 2.5
  BOTTOM w0.203: R1145.1 242.08,10.17 v1(242.08,10.84) 242.08,11.22 241.93,11.37 U44.1
N54133206: length 4
  BOTTOM w0.14: R652.1 48.11,159.14 v1(48.11,159.34) 48.42,159.66 49.68,159.66 50.02,160 U34.36
N54133596: length 4.6
  TOP w0.14: U2.3 67.12,159.95 C23.2 66.26,160.41 66.11,160.26 R17.2 65.22,160.73 64.46,160.73 R16.2
N54227218: length 4.2
  TOP w0.14: TP59.1 270.52,12.87 271.67,12.87 272.68,11.86 273.48,11.86 273.57,11.95 U30.6
N54227279: length 3.9
  TOP w0.14: TP60.1 270.66,11.7 272.08,11.7 272.18,11.6 273.61,11.6 273.66,11.55 U30.7
N54443582: length 6
  TOP w0.14: T1.1 90.07,150.42 87.85,152.64 87.85,153.89 88.01,154.05 v1(88.23,154.05)
  BOTTOM w0.14: U39.27 88.79,153.7 88.44,154.05 v1(88.23,154.05)
N54443594: length 3.7
  TOP w0.14: v1(88.31,153.39) 88.43,153.27 88.43,152.47 89.24,151.66 89.88,151.66 T3.1
  BOTTOM w0.14: U39.26 88.4,153.3 v1(88.31,153.39)
N54443678: length 2.5
  BOTTOM w0.14: U39.38 93.62,155.13 93.89,155.4 93.89,155.41 94.38,155.9 94.38,156.75 T8.1
N54443680: length 1.2
  BOTTOM w0.14: T9.1 92.42,155.45 U39.35
N54443682: length 1.5
  TOP w0.14: v1(96.07,153.3) 96.01,153.36 T2.1
  BOTTOM w0.14: U39.3 v1(96.07,153.3)
N55927396: length 2.2
  TOP w0.203: PR167.1 33.48,62.81 v1(33.48,62.31) 33.06,62.31 PC139.2
N55927404: length 2.2
  TOP w0.14: PU15.31 26.79,55.74 26.46,55.41 26.46,54.86 PR244.1
N55927441: length 2
  TOP w0.14: PR211.2 28.36,54 v1(28.59,53.76)
  BOTTOM w0.14: v1(28.59,53.76) 28.36,54 PR211.2
N55927461: length 1.9
  TOP w0.14: PU15.35 28.59,56.02 28.87,55.74 28.87,55.35 29.37,54.85 PR222.2
N55927578: length 2
  TOP w0.14: PR223.2 30.18,54.85 29.93,55.1 29.93,55.13 29.04,56.02 PU15.36
N55927589: length 1.6
  TOP w0.14: PR200.2 31.69,56.23 31.62,56.3 PU15.39
N55927593: length 2.3
  TOP w0.14: PU15.37 29.49,56.02 30.33,55.19 30.61,55.19 30.94,54.85 PR224.2
N55927597: length 2.2
  TOP w0.254: TP15.1 31.59,59.17 PU15.6 30.52,59.45 PU15.41
N55927792: length 2.6
  TOP w0.14: PR186.2 31.75,57.64 v1(31.57,57.82) PU15.3
  BOTTOM w0.14: PC386.1 30.71,57.82 v1(31.57,57.82)
N55928956: length 2
  TOP w0.203: PR171.1 23.82,62.82 v1(23.82,62.06) 23.29,62.06 PC142.2
N55928964: length 2.2
  TOP w0.14: PU14.31 17.14,55.9 16.58,55.34 v1(16.5,55.34) 16.44,55.34 PR209.1
N55929001: length 1.6
  TOP w0.508: PC184.1 14.97,52.5 14.59,52.13 PR257.2
N55929021: length 1.8
  TOP w0.14: PR219.2 19.81,55.11 18.94,55.98 PU14.35
N55929149: length 2.8
  TOP w0.14: PU14.39 20.74,56.06 21.02,55.77 21.16,55.77 21.44,55.49 v1(22.04,55.49) 22.27,55.49 22.55,55.21 PR207.2
N55929153: length 2.3
  TOP w0.14: PR221.2 21.29,54.85 20.96,55.19 20.67,55.19 19.84,56.02 PU14.37
N55929157: length 2.7
  TOP w0.14: TP14.1 22.12,60.24 21.69,59.81 21.67,59.81 21.46,59.6 21.35,59.6 21.14,59.39 PU14.6 20.82,59.17 20.55,59.45 PU14.41
N55929352: length 3.2
  TOP w0.14: PU14.3 21.58,57.82 21.8,58.04 22.18,58.04 22.34,57.88 v1(22.6,57.88) 22.52,57.96 PR177.2
  BOTTOM w0.14: v1(22.6,57.88) 22.51,57.97 22.51,58.38 PC355.1
N55940902: length 1.4
  TOP w0.203: PR173.1 91.24,62.56 91.27,62.53 PC144.2
N55940967: length 2.7
  TOP w0.14: v1(85.87,53.46) 85.87,54.28 PR216.2
  BOTTOM w0.14: PC403.1 85.95,53.91 85.95,53.53 v1(85.87,53.46)
N55940969: length 2.7
  TOP w0.14: PU21.3 89.12,57.82 89.23,57.93 v1(89.44,57.93) 89.63,57.93 89.92,57.64 PR192.2
  BOTTOM w0.14: v1(89.44,57.93) 88.99,57.93 88.74,57.67 PC380.1
N55940971: length 1.8
  TOP w0.14: PU21.35 86.5,56.02 86.79,55.74 86.79,55.41 PR240.1
N55940973: length 2.1
  TOP w0.14: PR241.1 88.01,54.78 87.21,55.58 87.21,55.71 86.95,55.97 PU21.36
N55940977: length 2.5
  TOP w0.14: PU21.37 87.4,55.97 87.49,55.88 87.49,55.69 88.09,55.09 88.48,55.09 88.74,54.83 PR242.2
N55940983: length 2.2
  TOP w0.254: TP21.1 89.4,59.48 89.1,59.17 PU21.6 88.33,59.17 88.06,59.45 PU21.41
N55940988: length 2.2
  TOP w0.14: PR250.1 83.96,54.54 84.45,55.02 84.45,55.49 84.7,55.74 PU21.31
N55941017: length 2.2
  TOP w0.14: PU20.31 75.05,55.74 74.8,55.49 74.8,55.02 74.31,54.54 PR249.1
N55941021: length 2.2
  TOP w0.203: PR170.1 81.86,62.69 v1(81.86,62.3) 81.59,62.03 PC138.2
N55941039: length 2.9
  TOP w0.14: v1(76.07,53.83) 76.21,53.68 v1(76.71,53.68) 77,53.98 77,54.29 PR215.2
  BOTTOM w0.14: PC404.1 76.59,54.34 v1(76.07,53.83)
N55941042: length 1.9
  TOP w0.14: PU20.35 76.85,55.89 77.13,55.61 77.13,55.35 77.63,54.85 PR237.1
N55941044: length 2.1
  TOP w0.14: PR238.1 78.31,54.85 77.3,55.86 PU20.36
N55941048: length 2.4
  TOP w0.14: PU20.37 77.75,55.8 78.37,55.19 78.87,55.19 79.2,54.85 PR239.2
N55941050: length 1.5
  TOP w0.102: 79.86,56.29 PR205.1
  TOP w0.14: 79.86,56.29 79.85,56.3 PU20.39
N55941056: length 2.2
  TOP w0.254: TP20.1 79.85,59.17 PU20.6 78.6,59.17 78.33,59.45 PU20.41
N55941092: length 2.2
  TOP w0.14: PR248.1 64.66,54.54 65.14,55.02 65.14,55.49 65.4,55.74 PU19.31
N55941096: length 2.2
  TOP w0.203: PC137.2 71.95,62.03 v1(72.2,62.28) 72.2,62.7 PR169.1
N55941113: length 1.9
  TOP w0.14: v1(66.38,54.08) 66.38,54.08 66.96,54.67 PR210.2
  BOTTOM w0.14: v1(66.38,54.08) 66.4,54.06 66.6,54.06 66.96,54.42 PR210.2
N55941116: length 1.9
  TOP w0.14: PR234.1 67.98,54.85 67.48,55.35 67.48,55.74 67.2,56.02 PU19.35
N55941118: length 2
  TOP w0.14: PU19.36 67.65,56.02 68.54,55.13 68.54,55.1 68.79,54.85 PR235.1
N55941122: length 2.3
  TOP w0.14: PR236.2 69.55,54.85 69.22,55.19 68.93,55.19 68.1,56.02 PU19.37
N55941124: length 1.6
  TOP w0.14: PU19.39 70.23,56.3 70.3,56.23 PR204.1
N55941130: length 2.2
  TOP w0.254: PU19.41 68.73,59.45 69,59.17 PU19.6 70.2,59.17 TP19.1
N55941168: length 2.2
  TOP w0.14: PU18.31 55.75,55.74 55.49,55.49 55.49,55.02 55.01,54.54 PR247.1
N55941172: length 2.2
  TOP w0.203: PR166.1 62.44,62.94 v1(62.44,62.43) 61.91,61.9 PC141.2
N55941190: length 2.8
  TOP w0.14: v1(56.5,53.77) 57.09,54.36 57.3,54.57 57.31,54.58 PR214.2
  BOTTOM w0.14: PR214.2 57.31,54.08 56.99,53.77 v1(56.5,53.77)
N55941193: length 1.9
  TOP w0.14: PR231.1 58.32,54.85 57.83,55.35 57.83,55.74 57.55,56.02 PU18.35
N55941195: length 2
  TOP w0.14: PU18.36 58,56.02 58.89,55.13 58.89,55.1 59.14,54.85 PR232.1
N55941199: length 2.3
  TOP w0.14: PR233.2 59.9,54.85 59.57,55.19 59.28,55.19 58.45,56.02 PU18.37
N55941201: length 1.8
  TOP w0.14: PU18.39 59.58,56.53 60.34,56.53 60.65,56.23 PR203.1
N55941207: length 2.2
  TOP w0.254: PU18.41 59.13,59.45 59.4,59.17 PU18.6 60.55,59.17 TP18.1
N55941243: length 2.2
  TOP w0.14: PU17.31 46.09,55.74 45.84,55.49 45.84,55.02 45.35,54.54 PR246.1
N55941247: length 2.5
  TOP w0.203: PR165.1 52.81,62.91 v1(52.81,62.12) 52.46,61.77 PC143.2
N55941265: length 1.7
  TOP w0.14: PR213.2 47.66,54.01 v1(47.52,53.86)
  BOTTOM w0.14: v1(47.52,53.86) 47.66,54.01 PR213.2
N55941268: length 1.9
  TOP w0.14: PU17.35 47.89,55.88 48.18,55.6 48.18,55.35 48.67,54.85 PR228.1
N55941270: length 2.1
  TOP w0.14: PU17.36 48.34,55.83 48.91,55.26 49.1,55.26 49.51,54.85 PR229.1
N55941274: length 2.3
  TOP w0.14: PR230.2 50.25,54.85 49.91,55.19 49.63,55.19 48.79,56.02 PU17.37
N55941276: length 1.6
  TOP w0.14: PR202.1 50.99,56.23 50.92,56.3 PU17.39
N55941282: length 2.2
  TOP w0.254: TP17.1 50.9,59.17 PU17.6 49.65,59.17 49.37,59.45 PU17.41
N55941318: length 2.2
  TOP w0.14: PR245.1 35.7,55.06 v1(35.84,55.2) 36.44,55.8 PU16.31
N55941322: length 2.2
  TOP w0.203: PR168.1 43.13,62.81 v1(43.13,62.3) 42.86,62.3 42.46,61.9 PC140.2
N55941340: length 2.2
  TOP w0.14: v1(38.3,53.71) 38.01,54 PR212.2
  BOTTOM w0.14: v1(38.3,53.71) 38.01,54 PR212.2
N55941343: length 1.9
  TOP w0.14: PR225.1 39.02,54.85 38.53,55.35 38.53,55.74 38.24,56.02 PU16.35
N55941345: length 2
  TOP w0.14: PR226.1 39.83,54.85 39.58,55.1 39.58,55.13 38.69,56.02 PU16.36
N55941347: length 2.3
  TOP w0.14: PU16.37 39.14,56.02 39.98,55.19 40.26,55.19 40.6,54.85 PR227.2
N55941349: length 1.6
  TOP w0.14: PU16.39 41.27,56.3 41.34,56.23 PR201.1
N55941355: length 2.2
  TOP w0.254: PU16.41 39.85,59.45 40.12,59.17 PU16.6 41.24,59.17 TP16.1
N55941374: length 2.6
  TOP w0.14: PU20.3 v1(79.83,57.82) 80.01,57.64 PR191.2
  BOTTOM w0.14: PC381.1 78.97,57.82 v1(79.83,57.82)
N55941387: length 2.6
  TOP w0.14: PU19.3 v1(70.18,57.82) 70.36,57.64 PR190.2
  BOTTOM w0.14: v1(70.18,57.82) 69.32,57.82 PC382.1
N55941398: length 2.5
  TOP w0.14: PR189.2 60.71,57.64 60.52,57.82 v1(60.47,57.82) PU18.3
  BOTTOM w0.14: v1(60.47,57.82) 59.66,57.82 PC383.1
N55941409: length 2.6
  TOP w0.14: PU17.3 v1(50.87,57.82) 51.06,57.64 PR188.2
  BOTTOM w0.14: PC384.1 50.72,57.67 v1(50.87,57.82)
N55941420: length 2.6
  TOP w0.14: PU16.3 v1(41.22,57.82) 41.4,57.64 PR187.2
  BOTTOM w0.14: v1(41.22,57.82) 40.36,57.82 PC385.1
N55953939: length 6.7
  TOP w0.14: PQ29.2 28.85,43.61 v1(28.85,43.18) 30.13,43.18 31.28,42.04 32.04,42.04 32.56,41.52 32.56,40.6 PR332.1
N55953943: length 5.6
  TOP w0.14: PQ26.2 25.8,46.48 26.17,46.48 27.26,45.39 v1(27.38,45.39) PQ29.3 29.07,45.51 PR306.1 29.07,46.5 28.62,46.95 PR301.2
N55953959: length 5.8
  TOP w0.508: v1(25.07,47.92) 25.07,47.73 24.66,47.31 PQ26.3
  BOTTOM w0.508: PR521.2 24.53,47.28 25.07,47.82 v1(25.07,47.92)
N56077694: length 18.5
  TOP w0.14: v1(75.63,160.01) 75.78,160.16 Q2.3
  IN1 w0.086: v1(78.4,159.91) 78.35,159.96 75.69,159.96 v1(75.63,160.01)
  BOTTOM w0.14: 77.49,158.39 77.05,158.83 C522.1 75.81,158.83 v1(75.78,158.86) 75.78,159.65 75.66,159.77 75.66,159.99 v1(75.63,160.01) 75.41,160.24 75.41,160.7 75.28,160.83 R641.2 75.28,162.69 Q56.3 ; 77.49,158.39 77.46,158.39 77.21,158.13 77.21,157.7 77.51,157.39 78.3,157.39 78.53,157.62 78.53,158.16 78.76,158.39 Q60.5 ; 77.49,158.39 Q60.2 ; Q57.5 78.68,160.93 78.48,160.72 78.48,159.99 v1(78.4,159.91) 77.23,159.91 C508.1 76.99,160.54 77.38,160.93 Q57.2
N56077756: length 4.2
  TOP w0.14: R21.2 75.69,161.9 76.55,161.04 76.55,160.7 76.78,160.48 Q2.2 77.66,160.98 Q3.3
N56077770: length 2
  BOTTOM w0.14: Q57.4 78.62,161.43 78.24,161.04 78.24,160.57 78.09,160.43 Q57.1
N56077935: length 3.9
  BOTTOM w0.14: Q58.3 75.13,159.65 75.13,160.31 74.83,160.61 74.12,160.61 73.71,161.02 R642.2 73.71,161.73 73.75,161.77 Q56.2
N56085154:
  vias: v1(97.07,163.87)
N56085203:
  vias: v1(100.05,160.77)
N56197477: length 20.3
  IN4 w0.508: v1(47.27,19.62) 47.15,19.75 47.15,29.46 46.64,29.96 45.89,29.96 44.24,28.31 v1(43.55,28.31)
  BOTTOM w0.254: U43.16 44.48,24.2 44.7,24.41 44.7,24.53
  BOTTOM w0.508: 44.7,24.53 44.99,24.81 44.99,26.53 v1(45.03,26.57) 45.03,27.33 44.73,27.63 C858.2 44.12,27.9 43.71,28.31 v1(43.55,28.31)
N56199005: length 3.4
  BOTTOM w0.14: R1070.1 42.4,18.9 42.95,19.45 43.72,19.45 43.88,19.29 44.24,19.29 44.48,19.54 U43.10
N56202137: length 16.3
  IN1 w0.086: v1(38.81,15.26) 39.34,14.73 39.34,14.44 38.87,13.98 29.98,13.98 v1(29.63,14.33)
  BOTTOM w0.14: R1111.2 39.02,16.81 38.81,16.61 v1(38.81,15.26) ; CN20.13 29.63,17.56 v1(29.63,14.33)
N56214175: length 2.8
  TOP w0.14: PR206.1 90.42,56.36 90.42,56.68 90.32,56.78 89.56,56.78 89.35,56.57 88.44,56.57 88.3,56.43 PU21.39
N56249919: length 2
  BOTTOM w0.14: Q60.1 78.13,157.89 78.25,158 78.25,158.49 78.65,158.89 Q60.4
N56249956: length 1.7
  BOTTOM w0.508: U36.3 v1(96.44,159.81) 95.89,159.81 R646.2
N56249990: length 13
  IN3 w0.089: v1(86.17,161.51) 88.04,163.38 90.51,163.38 91.13,164 91.13,165.42 90.77,165.78 88.82,165.78 CN2.14
  BOTTOM w0.14: R643.2 86.39,160.22 86,160.6 86,161.38 86.14,161.51 v1(86.17,161.51)
N56253576: length 2
  TOP w0.14: PU14.36 19.39,56.02 20.28,55.13 20.28,55.1 20.53,54.85 PR220.2
N56276780: length 5.6
  BOTTOM w0.14: C757.2 18.86,47.49 v1(19.5,46.85) 19.5,45.83 19.75,45.58 19.75,45.24 19.47,44.95 Q71.2 19.16,44.04 R824.1
N56281109: length 3.1
  BOTTOM w0.14: R997.2 245.76,24.03 v1(245.65,24.14) 245.59,24.2 Q74.3 245.59,25.05 245.15,25.49 R958.2
N56281163: length 8.5
  BOTTOM w0.14: R948.2 244.85,26.25 245.28,25.82 246.32,25.82 246.59,26.09 Q74.6 246.8,26.52 v1(247.57,26.52) 247.71,26.52 248.28,25.95 248.28,24.4 248.04,24.16 247.63,24.16 247.31,23.84 246.88,23.84 246.55,23.51 R996.2
N56382763: length 4.1
  TOP w0.14: Q48.3 88.1,13.97 R599.1 88.1,12.72 88.31,12.5 90.09,12.5 R600.2
N56382839: length 5.9
  TOP w0.14: v1(88.84,15.26) 89.08,15.02 Q48.6 89.75,15.28 R558.1 ; v1(89.72,12.99) 89.72,13.17 R585.2
  IN3 w0.089: v1(88.84,15.26) 88.84,13.87 v1(89.72,12.99)
N56383035: length 5.5
  TOP w0.14: Q42.3 85.01,15.92 85.31,15.61 85.31,14.66 85.13,14.48 84.74,14.48 84.46,14.2 R584.1 84.46,13.79 84.78,13.47 85.08,13.47 85.3,13.26 R597.2 R598.2
N56390078: length 1.5
  BOTTOM w0.14: CN19.12 83.15,19.65 83.71,20.21 TP120.1
N56406548: length 8.7
  BOTTOM w0.14: Q75.2 92.87,22.59 93.07,22.8 C873.1 93.52,25.98 93.92,25.59 Q77.3 93.92,24.3 95.14,23.07 R1159.2
N56481431: length 2.8
  TOP w0.381: R392.2 39.29,26.91 40.01,26.18 C366.2 39.64,25.95 39.57,26.03 38.97,26.03 R407.2
N56481770: length 1.5
  TOP w0.254: C366.1 41.23,25.95 41.45,26.17 U20.9
N56482049: length 2
  TOP w0.14: C358.2 40.64,26.98 41,26.62 U20.8
N56482420:
  vias: v1(46.71,24.98)
N56482438:
  vias: v1(46.07,23.48)
N56543786: length 1.8
  TOP w0.254: C409.2 15.8,23.12 U22.8
N56543890: length 1.6
  TOP w0.254: U22.9 16.29,23.57 C401.1
N56544006: length 1.9
  TOP w0.254: U22.10 15.6,24.02 C388.1
N56544277: length 2.9
  TOP w0.381: C418.2 23.06,23.31 v1(23.16,23.41)
  BOTTOM w0.381: R974.2 23.16,23.48 v1(23.16,23.41) 23.51,23.05 R1002.2
N56544490: length 1.9
  TOP w0.254: C417.1 22.31,21.62 22.84,21.09 22.9,21.09 23.12,20.86 U25.10
N56544498: length 1.3
  TOP w0.14: U25.8 24.02,21.06 24.02,21.07 C419.2
N56546363:
  vias: v1(20.51,16.02)
N56753045: length 2.9
  BOTTOM w0.203: PR568.1 241.68,23.8 PC439.1 240.61,24.13 PU32.4
N56753133: length 1.4
  BOTTOM w0.14: PU32.12 241.01,27.7 241.09,27.78 241.09,28.39 PC423.1
N56753135: length 1.4
  BOTTOM w0.14: PC424.1 240.12,28.44 240.12,27.75 240.21,27.67 PU32.10
N56849590:
  vias: v1(52.6,34.92)
N56881941: length 3.7
  TOP w0.254: U1.1 U1.5 75.32,165.64 75.62,165.34 R7.1
N56914265: length 2.2
  BOTTOM w0.203: PR473.1 106.39,141.16 106.33,141.22 PQ43.1 106.53,141.66 106.78,141.9 PR472.1
N56915153: length 2.3
  TOP w0.203: PU7.8 99.15,152.83 98.86,152.54 98.86,151.73 v1(98.77,151.65) PR105.1
N56915158: length 1.3
  TOP w0.203: PU7.5 98.43,154.33 PR92.1
N56915160: length 1.5
  TOP w0.203: PR95.1 98.5,153.88 98.55,153.83 PU7.6
N56980326: length 2.8
  TOP w0.203: PQ13.2 113.26,139.11 112.72,138.57 PR130.1
N57158778: length 19
  TOP w0.14: R518.2 80.21,17.26 v1(80.21,17.79) 80.21,17.82 80.23,17.84 U18.56
  BOTTOM w0.14: v1(80.21,17.79) 81.68,16.32 81.68,14.39 82.44,13.63 84.22,13.63 85.35,12.5 89.95,12.5 91.46,14.01 91.46,14.52 92.19,15.25 R1162.2
N57158785: length 1.7
  TOP w0.14: U18.57 80.63,18.49 80.9,18.22 R517.2
N57203085: length 19
  TOP w0.14: v1(30.5,78.87) 30.48,78.87 29.79,79.56 UG3.1 29.19,79.94 30.09,80.84 RG68.2
  IN1 w0.086: v1(30.5,78.87) 31.32,79.7 33.82,79.7 34.81,80.69 35.73,80.69 v1(36.31,80.12)
  BOTTOM w0.14: UG6.1 41.53,81.42 40.84,80.73 39.55,80.73 v1(39.32,80.96) 39.19,80.96 38.56,80.33 38.56,79.53 38.14,79.11 38.14,78.86 37.95,78.67 UG11.4 36.81,78.67 36.53,78.95 36.53,79.89 v1(36.31,80.12)
N57219273: length 2.1
  BOTTOM w0.14: RG175.1 RG176.1 10.84,85.9 10.83,85.9 UG5.5
N57227413: length 2.3
  TOP w0.14: RG75.1 33.48,79.71 RG73.1 32.12,79.71 31.96,79.56 UG3.5
N57230212: length 3.1
  TOP w0.203: v1(42.16,82.54) 42.32,82.38 RG64.1 RG63.1
  BOTTOM w0.254: v1(42.16,82.54) 41.53,83.17 UG6.5
N57230715: length 1.9
  BOTTOM w0.14: RG193.1 RG194.1 34.79,78.18 34.7,78.27 UG8.5
N57233291: length 2.4
  BOTTOM w0.14: UG11.5 37.58,80.85 RG187.1 37.51,81.41 37.24,81.68 RG186.1
N57517898: length 1.3
  TOP w0.14: QG5.1 25.88,97.78 RG25.2
N57587352: length 0.8
  TOP w0.14: PC30.2 12.72,164.9 12.52,165.09 PR572.2
N57588964: length 0.8
  TOP w0.14: PR574.2 11.19,165 PC29.1
N58187744: length 1.6
  TOP w0.14: U18.64 83.43,18.71 83.8,18.34 TP131.1
N58187751: length 2
  TOP w0.14: TP132.1 84.35,20.33 84.16,20.52 84.16,20.87 84.31,21.02 U18.65
N58349202: length 2.4
  TOP w0.14: v1(34.12,33.41) 34.01,33.29 34.01,32.57 34.22,32.36 U17.56
  BOTTOM w0.14: R1149.2 34.25,33.53 v1(34.12,33.41)
N58457890: length 18.6
  TOP w0.508: PR575.2 14.29,83.84 14.59,84.14 14.59,84.86 v1(14.27,85.18)
  IN3 w0.508: v1(14.27,85.18) 14.37,85.18 15.74,86.55 16.12,86.55 18.6,89.03 18.6,91.87 19.6,92.87 21.43,92.87 21.93,92.37 v1(21.93,92.05)
N58458180: length 5.3
  TOP w0.14: v1(21.28,92.07) 20.74,92.61 PU11.5
  BOTTOM w0.14: v1(21.28,92.07) 21.22,92.12 PR578.2 22.16,93.02 22.67,93.53 22.67,94.19 22.19,94.68 PC447.1
N58458766: length 1.8
  TOP w0.14: PU11.10 20.74,95.87 v1(20.82,95.95)
  BOTTOM w0.14: v1(20.82,95.95) 20.93,95.84 PC448.1
N58530481: length 4.7
  TOP w0.14: U6.1 210.99,50.45 210.31,51.12 208.9,51.12 208.33,51.7 R1152.1 R1151.1
N59529757: length 4.5
  BOTTOM w0.14: R1161.2 94.8,17.76 Q79.2 95.08,17.57 C945.1
N59747615: length 22.7
  BOTTOM w0.14: PQ59.2 177.05,19.64 177.05,26.73 177.31,26.99 177.31,27.52 177.56,27.78 177.56,33.06 180.19,35.69 PQ58.3 180.19,37.43 180.3,37.54 PR582.1 180.3,39.36 180.39,39.46 PR580.2
N59747617: length 2.5
  BOTTOM w0.508: PR581.2 175.66,16.6 176.13,17.08 PQ59.3
N59809104: length 9.4
  BOTTOM w0.381: Q81.2 102.51,155.69 Q80.3 101.73,159.16 101.36,158.79 R1168.1 100.73,159.12 101.85,160.24 R1166.2
N59809106: length 2.5
  BOTTOM w0.508: Q81.3 103.23,153.05 R1167.2
N62406391: length 4.6
  TOP w0.305: v1(37.24,82.2) 36.85,82.59 QG12.5
  IN2 w0.305: v1(37.24,82.2) 36.68,82.76 33.99,82.76 v1(33.9,82.67)
N62406446: length 1.8
  TOP w0.14: QG11.3 QG11.2 29.89,82.59 29.64,82.35 RG60.2
N62406461: length 2.8
  TOP w0.14: RG69.2 31.85,80.56 31.66,80.75 31.66,82.3 31.95,82.59 QG11.5
N597246311: length 1.4
  TOP w0.508: PR424.2 PC292.1

## Copper pours and planes (outline as drawn)
1V8_ANX on TOP (solid shape): 279.77,40.25 279.77,39.18 279.62,39.03 279.11,39.03 278.99,39.16 278.99,40.17 279.16,40.35 279.67,40.35
1V8_ANX on TOP (solid shape): 258.9,22.6 258.9,22.42 259.3,22.01 259.3,21.2 259.23,21.12 258.82,21.12 258.62,21.33 258.62,21.45 257.93,22.14 257.73,22.14 257.57,22.29 257.57,22.67 257.7,22.8 258.69,22.8
1V8_ANX on TOP (solid shape): 266.49,15.71 266.49,15.52 267,15.01 267.68,15.01 268.4,14.29 268.4,12.92 268.24,12.77 267.66,12.77 267.51,12.92 267.51,13.91 267.2,14.22 266.67,14.22 266.24,14.65 266.24,14.74 266.24,14.74 266.24,15.73 266.24,15.74 266.26,15.76 266.44,15.76
1V8_ANX on TOP (solid shape): 258.39,33.85 259.04,33.85 259.1,33.85 259.17,33.87 259.56,33.87 259.59,33.86 259.61,33.82 259.61,33.72 259.59,33.68 259.56,33.67 259.17,33.67 259.1,33.69 259.04,33.69 258.25,33.69 258.17,33.61 257.67,33.61 257.24,33.19 256.86,33.19 256.79,33.27 256.79,33.77 257.08,34.07 257.22,34.07 257.3,34.09 257.38,34.13 258.1,34.13
1V8_ANX on TOP (solid shape): 241.77,20.43 241.85,20.37 241.87,20.36 241.88,20.33 241.88,20.22 241.77,20.08 241.73,19.91 241.77,19.74 241.88,19.6 241.88,19.35 241.27,18.74 240.02,18.74 239.92,18.84 239.92,19.07 239.99,19.13 240.76,19.13 241.05,19.13 241.27,19.35 241.27,20.15 241.29,20.17 241.29,20.4 241.43,20.54 241.66,20.54
1V8_ANX on TOP (solid shape): 261.56,37.99 261.56,36.69 261.54,36.67 261.54,35.68 261.54,35.68 261.36,35.68 261.34,35.7 261.34,36.67 261.31,36.69 261.31,37.33 261.21,37.43 261.21,37.44 261.13,37.56 261.01,37.63 261,37.64 260.98,37.66 260.72,37.66 260.49,37.9 260.48,37.91 260.39,38.06 260.24,38.15 260.23,38.16 260.12,38.26 260.11,38.3 260.12,38.33 260.15,38.36 260.15,38.98 260.17,39.02 260.2,39.03 260.52,39.03
1V8_ANX on TOP (solid shape): 250.23,17.11 250.27,17.1 250.28,17.06 250.28,16.88 250.94,16.22 250.96,16.2 250.96,16.18 250.96,16.15 251.07,15.87 251.35,15.75 251.39,15.75 251.41,15.75 251.43,15.74 251.61,15.56 251.61,14.19 251.45,14.04 251.21,14.04 251.19,14.04 251.17,14.06 251.06,14.16 250.93,14.22 250.91,14.22 250.82,14.32 250.82,15.41 250.39,15.84 249.22,15.84 249.04,16.02 249.03,16.04 249.03,16.06 249.04,16.11 249.04,16.16 248.99,16.35 248.84,16.51 248.84,16.53 248.84,16.93 249.01,17.11
1V8_ANX on BOTTOM (solid shape): 279.8,40.17 279.8,39.28 279.55,39.03 278.94,39.03 278.83,39.13 278.83,40 279.14,40.3 279.67,40.3
1V8_ANX on BOTTOM (solid shape): 233.56,12.09 233.56,11.26 233.98,10.84 233.98,9.29 233.75,9.06 231.69,9.06 231.41,9.34 231.41,12.72 231.67,12.97 232.68,12.97
1V8_ANX on BOTTOM (solid shape): 268.62,25.57 268.62,24.91 267.73,24.02 267.73,23.05 267.63,22.95 266.72,22.95 266.59,23.08 266.59,24.68 267.63,25.72 268.47,25.72
1V8_ANX on BOTTOM (solid shape): 264,23.94 264,23.69 263.99,23.64 263.99,23.59 263.99,23.54 264,23.49 264,23.33 265.04,22.29 265.04,21.81 264.95,21.71 264.5,21.71 263.29,22.93 263.29,23.79 263.54,24.04 263.9,24.04
1V8_ANX on BOTTOM (solid shape): 266.21,33.22 268.32,33.22 268.58,32.95 268.59,32.76 268.6,32.71 268.6,32.38 268.58,32.36 267.93,32.36 267.81,32.24 267.81,31.54 267.28,31 266.07,31 266.04,31.02 265.99,31.04 265.6,31.44 265.6,32 265.3,32.3 265.3,32.62 265.31,32.65 265.61,32.79 265.72,33.06 265.71,33.13 265.69,33.2 265.7,33.23 265.8,33.34 266.08,33.34
1V8_ANX on IN2 (solid shape): outline of 1438 points within 257.3,21.63 266.26,38.55
1V8_ANX on IN3 (solid shape): outline of 2484 points within 232.56,9.06 268.12,24.1
1V8_MAIN_S on TOP (solid shape): 17.68,99.25 17.68,98.12 17.72,98.03 17.82,97.99 18.08,97.99 18.21,97.86 18.25,97.82 18.95,97.11 18.95,96.33 19.28,96.01 19.28,95.93 19.64,95.57 19.64,94.71 19.58,94.64 18.85,94.64 18.6,94.9 17.94,94.9 17.8,95.04 17.8,95.24 17.64,95.4 17.64,95.44 17.65,95.46 17.73,95.58 17.76,95.73 17.71,95.92 17.58,96.07 17.57,96.07 17.54,96.11 17.54,97.02 17.37,97.2 16.36,97.2 16.18,97.38 16.18,99.4 16.29,99.51 17.41,99.51
3V3_SYS on TOP (solid shape): 279.19,26.76 279.19,24.32 279.18,24.29 279.14,24.27 277.23,24.27 277.01,24.5 277.01,25.11 277.72,25.82 277.72,26.92 277.84,27.04 278.91,27.04
3V3_SYS on BOTTOM (solid shape): 264.18,30.8 264.18,30.32 264.71,29.79 264.71,29.18 264.61,29.07 264.31,29.07 263.65,29.73 263.16,29.73 262.6,30.29 262.6,30.8 262.71,30.9 264.08,30.9
3V3_SYS on BOTTOM (solid shape): 227,12.82 227.03,12.81 227.19,12.63 227.4,12.58 227.46,12.58 227.54,12.6 227.57,12.6 227.98,12.18 227.98,9.34 227.76,9.11 225.75,9.11 225.42,9.44 225.42,12.69 225.54,12.81 225.73,12.81 225.74,12.82
3V3_SYS on BOTTOM (solid shape): outline of 367 points within 242.74,9.14 266.85,12.26
