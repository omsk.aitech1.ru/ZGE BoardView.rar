# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
C_PEG_TXN2: length 8.5
  TOP w0.089: U3.B12 120.5,112.35 120.59,112.26 120.59,112.17 120.46,112.04 117.51,112.04 117.47,112.08 117.44,112.08
  TOP w0.14: C86.2 113.71,110.32 114.92,110.32 116.69,112.08 117.44,112.08
C_PEG_TXN3: length 6.9
  TOP w0.089: U3.B13 120.13,113.04 120.13,112.89 119.91,112.67 119.27,112.67 119.07,112.87 118.08,112.87 117.92,112.71 117.57,112.71 117.53,112.67 117.5,112.67 ; 117.44,112.67 117.47,112.67
  TOP w0.14: 117.44,112.67 116.41,112.67 115.06,111.32 114.75,111.32 C85.2 ; 117.47,112.67 117.5,112.67
C_PEG_TXN4: length 8.3
  TOP w0.089: U3.B14 120.53,113.93 120.59,113.86 120.59,113.75 120.45,113.61 119.23,113.61 119.12,113.5 118.46,113.5 118.22,113.74 117.51,113.74 117.47,113.78 117.44,113.78
  TOP w0.14: 117.44,113.78 115.69,113.78 114.75,112.84 113.73,112.84 C82.2
C_PEG_TXN5: length 6.4
  TOP w0.089: U3.B15 120.11,114.59 120.11,114.43 119.92,114.24 119.22,114.24 119.07,114.39 117.51,114.39 117.47,114.35 117.44,114.35
  TOP w0.14: C81.2 114.75,113.86 114.95,113.86 115.44,114.35 117.44,114.35
C_PEG_TXN6: length 8
  TOP w0.089: U3.B16 120.49,115.5 120.59,115.4 120.59,115.31 120.49,115.21 119.4,115.21 119.3,115.1 118.71,115.1 118.43,115.38 117.51,115.38 117.47,115.43 117.44,115.43
  TOP w0.14: 117.44,115.43 113.62,115.43 113.48,115.57 C78.2
C_PEG_TXN7: length 6.4
  TOP w0.089: U3.B17 120.14,116.19 120.14,116.05 119.9,115.82 119.27,115.82 119.08,116.01 117.44,116.01
  TOP w0.14: C77.2 114.49,116.22 114.63,116.36 115.07,116.36 115.43,116.01 117.44,116.01
C_PEG_TXN8: length 8.3
  TOP w0.089: 117.44,116.84 117.47,116.84 117.51,116.88 118.19,116.88 118.56,116.51 119.31,116.51 119.38,116.58 120.51,116.58 120.74,116.81 120.74,116.94 U3.C18
  TOP w0.14: C75.2 113.72,117.66 115.8,117.66 116.62,116.84 117.44,116.84
C_PEG_TXN9: length 6.8
  TOP w0.089: U3.A19 119.84,117.87 119.93,117.78 119.93,117.71 119.79,117.57 119.4,117.57 119.3,117.67 118.28,117.67 118.08,117.87 117.51,117.87 117.47,117.92 117.44,117.92
  TOP w0.14: C72.2 114.49,119.46 114.63,119.32 115.69,119.32 117.09,117.92 117.44,117.92
C_PEG_TXN10: length 8.8
  TOP w0.089: 117.44,118.57 117.45,118.57 117.64,118.38 118.28,118.38 118.61,118.05 119.3,118.05 119.42,118.18 120.52,118.18 120.74,118.41 120.74,118.51 U3.C20
  TOP w0.14: 117.44,118.57 117.22,118.57 115.46,120.32 113.72,120.32 C71.2
C_PEG_TXN11: length 7.2
  TOP w0.089: 117.63,119.69 117.65,119.67 117.65,119.61 117.8,119.45 117.84,119.45 118.06,119.24 119.28,119.24 119.37,119.14 119.78,119.14 119.89,119.25 119.89,119.35 119.8,119.44 U3.A21
  TOP w0.14: C68.2 114.77,121.83 115.49,121.83 117.63,119.69
C_PEG_TXN12: length 9.1
  TOP w0.089: U3.C22 120.77,120.11 120.77,119.98 120.51,119.73 119.32,119.73 119.23,119.63 118.54,119.63 117.52,120.65 117.46,120.65 117.44,120.67
  TOP w0.14: 117.44,120.67 115.89,122.22 115.27,122.84 113.69,122.84 C67.2
C_PEG_TXN13: length 7.9
  TOP w0.089: U3.A23 119.88,121.01 119.94,120.96 119.94,120.81 119.83,120.69 119.37,120.69 119.22,120.85 118.43,120.85 117.67,121.61 117.67,121.92 117.24,122.35 117.24,122.42 117.23,122.43
  TOP w0.14: 117.23,122.43 115.26,124.4 114.67,124.4 114.47,124.59 C63.2
C_PEG_TXN14: length 10
  TOP w0.089: U3.C24 120.78,121.7 120.78,121.58 120.5,121.3 119.33,121.3 119.24,121.21 118.64,121.21 118.2,121.65 118.2,122.32 117.69,122.83 117.63,122.83
  TOP w0.14: 117.63,122.83 116.8,123.65 115.32,125.13 115.05,125.4 113.62,125.4 113.48,125.26 C61.2
C_PEG_TXN15: length 8.1
  TOP w0.089: U3.A25 119.71,122.59 119.77,122.53 119.77,122.39 119.68,122.3 119.39,122.3 119.14,122.55 119.02,122.55 118.59,122.98 118.59,123.34 118.41,123.52 118.41,123.58 118.39,123.6
  TOP w0.14: 118.39,123.6 115.15,126.84 114.63,126.84 114.49,126.98 C57.2
C_PEG_TXP0: length 8.9
  TOP w0.089: 117.43,110.13 117.47,110.18 118.25,110.18 118.37,110.3 120.54,110.3 120.74,110.51 120.74,110.64 U3.C10
  TOP w0.14: 117.43,110.13 117.41,110.13 114.76,107.47 113.7,107.47 C91.2
C_PEG_TXP1: length 7.3
  TOP w0.089: U3.A11 119.88,111.57 119.93,111.51 119.93,111.38 119.82,111.27 119.15,111.27 118.92,111.5 118.23,111.5 117.93,111.19 117.51,111.19 117.47,111.24 117.44,111.24
  TOP w0.14: 117.44,111.24 116.99,111.24 114.8,109.04 114.66,109.04 114.49,109.21 C88.2
C_PEG_TXP2: length 8.5
  TOP w0.089: U3.C12 120.77,112.24 120.77,112.09 120.54,111.86 117.51,111.86 117.47,111.81 117.44,111.81
  TOP w0.14: C87.2 113.69,110.05 115.03,110.05 116.8,111.81 117.44,111.81
C_PEG_TXP3: length 6.8
  TOP w0.089: 117.44,112.94 117.53,112.94 117.57,112.89 117.85,112.89 118,113.05 119.14,113.05 119.34,112.84 119.83,112.84 119.95,112.97 119.95,113.08 119.89,113.14 U3.A13
  TOP w0.14: C84.2 114.73,111.59 114.95,111.59 116.3,112.94 117.44,112.94
C_PEG_TXP4: length 8.3
  TOP w0.089: 117.44,113.52 117.47,113.52 117.51,113.56 118.15,113.56 118.39,113.33 119.2,113.33 119.3,113.43 120.53,113.43 120.77,113.68 120.77,113.81 U3.C14
  TOP w0.14: C83.2 113.72,112.58 114.86,112.58 115.8,113.52 117.44,113.52
C_PEG_TXP5: length 6.4
  TOP w0.089: 117.44,114.61 117.47,114.61 117.51,114.57 119.14,114.57 119.3,114.42 119.85,114.42 119.93,114.5 119.93,114.65 119.87,114.72 U3.A15
  TOP w0.14: C80.2 114.49,114.27 114.63,114.13 114.84,114.13 115.33,114.61 117.44,114.61
C_PEG_TXP6: length 8
  TOP w0.089: 117.44,115.16 117.47,115.16 117.51,115.21 118.36,115.21 118.64,114.93 119.37,114.93 119.47,115.03 120.56,115.03 120.77,115.24 120.77,115.39 U3.C16
  TOP w0.14: C79.2 113.76,115.16 117.44,115.16
C_PEG_TXP7: length 6.4
  TOP w0.089: U3.A17 119.89,116.29 119.96,116.22 119.96,116.13 119.82,115.99 119.35,115.99 119.16,116.18 117.55,116.18 117.46,116.27 117.44,116.27
  TOP w0.14: C76.2 114.77,116.63 115.18,116.63 115.54,116.27 117.44,116.27
C_PEG_TXP8: length 8.3
  TOP w0.089: 117.44,117.1 117.47,117.1 117.51,117.06 118.27,117.06 118.64,116.69 119.24,116.69 119.31,116.75 120.43,116.75 120.57,116.89 120.57,116.99 120.48,117.08 U3.B18
  TOP w0.14: C74.2 113.48,118.06 113.62,117.92 115.92,117.92 116.73,117.1 117.44,117.1
C_PEG_TXP9: length 6.8
  TOP w0.089: 117.44,117.65 117.47,117.65 117.51,117.69 118,117.69 118.21,117.49 119.23,117.49 119.33,117.39 119.87,117.39 120.11,117.63 120.11,117.74 U3.B19
  TOP w0.14: 117.44,117.65 116.98,117.65 115.58,119.05 114.74,119.05 C73.2
C_PEG_TXP10: length 8.7
  TOP w0.089: 117.44,118.83 117.46,118.83 117.74,118.56 118.36,118.56 118.68,118.23 119.23,118.23 119.35,118.36 120.44,118.36 120.57,118.48 120.57,118.58 120.49,118.65 U3.B20
  TOP w0.14: 117.44,118.83 117.33,118.83 115.57,120.59 113.73,120.59 C70.2
C_PEG_TXP11: length 7.2
  TOP w0.089: 117.44,119.5 117.46,119.49 117.52,119.49 117.73,119.28 117.77,119.28 117.99,119.06 119.21,119.06 119.3,118.96 119.86,118.96 120.07,119.18 120.07,119.27 U3.B21
  TOP w0.14: 117.44,119.5 115.6,121.34 115.38,121.57 114.71,121.57 C69.2
C_PEG_TXP12: length 9.2
  TOP w0.089: U3.B22 120.48,120.23 120.58,120.13 120.58,120.05 120.44,119.9 119.25,119.9 119.15,119.81 118.61,119.81 117.65,120.78 117.65,120.84 117.63,120.85
  TOP w0.14: C65.2 113.75,123.1 115.38,123.1 117.63,120.85
C_PEG_TXP13: length 8
  TOP w0.089: U3.B23 120.13,120.91 120.13,120.74 119.9,120.51 119.3,120.51 119.15,120.67 118.36,120.67 117.49,121.53 117.49,121.85 117.12,122.23 117.05,122.23 117.04,122.24
  TOP w0.14: C64.2 114.47,124.05 114.55,124.13 115.15,124.13 115.69,123.59 117.04,122.24
C_PEG_TXP14: length 10
  TOP w0.089: U3.B24 120.54,121.8 120.59,121.76 120.59,121.64 120.43,121.48 119.26,121.48 119.17,121.39 118.71,121.39 118.38,121.73 118.38,122.39 117.83,122.94 117.83,123 117.81,123.02
  TOP w0.14: 117.81,123.02 116.99,123.84 115.16,125.67 113.73,125.67 C59.2
C_PEG_TXP15: length 8.1
  TOP w0.089: 118.2,123.41 118.22,123.39 118.28,123.39 118.41,123.27 118.41,122.9 118.94,122.37 119.07,122.37 119.32,122.12 119.77,122.12 U3.B25
  TOP w0.14: C58.2 114.63,126.57 115.04,126.57 115.43,126.18 118.2,123.41
C_SPKL+: length 23.2
  IN2 w0.762: 51.12,16.38 48.58,16.38 47.59,17.38 38.01,17.38 37.67,17.72 28.45,17.72
  vias: v1(27.17,16.13) v1(27.46,15.52) v1(52.65,17.09) v1(53.33,17.09)
C_SPKL-: length 36.2
  IN3 w0.762: 21.23,15 21.23,16.02 22.04,16.83 25.73,16.83 27.05,18.15 37.86,18.15 38.77,17.25 47.14,17.25 49.36,15.03 54.2,15.03
  vias: v1(19.58,14.39) v1(20.26,14.39) v1(54.91,15.54) v1(55.59,15.54)
C_TX0_HDMI+: length 4.5
  BOTTOM w0.14: U34.17 55.62,163.96 55.73,163.86 56.67,163.86 57.05,163.48 59.11,163.48 R636.1
C_TX0_HDMI-: length 4.5
  BOTTOM w0.14: R635.1 59.05,163.9 57.22,163.9 56.85,164.28 55.9,164.28 55.81,164.36 U34.16
C_TX1_HDMI+: length 2.6
  BOTTOM w0.14: R638.1 57.29,161.72 56.44,162.56 55.99,162.56 55.79,162.76 U34.20
C_TX1_HDMI-: length 2.6
  BOTTOM w0.14: R637.1 57.21,162.58 57.02,162.58 56.62,162.98 56.3,162.98 56.01,163.27 55.81,163.27 55.71,163.16 U34.19
C_TX2_HDMI+: length 4.5
  BOTTOM w0.14: R644.1 58.85,160.78 56.4,160.78 55.62,161.56 U34.23
C_TX2_HDMI-: length 4.5
  BOTTOM w0.14: U34.22 55.81,161.96 56.57,161.2 58.98,161.2 59.18,161.4 R639.1
C_TXC_HDMI+: length 2.4
  BOTTOM w0.14: R634.1 57.06,164.89 56.75,164.89 56.47,165.16 U34.14
C_TXC_HDMI-: length 2.5
  BOTTOM w0.14: U34.13 56.72,165.56 56.98,165.31 57.22,165.31 57.39,165.47 R632.1
CAD_SNK: length 41.9
  TOP w0.14: U1.2 75.12,164.99 75.27,164.84 76.28,164.84 R9.1 76.74,163.96 v1(76.96,163.74)
  IN1 w0.086: v1(72.67,159.2) 72.84,159.37 78.42,159.37 78.8,159.74 78.8,161.13 76.96,162.98 v1(76.96,163.74)
  IN3 w0.089: CN2.13 88.82,163.78 v1(90.31,163.78)
  BOTTOM w0.14: v1(72.67,159.2) 72.84,159.03 Q58.2 ; v1(90.31,163.78) 90.16,163.63 83.52,163.63 82.95,163.06 82.95,162.2 83.35,161.8 83.35,161.39 ESD1.6 83.36,161.12 83.36,160.53 ESD1.5 83.34,160.26 83.34,159.95 83.25,159.85 82.87,159.85 82.71,160 82.71,160.84 R640.2 82.41,161.78 82.41,162.72 82.05,163.08 78.78,163.08 78.12,163.74 v1(76.96,163.74)
CAD_SNK_R_DP: length 29.7
  TOP w0.14: U1.4 75.33,164.34 75.37,164.38 R9.2 75.96,164.02 v1(75.69,163.74)
  BOTTOM w0.14: U39.29 89.62,154.71 89.05,155.29 89.05,156.33 88.63,156.74 R649.1 88.63,159.12 88.66,159.15 R647.1 88.66,160.15 90.38,161.88 v1(90.38,162.47) 91.09,163.19 91.09,163.88 90.61,164.37 88.85,164.37 88.4,163.91 82.51,163.91 82.06,163.47 78.81,163.47 78.08,164.2 76.14,164.2 v1(75.69,163.74)
CAD_SNK_R_EDP: length 3.2
  BOTTOM w0.14: R704.1 173.64,96.08 173.74,95.98 R705.1 174.09,95.29 174.73,94.65 U41.29
CATERR#: length 16.2
  TOP w0.14: v1(165.56,122.04) 165.78,122.04 166.24,121.58 TP6.1 166.24,121.12 166.08,120.97 R78.2 166.53,119.93 Q8.5 ; v1(157.94,125.9) 157.61,126.23 U3.BM30
  IN2 w0.102: v1(165.56,122.04) 165.28,122.32 164.69,122.32 164.53,122.47 164.53,123.76 164.09,124.21 164.09,125.92 163.09,126.92 162.17,126.92 160.75,125.5 158.34,125.5 v1(157.94,125.9)
CCD_PWR: length 6.5
  IN1 w0.508: v1(174.87,133.22) 174.62,133.47 v1(171.95,133.47)
  BOTTOM w0.508: 173.73,130.7 171.95,132.48 v1(171.95,133.47)
CEN_SPK: length 6.1
  TOP w0.203: v1(25.65,29.81) 25.9,30.06 26.53,30.06 26.64,29.96 U17.21
  BOTTOM w0.381: v1(25.65,29.81) 25.47,29.81 24.56,28.9 v1(24.56,27.55) 23.85,26.85 C863.2
CFG2: length 5.7
  TOP w0.079: 160.83,122.66 158.72,122.66 158.26,123.12 U3.BN26
  TOP w0.089: 160.83,122.66 161.2,123.03 163.33,123.03 R75.1
CFG4: length 5
  TOP w0.14: U3.BR20 159.95,118.81 161.54,118.81 162.1,119.36 v1(163.15,119.36) 163.53,118.98 R79.1
CFG5: length 8.1
  TOP w0.079: U3.BM20 157.94,118.1 157.94,117.53 158.29,117.19 160.39,117.19 160.79,116.79
  TOP w0.089: 160.79,116.79 161.99,115.6 v1(163.19,115.6) 163.33,115.6 163.53,115.8 R84.1
CFG6: length 3.7
  TOP w0.127: U3.BT20 162.57,118.42 R81.1
CFG_RCOMP: length 3.5
  TOP w0.305: R77.1 163.01,122.36 U3.BT25
CHA_DIMM0_SA0: length 7.9
  TOP w0.14: JDIM2.256 107.32,36.26 107.46,36.12 107.95,36.12 108.32,35.76 111.46,35.76 111.94,35.28 v1(111.94,35.22) R325.2 111.95,34.39 R324.2
CHA_DIMM0_SA1: length 6.8
  TOP w0.14: R323.2 109.95,34.44 R317.2 v1(109.92,35.27) 109.32,35.27 109.11,35.48 108.21,35.48 107.87,35.82 106.82,35.82 106.32,36.31 JDIM2.260
CHA_DIMM0_SA2: length 4.9
  TOP w0.14: R329.2 R330.2 129.49,34.21 130.1,34.82 v1(130.1,35.25) 130.1,35.7 129.82,35.97 JDIM2.166
CHA_DIMM1_SA0: length 20
  TOP w0.14: R322.1 105.98,34.44 R315.1 105.85,34.57 v1(105.85,35.27) 105.85,35.69 105.35,36.19 105.35,37.92 106,38.57 106,39.23 105.2,40.03 102.75,40.03 101.95,40.83 101.95,43.09 103.04,44.19 103.45,44.19 103.73,43.91 v1(103.73,43.3)
  BOTTOM w0.14: v1(103.73,43.3) 105.1,43.3 105.52,43.72 105.52,44 105.42,44.1 JDIM4.256
CHA_DIMM1_SA1: length 18.4
  TOP w0.14: v1(103.22,43.7) 102.99,43.7 102.23,42.94 102.23,40.95 102.87,40.31 105.32,40.31 106.24,39.39 106.24,38.42 105.63,37.81 105.63,36.4 106.51,35.52 107.5,35.52 v1(107.75,35.27) 107.75,34.63 R314.2 108.33,34.46 108.34,34.47 R316.2
  BOTTOM w0.14: v1(103.22,43.7) 103.32,43.81 104.08,43.81 104.42,44.15 JDIM4.260
CHA_DIMM1_SA2: length 72
  IN3 w0.089: v1(127.46,41.45) 126.51,42.39 126.51,43.48 125.3,44.68 112.1,44.68 107.97,48.81 107.97,57.16 109.95,59.14 112.44,59.14 114.01,60.71 v1(114.01,61.29)
  BOTTOM w0.102: JDIM4.166 127.92,44.25 128.16,44.02 128.16,42.15 v1(127.46,41.45)
  BOTTOM w0.14: R722.2 92.12,66.51 92.12,66.92 92.34,67.14 R719.2 92.57,66.95 92.88,66.64 93.64,66.64 93.77,66.77 94.46,66.77 94.68,66.55 94.68,66.43 96.04,65.07 97.09,65.07 97.42,64.74 v1(97.68,64.74) 97.79,64.74 97.97,64.92 98.91,64.92 99.34,64.49 99.34,62.22 101.04,60.53 105.2,60.53 106.11,61.45 113.86,61.45 v1(114.01,61.29)
CHB_DIMM0_SA0: length 11.3
  TOP w0.14: JDIM1.256 107.32,51.41 107.13,51.6 105.51,51.6 100.96,47.06 100.82,47.06 R186.2 100.3,46.74 R185.2
CHB_DIMM0_SA1: length 12.3
  TOP w0.14: R198.1 99.76,43.85 R199.1 101.74,43.85 102.86,44.97 102.86,48.2 103.89,49.23 105.15,49.23 105.38,49 106.1,49 106.32,49.22 JDIM1.260
CHB_DIMM0_SA2: length 28.8
  TOP w0.14: v1(116.49,48.33) 117,48.84 117.76,48.84 118.07,48.54 126.45,48.54 126.58,48.4 128.3,48.4 128.63,48.73 129.28,48.73 129.82,49.28 JDIM1.166
  BOTTOM w0.14: R805.2 104.6,47.98 105.05,48.43 105.6,48.43 105.81,48.64 106.69,48.64 107.03,48.3 R802.2 107.03,47.6 107.32,47.32 107.88,47.32 108.89,48.34 116.48,48.34 v1(116.49,48.33)
CHB_DIMM1_SA0: length 15.9
  BOTTOM w0.14: JDIM3.256 105.42,59.69 105.12,60 104,60 103.69,59.68 103.69,58.65 103.39,58.34 102.72,58.34 101.97,57.6 101.97,55.41 100.7,54.14 100.7,53.68 98.96,51.95 98.51,51.95 98.27,52.18 98.27,52.47 98.09,52.65 R776.1 97.81,53.45 R770.1
CHB_DIMM1_SA1: length 12
  BOTTOM w0.14: R797.1 97.5,49.79 97.96,50.26 98.22,50.26 98.42,50.46 98.42,50.66 R790.1 98.84,51.08 98.84,51.25 104.42,56.83 JDIM3.260
CHB_DIMM1_SA2: length 41.9
  BOTTOM w0.14: JDIM3.166 127.92,59.42 127.52,59.82 122.72,59.82 v1(121.87,60.68) 121.38,61.17 120.2,61.17 119.96,60.93 115.16,60.93 115.05,60.82 113.38,60.82 113.27,60.93 107.59,60.93 107.36,61.17 106.23,61.17 105.32,60.25 100.92,60.25 99.07,62.11 99.07,63.35 98.14,64.27 97.44,64.27 96.92,64.79 94.97,64.79 94.71,64.53 94.71,64.35 94.38,64.02 93.59,64.02 R724.2 92.83,64.2 92.4,63.77 92.4,63.37 R725.2
CL_CLK: length 7.8
  TOP w0.102: U14.AR2 204.51,28.62 204.97,28.62 205.2,28.85 205.2,28.85 v1(205.23,28.88)
  BOTTOM w0.102: 201.92,29.79 203.58,29.79 EC10.2 204.5,28.87 205.22,28.87 v1(205.23,28.88)
  BOTTOM w0.14: 201.92,29.79 201.64,29.79 200.96,29.1 200.8,29.1 200.39,28.69 TP125.1
CL_DATA: length 7.4
  TOP w0.14: U14.AT5 205.78,28.74 205.78,29.23 v1(205.75,29.25)
  BOTTOM w0.14: v1(205.75,29.25) 205.71,29.25 205.43,29.53 204.59,29.53 204.11,30.01 202.82,30.01 202.78,30.05 201.53,30.05 200.97,29.49 200.07,29.49 TP126.1
CL_RST#: length 2.3
  TOP w0.102: U14.AU4 205.3,28.29 205.66,27.93 v1(205.78,27.93)
  BOTTOM w0.14: TP127.1 204.67,27.93 v1(205.78,27.93)
CLK_CPU_BCLKN: length 161.8
  TOP w0.079: U3.A32 119.43,127.61 119.21,127.61 119.08,127.74 118.33,127.74 118.18,127.89 118.18,128.09 118.33,128.24 v1(118.48,128.24)
  TOP w0.089: v1(207.12,50.33) 207.12,50.19 206.99,50.07 206.72,50.07 206.42,49.77 206.42,47.31 206.52,47.22 206.52,46.24 206.67,46.1 206.67,45.18 206.91,44.95 U14.C8
  IN4 w0.086: v1(118.48,128.24) 118.18,127.94 118.18,127.69 118.45,127.43 119.42,127.43 119.85,127 119.85,125.02 117.16,122.34 117.16,111.17 114.95,108.96 114.95,106.43 112.39,103.87 112.39,102.87 111.3,101.77 111.3,96.23 122.28,85.25 123.7,85.25 126.54,82.41 165.66,82.41 178.99,69.08 179.6,69.08 184.22,64.46 184.22,63.57 187.38,60.4 188.07,60.4 188.62,59.86 189.27,59.86 190.32,58.82 191.54,58.82 193.14,57.22 201.36,57.22 201.41,57.18 201.44,57.18 201.57,57.04 206.64,51.98 206.64,50.22 206.77,50.09 206.88,50.09 v1(207.12,50.33)
CLK_CPU_BCLKP: length 162.1
  TOP w0.079: U3.B31 120.11,127.44 119.15,127.44 119.15,127.45 119.01,127.58 118.27,127.58 118.02,127.83 118.02,128.09 117.87,128.24 v1(117.72,128.24)
  TOP w0.089: U14.B8 206.85,45.41 206.85,46.17 206.7,46.32 206.7,47.29 206.6,47.39 206.6,49.7 206.79,49.89 206.91,49.89 v1(207.12,49.68)
  IN4 w0.086: v1(207.12,49.68) 206.87,49.93 206.7,49.93 206.47,50.16 206.47,51.91 201.5,56.87 201.5,56.87 201.37,57.01 201.34,57.01 201.29,57.06 193.07,57.06 191.48,58.65 190.25,58.65 189.21,59.69 188.55,59.69 188.01,60.24 187.31,60.24 184.05,63.5 184.05,64.4 179.53,68.92 178.92,68.92 165.6,82.24 126.47,82.24 123.64,85.08 122.21,85.08 111.13,96.16 111.13,101.84 112.23,102.93 112.23,103.94 114.79,106.5 114.79,109.03 117,111.24 117,122.41 119.68,125.09 119.68,126.93 119.35,127.26 118.38,127.26 118.02,127.62 118.02,127.94 v1(117.72,128.24)
CLK_DPLL_NSCCLKN: length 161.1
  TOP w0.079: v1(117.64,126.58) 117.72,126.58 117.92,126.78 117.92,127.02 118.14,127.23 119.83,127.23 120.05,127.01 121.66,127.01 121.8,127.15 121.8,127.26 121.75,127.31 U3.D31
  TOP w0.089: v1(205.51,50.03) 205.51,50.19 205.6,50.29 205.82,50.29 205.99,50.12 205.99,47.08 206.12,46.94 206.12,46.07 206.29,45.9 206.29,44.87 U14.C6
  IN4 w0.086: v1(205.51,50.03) 205.51,50.15 205.36,50.3 205.08,50.3 204.82,50.56 204.82,52.77 201.14,56.46 201.11,56.46 201.06,56.5 192.84,56.5 191.25,58.09 190,58.09 188.98,59.11 188.33,59.11 187.77,59.68 187.09,59.68 183.52,63.25 183.32,63.25 182.75,63.81 182.75,64.9 179.29,68.36 178.69,68.36 165.37,81.68 126.02,81.68 123.22,84.48 122.03,84.48 110.58,95.93 110.58,102.07 111.58,103.08 111.58,104.16 114.05,106.63 114.05,109.79 116.21,111.95 116.21,123.22 117.94,124.95 117.94,126.39 117.75,126.58 v1(117.64,126.58)
CLK_DPLL_NSCCLKP: length 161.1
  TOP w0.079: v1(118.3,126.58) 118.08,126.8 118.08,126.95 118.2,127.07 119.76,127.07 119.98,126.85 121.73,126.85 U3.E31
  TOP w0.089: U14.D7 206.58,44.47 206.58,44.98 206.47,45.1 206.47,45.97 206.3,46.15 206.3,47.01 206.16,47.15 206.16,50.2 205.9,50.46 205.72,50.46 v1(205.51,50.67)
  IN4 w0.086: v1(118.3,126.58) 118.1,126.39 118.1,124.88 116.38,123.16 116.38,111.88 114.22,109.72 114.22,106.56 111.75,104.1 111.75,103.01 110.74,102 110.74,96 122.09,84.65 123.29,84.65 126.09,81.85 165.44,81.85 178.76,68.53 179.36,68.53 182.92,64.97 182.92,63.88 183.39,63.41 183.58,63.41 187.16,59.84 187.84,59.84 188.4,59.27 189.05,59.27 190.07,58.26 191.32,58.26 192.91,56.67 201.13,56.67 201.18,56.62 201.2,56.62 204.98,52.84 204.98,50.63 205.15,50.46 205.3,50.46 v1(205.51,50.67)
CLK_PCI_EC: length 213.5
  TOP w0.14: v1(75.76,31.93) 75.76,31.36 73.64,29.24 70.82,29.24 70.2,28.62 U18.13
  IN3 w0.089: v1(75.76,31.93) 75.76,31.89 76.26,31.39 77.23,31.39 78.28,30.34 79.54,30.34 80.16,29.72 82.1,29.72 82.46,29.36 82.61,29.36 84.21,27.77 89.15,27.77 89.33,27.94 90.99,27.94 91.1,28.06 92.96,28.06 93.85,28.94 95.23,28.94 95.46,28.71 100.55,28.71 101.73,29.89 102.74,29.89 103.45,29.17 109.11,29.17 109.55,29.61 148.55,29.61 148.87,29.29 166.72,29.29 167.23,28.79 174.36,28.79 177.11,26.04 177.11,23.86 177.56,23.41 178.84,23.41 179.71,24.27 182.63,24.27 182.94,23.96 185.85,23.96 187.83,21.98 187.83,21.6 190.69,18.74 191.17,18.74 191.62,18.29 193.82,18.29 194.71,17.4 195.3,17.4 197.16,15.54 199.41,15.54 200,14.95 200.96,14.95 201.55,15.54 203.77,15.54 204.34,16.11 218.19,16.11 218.31,16.24 220.66,16.24 221.37,16.95 226.09,16.95 v1(226.84,17.69)
  BOTTOM w0.14: R939.2 63.32,28.13 63.32,29 62.8,29.52 62.8,30.44 64.85,32.49 64.85,34.02 63.39,35.48 63.39,36.38 64.41,37.4 65.05,37.4 65.39,37.73 65.39,38.51 66.4,39.52 67.17,39.52 67.73,38.96 70.24,38.96 71.56,40.28 73.15,40.28 73.42,40.56 75.07,40.56 76.47,39.16 78,39.16 78.39,39.55 78.88,39.55 79.13,39.3 79.13,37.99 79.53,37.59 79.53,35.96 76.34,32.77 76.34,32.36 75.91,31.93 v1(75.76,31.93) ; R1035.2 C918.1 EC11.2 227.56,17.69 v1(226.84,17.69)
CLK_PCI_EC_R: length 13.1
  TOP w0.14: U14.BB36 221.28,25.96 v1(221.52,25.96)
  BOTTOM w0.14: v1(221.52,25.96) 221.97,26.42 222.26,26.42 222.62,26.77 223.59,26.77 224.29,26.07 224.29,25.64 224.09,25.45 224.09,24.43 224.43,24.1 225.05,24.1 225.15,24.19 225.51,24.19 226.84,22.86 226.84,21.71 v1(227.75,20.8) 228.22,20.8 228.58,20.44 R1035.1
CLK_PCI_LPC: length 205.3
  TOP w0.14: R178.2 47.55,45.68 47.55,42.85 47.7,42.69 47.7,39.36 v1(48.07,38.99)
  IN3 w0.089: v1(48.07,38.99) 48.01,38.99 47.91,38.89 47.91,38.02 48.47,37.46 49.17,37.46 50.12,36.52 52.34,36.52 52.86,36 53.85,36 54.01,36.16 56.85,36.16 58.78,34.23 62.86,34.23 63.15,34.52 64.74,34.52 65.09,34.17 67.43,34.17 67.83,33.77 71.02,33.77 71.51,33.28 74.22,33.28 74.41,33.08 75.27,33.08 76.58,31.78 77.4,31.78 78.45,30.73 79.7,30.73 80.32,30.11 82.42,30.11 82.88,29.65 84.12,29.65 85.61,28.16 88.94,28.16 89.12,28.34 90.62,28.34 90.73,28.45 92.8,28.45 93.68,29.33 95.39,29.33 95.62,29.1 100.39,29.1 101.25,29.97 101.25,30.53 101.6,30.88 109.97,30.88 110.85,30 148.71,30 149.03,29.69 166.88,29.69 167.39,29.18 175.34,29.18 177,27.52 178.18,27.52 179.57,26.13 179.57,25.52 179.85,25.24 185.13,25.24 188.23,22.14 188.23,21.76 190.85,19.14 191.34,19.14 191.79,18.69 193.99,18.69 194.88,17.8 195.46,17.8 197.32,15.94 203.59,15.94 204.16,16.51 218.02,16.51 218.17,16.65 220.52,16.65 221.2,17.34 225.79,17.34 225.88,17.43 v1(225.88,17.69)
  BOTTOM w0.14: v1(225.88,17.69) 225.44,17.26 C922.1 225.19,17.99 225.49,18.29 225.49,18.94 R1049.2
CLK_PCI_LPC_C: length 2.2
  TOP w0.14: v1(51.12,47.5) 51.09,47.54 R178.1
  BOTTOM w0.14: CN16.60 v1(51.12,47.5)
CLK_PCI_LPC_R: length 10.5
  TOP w0.14: U14.BB34 219.95,25.7 v1(220.21,25.96)
  BOTTOM w0.102: v1(220.21,25.96) 220.21,25.96 220.21,25.95 220.64,25.95 221.11,25.48 221.11,25.23 221.69,24.65 222.1,24.65 222.62,24.12 223.49,24.12 223.94,23.66 224.45,23.66 225.51,22.61
  BOTTOM w0.14: 225.51,22.61 225.95,22.17 225.95,20.88 225.81,20.74 v1(225.81,20.74) 225.7,20.63 R1049.1
CLK_PCIE_LANN: length 236
  TOP w0.102: U14.AE6 206.55,34.44 v1(206.55,34.45)
  IN4 w0.086: v1(35.1,33.07) 35.44,33.07 35.67,33.3 36.25,33.3 36.62,32.93 36.62,32.26 37.99,30.89 41.82,30.89 43.01,32.08 46.12,32.08 46.5,31.71 48.71,31.71 50.19,33.19 52.78,33.19 54.26,34.67 54.46,34.67 55.35,35.56 56.37,35.56 56.96,34.97 56.96,33.49 56.35,32.88 56.35,28.46 56.74,28.07 56.74,22.36 57.41,21.69 59.15,21.69 60.07,20.76 61.07,20.76 61.49,20.35 61.49,20.05 62.2,19.33 62.75,19.33 63.2,18.88 64.17,18.88 64.18,18.88 64.57,18.88 64.76,18.69 66.13,18.69 68.86,21.42 73.56,21.42 74.07,21.92 75.58,21.92 76.9,23.24 77.46,23.24 78.67,24.45 78.67,24.93 80.14,26.4 80.14,26.47 81.46,27.79 83.9,27.79 85.92,29.81 88.64,29.81 89.08,30.25 89.08,30.77 89.59,31.27 91.2,31.27 91.56,30.91 99.11,30.91 99.4,31.2 100.09,31.2 101.25,32.36 174.85,32.36 181.95,39.46 187.14,39.46 187.44,39.77 188.82,39.77 189.37,39.22 194.47,39.22 197.94,35.75 199.46,35.75 200.51,34.7 203.66,34.7 204.5,33.86 206.56,33.86 206.91,34.2 206.91,34.4 206.78,34.53 206.62,34.53 v1(206.55,34.45)
  BOTTOM w0.14: v1(35.1,33.07) 35.18,33 35.18,32.73 34.67,32.22 33.58,32.22 32.85,32.95 26.19,32.95 25.39,33.75 24.55,33.75 22.39,35.91 21.33,35.91 18.45,38.79 17.9,38.79 16.94,39.75 15.05,39.75 12.96,37.65 12.96,34.24 12.6,33.88 12.4,33.88 12.29,34 CN17.41
CLK_PCIE_LANP: length 236
  TOP w0.102: U14.AE7 206.79,33.93 v1(207.34,34.48)
  IN4 w0.086: v1(207.34,34.48) 207.08,34.22 207.08,34.14 206.63,33.7 204.43,33.7 203.59,34.54 200.45,34.54 199.39,35.59 197.87,35.59 194.4,39.05 189.3,39.05 188.75,39.6 187.51,39.6 187.2,39.3 182.02,39.3 174.92,32.2 101.32,32.2 100.16,31.03 99.47,31.03 99.18,30.75 91.49,30.75 91.13,31.11 89.66,31.11 89.25,30.7 89.25,30.18 88.71,29.65 85.99,29.65 83.97,27.63 81.53,27.63 80.31,26.4 80.31,26.33 78.83,24.86 78.83,24.38 77.53,23.07 76.97,23.07 75.65,21.76 74.14,21.76 73.63,21.25 68.93,21.25 66.2,18.52 64.69,18.52 64.5,18.71 64.11,18.71 64.1,18.72 63.13,18.72 62.68,19.17 62.13,19.17 61.32,19.98 61.32,20.28 61,20.6 60.01,20.6 59.08,21.52 57.34,21.52 56.57,22.29 56.57,28 56.19,28.39 56.19,32.95 56.8,33.56 56.8,34.9 56.31,35.4 55.42,35.4 54.53,34.51 54.33,34.51 52.85,33.03 50.26,33.03 48.78,31.55 46.43,31.55 46.05,31.92 43.08,31.92 41.89,30.73 37.92,30.73 36.46,32.19 36.46,32.87 36.19,33.14 35.74,33.14 35.65,33.05 v1(35.65,32.67)
  BOTTOM w0.14: CN17.40 12.29,33.5 12.4,33.62 12.71,33.62 13.23,34.13 13.23,37.54 15.16,39.48 16.83,39.48 17.79,38.52 18.34,38.52 21.22,35.64 22.28,35.64 24.44,33.48 25.28,33.48 26.08,32.68 32.74,32.68 33.47,31.96 34.78,31.96 35.5,32.67 v1(35.65,32.67)
CLK_PCIE_SSD1N: length 30.1
  TOP w0.14: v1(206.4,31.54) 206.38,31.56 206.35,31.56 U14.AJ6
  IN4 w0.086: v1(183.82,38.66) 184.07,38.41 184.07,38.27 184.28,38.06 187.93,38.06 188.29,38.42 190.37,38.42 191.34,37.44 194.82,37.44 197.73,34.54 198.73,34.54 200,33.27 203.52,33.27 204.62,32.16 206.32,32.16 206.59,31.9 206.59,31.72 v1(206.4,31.54)
  BOTTOM w0.14: R834.1 185.81,40.18 185.24,40.18 184.22,39.16 184.22,39.05 v1(183.82,38.66)
CLK_PCIE_SSD1N_R: length 2.9
  BOTTOM w0.14: CN15.53 188.77,40 188.64,39.87 188.05,39.87 187.75,40.18 187.35,40.18 R834.2
CLK_PCIE_SSD1P: length 30.1
  TOP w0.14: v1(207.08,31.56) 206.74,31.89 U14.AJ7
  IN4 w0.086: v1(184.67,38.66) 184.33,38.66 184.23,38.56 184.23,38.34 184.34,38.23 187.87,38.23 188.22,38.58 190.44,38.58 191.41,37.61 194.89,37.61 197.8,34.7 198.79,34.7 200.06,33.43 203.59,33.43 204.69,32.33 206.39,32.33 206.75,31.97 206.75,31.77 206.96,31.56 v1(207.08,31.56)
  BOTTOM w0.14: v1(184.67,38.66) 184.48,38.85 184.48,39.05 185.35,39.91 185.82,39.91 R837.1
CLK_PCIE_SSD1P_R: length 2.9
  BOTTOM w0.14: R837.2 187.34,39.91 187.64,39.91 187.94,39.6 188.6,39.6 188.7,39.5 CN15.55
CLK_PCIE_SSD2N: length 44.5
  TOP w0.102: U14.AB2 204.21,35.56 204.13,35.47 204.07,35.47 203.69,35.09 203.05,35.09 202.85,35.3 202.85,35.66 v1(203.07,35.88)
  IN1 w0.086: v1(181.53,18.18) 181.72,18.37 181.72,18.85 181.53,19.04 180.86,19.04 179.49,20.42 179.49,25.82 180.16,26.5 185.43,26.5 186.15,27.21 186.72,27.21 187.06,27.56 187.06,30.33 188.48,31.75 188.48,32.06 189.43,33.01 193.36,33.01 193.95,32.43 195.77,32.43 196.74,33.4 196.74,34.12 197.58,34.96 198.47,34.96 200.03,36.52 202.48,36.52 202.72,36.28 202.72,36.23 v1(203.07,35.88)
  BOTTOM w0.14: R1075.1 182.5,19.03 182.1,19.03 181.71,18.63 181.71,18.36 v1(181.53,18.18)
CLK_PCIE_SSD2N_R: length 7.9
  BOTTOM w0.14: R1075.2 183.62,19.31 184.97,17.96 185.43,17.96 185.78,17.61 186.13,17.61 188.44,15.3 188.44,15.2 188.68,14.95 CN18.53
CLK_PCIE_SSD2P: length 44.4
  TOP w0.102: U14.AB3 204.63,35.69 204.21,35.27 204.16,35.27 203.78,34.89 202.96,34.89 202.64,35.21 202.64,35.69 v1(202.42,35.92)
  IN1 w0.086: v1(182.19,18.18) 181.88,18.49 181.88,18.92 181.59,19.2 180.93,19.2 179.65,20.48 179.65,25.75 180.23,26.33 185.5,26.33 186.21,27.04 186.78,27.04 187.23,27.49 187.23,30.26 188.64,31.68 188.64,31.99 189.5,32.85 193.3,32.85 193.88,32.26 195.84,32.26 196.91,33.33 196.91,34.05 197.65,34.8 198.54,34.8 200.1,36.35 202.41,36.35 202.56,36.21 202.56,36.06 v1(202.42,35.92)
  BOTTOM w0.14: v1(182.19,18.18) 181.97,18.39 181.97,18.52 182.21,18.76 182.7,18.76 182.84,18.62 R1086.1
CLK_PCIE_SSD2P_R: length 7.8
  BOTTOM w0.14: R1086.2 183.83,18.62 183.93,18.62 184.86,17.69 185.32,17.69 185.67,17.34 186.02,17.34 188.17,15.19 188.17,15.09 188.81,14.45 CN18.55
CLK_PCIE_TBTN: length 68.7
  TOP w0.102: U14.W4 205.17,36.64 204.62,36.64 204.59,36.66 204.01,36.66 203.71,36.96 203.19,36.96 v1(202.99,36.76)
  TOP w0.127: U7.T19 260.78,47.54 v2(260.74,47.54)
  IN3 w0.089: v1(202.99,36.76) 203.17,36.94 203.36,36.94 203.71,37.29 203.71,37.86 205.88,40.02 206.59,40.02 206.98,40.41 206.98,40.5 207.42,40.95 207.98,40.95 208.57,41.53 209.86,41.53 211.1,40.29 216.7,40.29 216.91,40.09 224.94,40.09 226.01,41.15 226.46,41.15 226.81,40.8 228.24,40.8 228.85,41.41 237.1,41.41 237.85,40.66 239.11,40.66 240.24,41.79 242.7,41.79 244.28,43.37 244.28,43.98 244.9,44.61 245.58,44.61 245.79,44.4 246.33,44.4 247.2,45.28 255.09,45.28 255.84,46.03 258.25,46.03 258.47,46.25 260.13,46.25 260.52,46.64 260.52,47.3 260.74,47.52 v2(260.74,47.54)
CLK_PCIE_TBTP: length 68.7
  TOP w0.102: U14.W3 204.95,36.87 205.02,36.93 205.02,37.02 204.91,37.13 204.64,37.13 204.38,36.87 204.09,36.87 203.79,37.17 203.09,37.17 202.99,37.27 v1(202.99,37.42)
  TOP w0.127: U7.V19 260.44,47.85 v2(260.11,47.52)
  IN3 w0.089: v1(202.99,37.42) 202.99,37.28 203.14,37.13 203.28,37.13 203.52,37.37 203.52,37.93 205.8,40.21 206.51,40.21 206.79,40.49 206.79,40.58 207.34,41.14 207.9,41.14 208.49,41.72 209.94,41.72 211.18,40.49 216.78,40.49 216.99,40.28 224.86,40.28 225.93,41.34 226.54,41.34 226.89,40.99 228.16,40.99 228.77,41.6 237.18,41.6 237.93,40.85 239.03,40.85 240.16,41.98 242.62,41.98 244.09,43.45 244.09,44.06 244.82,44.8 245.66,44.8 245.87,44.59 246.25,44.59 247.12,45.47 255.01,45.47 255.76,46.22 258.17,46.22 258.39,46.44 260.05,46.44 260.33,46.72 260.33,47.3 v2(260.11,47.52)
CLK_PCIE_WLANN: length 189.4
  TOP w0.102: U14.AC2 204.24,34.97 204.24,34.78 204.32,34.7 204.43,34.7 204.56,34.82 204.56,34.87 204.59,34.91 204.7,34.91 205.08,34.53 v1(205.08,34.35)
  IN4 w0.086: v1(58.95,44.72) 58.69,44.47 58.44,44.47 58.18,44.21 58.18,40.04 58.45,39.78 58.45,37.83 57.43,36.81 57.43,33.3 57.01,32.88 57.01,29.79 57.94,28.85 57.94,23.35 58.43,22.86 58.76,22.86 60.1,21.52 61.08,21.52 61.41,21.2 61.84,21.2 62.81,20.23 62.81,19.94 63.4,19.35 66.14,19.35 68.68,21.89 72.95,21.89 73.25,22.19 73.25,22.72 73.92,23.4 74.93,23.4 75.16,23.17 75.98,23.17 76.96,24.15 77.21,24.15 79.07,26.01 79.07,26.52 79.65,27.09 80.08,27.09 81.29,28.3 83.39,28.3 85.81,30.72 87.55,30.72 88.58,31.74 91.61,31.74 91.96,31.39 98.75,31.39 99.03,31.67 99.84,31.67 101,32.83 174.64,32.83 181.8,40 182.88,40 183.54,40.66 184.19,40.66 184.85,40 186.3,40 187.43,41.13 188.67,41.13 190.11,39.69 193.62,39.69 193.95,40.02 194.37,40.02 198.08,36.31 200.09,36.31 201.2,35.21 203.87,35.21 204.27,34.8 205.18,34.8 205.33,34.66 205.33,34.48 205.19,34.35 v1(205.08,34.35)
  BOTTOM w0.14: CN16.49 58.28,44.75 58.4,44.64 58.86,44.64 v1(58.95,44.72)
CLK_PCIE_WLANP: length 189.4
  TOP w0.102: U14.AC3 204.84,35.05 205.12,34.77 205.25,34.77 205.51,34.5 205.8,34.5 v1(205.88,34.42)
  IN4 w0.086: v1(205.88,34.42) 205.82,34.36 205.58,34.36 205.49,34.44 205.49,34.73 205.25,34.97 204.34,34.97 203.94,35.37 201.27,35.37 200.16,36.48 198.15,36.48 194.44,40.19 193.88,40.19 193.55,39.86 190.18,39.86 188.74,41.29 187.36,41.29 186.23,40.16 184.92,40.16 184.26,40.82 183.47,40.82 182.81,40.16 181.74,40.16 174.57,32.99 100.94,32.99 99.78,31.83 99.06,31.83 98.96,31.83 98.68,31.55 92.03,31.55 91.68,31.91 88.51,31.91 87.49,30.88 85.74,30.88 83.33,28.46 81.22,28.46 80.01,27.26 79.58,27.26 78.91,26.58 78.91,26.08 77.14,24.31 76.89,24.31 75.91,23.33 75.23,23.33 75,23.56 73.85,23.56 73.08,22.79 73.08,22.25 72.88,22.05 68.61,22.05 66.07,19.51 63.46,19.51 62.97,20.01 62.97,20.3 61.91,21.36 61.47,21.36 61.15,21.68 60.17,21.68 58.82,23.03 58.49,23.03 58.11,23.42 58.11,28.92 57.17,29.85 57.17,32.81 57.6,33.23 57.6,36.74 58.62,37.76 58.62,39.84 58.35,40.11 58.35,44.14 58.51,44.3 58.71,44.3 v1(58.97,44.03)
  BOTTOM w0.14: v1(58.97,44.03) 58.64,44.37 58.39,44.37 58.28,44.25 CN16.47
CLK_VGA_N: length 203.1
  TOP w0.105: 54.33,87.83 54.33,87.84 54.32,87.86 54.32,87.95 54.3,87.96 54.3,88.36 53.92,88.74 53.92,91.79 54.84,92.7 54.84,92.93 55.05,93.15 UG1.BM27
  TOP w0.14: v1(177.95,79.59) 177.88,79.59 177.74,79.73 177.74,80.51 172.34,85.91 168.56,85.91 167.07,87.39 105.85,87.39 105.76,87.48 99.3,87.48 99.01,87.76 63.11,87.76 62.3,86.95 54.82,86.95 54.33,87.43 54.33,87.83 ; U14.AH9 207.61,32.43 207.61,32.63 v1(207.19,33.05)
  IN2 w0.089: v1(177.95,79.59) 177.79,79.59 177.7,79.5 177.7,67.73 179.57,65.86 181.08,65.86 182.28,64.66 182.28,63.78 184.84,61.21 184.84,60.66 187.64,57.87 190.47,57.87 191.01,57.33 191.33,57.33 191.87,56.79 191.87,54.47 190.95,53.56 190.64,53.56 190.5,53.42 190.5,51.88 193.8,48.58 193.8,48.02 194.74,47.08 194.74,44.57 194.1,43.93 194.1,42.64 194.51,42.23 195.04,42.23 197.04,40.23 197.04,39.55 199.89,36.69 199.89,36.16 201.15,34.9 202.56,34.9 203.42,34.04 203.42,33.6 204.49,32.52 207.36,32.52 207.47,32.63 207.47,32.91 207.33,33.05 v1(207.19,33.05)
CLK_VGA_P: length 203.2
  TOP w0.105: 54.09,87.85 54.09,88.27 53.71,88.65 53.71,91.88 54.63,92.79 54.63,92.97 UG1.BM26
  TOP w0.14: v1(177.29,79.59) 177.48,79.79 177.48,80.39 172.23,85.64 168.44,85.64 166.96,87.13 105.74,87.13 105.65,87.21 99.19,87.21 98.9,87.5 63.22,87.5 62.41,86.68 54.7,86.68 54.07,87.32 54.07,87.83 54.09,87.85 ; v1(207.84,33.06) 207.84,32.86 U14.AH10
  IN2 w0.089: v1(207.84,33.06) 207.66,32.88 207.66,32.55 207.44,32.33 204.41,32.33 203.23,33.52 203.23,33.96 202.48,34.71 201.07,34.71 199.7,36.08 199.7,36.62 196.85,39.47 196.85,40.15 194.96,42.04 194.43,42.04 193.91,42.56 193.91,44.01 194.54,44.65 194.54,47 193.61,47.94 193.61,48.5 190.31,51.8 190.31,53.5 190.56,53.75 190.87,53.75 191.68,54.55 191.68,56.71 191.25,57.14 190.93,57.14 190.39,57.67 187.56,57.67 184.65,60.58 184.65,61.13 184.46,61.32 184.02,61.77 182.09,63.7 182.09,64.58 181,65.67 179.49,65.67 177.51,67.65 177.51,79.37 v1(177.29,79.59)
CLKIN_XTAL: length 179.4
  TOP w0.102: U14.R6 206.1,38.16 v1(205.91,37.96)
  TOP w0.14: R175.2 49.14,48.56 v1(48.61,48.02)
  IN2 w0.089: v1(187.77,36.25) 187.33,36.25 185.74,37.83 179.95,37.83 176.16,34.05 166.37,34.05 165.93,33.6 148.73,33.6 148.46,33.33 112.4,33.33 111.65,34.07 105.45,34.07 105.22,34.31 98.77,34.31 98.16,33.7 94.14,33.7 93.7,33.26 88.65,33.26 88.27,33.63 85.9,33.63 85.73,33.46 83.07,33.46 81.58,31.97 76.87,31.97 75.62,30.72 74.05,30.72 73.72,30.39 70.29,30.39 68.62,32.06 66.76,32.06 65.62,33.21 62.53,33.21 61.8,32.48 60.18,32.48 59.7,32.97 59.7,33.22 56.1,36.82 55.13,36.82 53.1,38.85 52.8,38.85 52.13,39.52 52.13,40.16 52.54,40.57 52.54,41.44 52.1,41.88 52.1,42.99 53.25,44.14 53.25,45.42 51.9,46.76 49.87,46.76 v1(48.61,48.02)
  BOTTOM w0.14: v1(187.77,36.25) 188.55,37.02 190.47,37.02 190.8,37.35 194.96,37.35 195.71,38.11 198.12,38.11 199.3,39.28 200.43,39.28 201.05,38.67 202.95,38.67 203.84,37.77 R858.1 204.39,37.96 v1(205.91,37.96)
CLKOUT_SRC_N15: length 10.1
  TOP w0.14: U14.V2 204.08,37.23 203.43,37.88 203.32,37.88 203.08,38.12 201.14,38.12 199.9,39.36 199.9,39.9 199.33,40.47 198.95,40.47 198.49,40.93 v1(198.46,40.93) 198.1,40.93 197.63,41.39 197.63,42.1 R207.2
CLKOUT_SRC_P15: length 12.6
  TOP w0.14: R197.1 197.19,43.57 R203.2 197.88,42.88 197.88,41.57 198.05,41.41 198.75,41.41 198.89,41.27 198.89,40.87 199.05,40.71 199.43,40.71 200.14,40 200.14,39.46 201.24,38.36 203.18,38.36 203.42,38.12 203.56,38.12 204.1,37.58 204.65,37.58 U14.V3
CLKRUN#: length 208.7
  TOP w0.102: v1(219.14,27.65) 218.98,27.82 U14.AV32
  TOP w0.14: v1(83.91,32.22) U18.93
  IN2 w0.089: v1(219.14,27.65) 219.95,27.65 220.32,27.27 220.32,26.72 220.6,26.44 220.6,26.05 222.06,24.59 222.72,24.59 222.92,24.4 223.29,24.4 223.98,25.09 223.98,25.72 224.48,26.21 225.97,26.21 226.83,25.35 226.83,24.25 225.84,23.26 221.4,23.26 221.18,23.04 221.18,20.88 219.74,19.45 217.1,19.45 214.32,16.67 211.14,16.67 210.21,15.74 210.21,14.38 210.51,14.08 210.84,14.08 211.21,14.45 214.21,14.45 v1(214.76,13.89)
  IN3 w0.089: v1(219.14,27.65) 219.14,28.54 219.49,28.89 221.67,28.89 222.06,28.5 222.06,27.79 222.73,27.13 222.73,26.66 222.35,26.28 222.35,24.97 221.66,24.27 217.4,24.27 216.8,23.67 216.39,23.27 214.53,23.27 214.32,23.48 213.28,23.48 212.88,23.08 211.75,23.08 211.41,23.42 210.83,23.42 210.72,23.31 209.07,23.31 207.13,21.36 204.44,21.36 203.13,22.67 197.94,22.67 197.55,23.05 197.55,23.55 197.03,24.07 197.03,28.53 196.31,29.25 195.83,29.25 194.53,30.55 194.53,31.09 192.75,32.87 191.55,32.87 190.93,33.49 190.93,33.93 187.84,37.02 178.33,37.02 177.04,35.72 98.9,35.72 98.75,35.58 96.65,35.58 96.08,36.14 94.57,36.14 94.1,35.67 93.42,35.67 92.1,37 90.28,37 89.84,36.55 88.74,36.55 87.96,37.33 85.47,37.33 85.07,37.74 84.37,37.74 v1(84.18,37.55)
  BOTTOM w0.14: v1(83.91,32.22) 83.68,32.45 83.68,36.97 84.11,37.4 84.11,37.48 v1(84.18,37.55) ; v1(214.76,13.89) 214.54,14.12 R1121.1
CLR_CMOS: length 164
  TOP w0.14: v1(206.34,12.74) 206.34,13.02 205.73,13.62 R586.2 205.26,13.99 Q49.2 204.31,13.99 203.68,14.63 203.68,14.91 203.56,15.03 202.72,15.03 Q41.2 ; U18.19 70.16,26.22 70.35,26.03 70.35,25.44 70.84,24.95 73.86,24.95 v1(74.86,25.95)
  IN3 w0.089: v1(206.34,12.74) 205.76,12.16 199.5,12.16 198.06,13.61 196.36,13.61 195.17,14.8 191.49,14.8 188.06,18.23 187.17,18.23 185.54,19.86 184.24,19.86 183.76,20.34 178.01,20.34 177.12,19.45 176.34,19.45 175.71,20.08 175.71,22.15 174.67,23.19 174.67,23.72 171.53,26.86 166.87,26.86 166.08,26.07 164.88,26.07 164.47,26.48 153.12,26.48 152.89,26.24 151.84,26.24 151.38,26.7 149.18,26.7 147.75,25.28 143.69,25.28 143.34,25.63 141.87,25.63 141.54,25.3 133.17,25.3 130.51,22.64 125.42,22.64 121.53,26.52 120.28,26.52 119.56,27.24 102.37,27.24 99.68,24.55 99.68,23.43 99.45,23.19 98.2,23.19 97.56,23.84 96.45,23.84 96.44,23.84 96.11,23.84 95.22,22.95 95.22,22.62 94.42,21.81 89.33,21.81 88.75,22.39 88.09,22.39 87.58,22.9 85.45,22.9 83.95,24.4 83.3,24.4 82.84,24.86 82.11,24.86 81.81,24.55 81.47,24.55 81.06,24.96 80.46,24.96 79.98,24.48 77.43,24.48 76.55,25.37 76.55,25.59 75.73,26.41 75.32,26.41 v1(74.86,25.95)
CNV_BRI_DT: length 168.3
  TOP w0.14: v1(193.28,30.66) 193.82,31.2 195.17,31.2 195.61,31.64 R355.2 195.79,31.92 196.83,30.88 196.93,30.88 197.17,30.64 197.17,30.34 198,29.51 R372.1 ; v1(51.73,40.91) 51.73,40.71 51.42,40.39 50.43,40.39 R225.1
  IN2 w0.089: v1(51.73,40.91) 51.73,40.86 51.3,40.43 51.3,39.2 52.53,37.97 53.01,37.97 54.95,36.03 55.84,36.03 57.8,34.08 57.8,33.5 59.21,32.09 62.06,32.09 62.36,32.39 63.33,32.39 63.8,31.91 65.47,31.91 66.02,31.36 68.24,31.36 69.96,29.65 74.02,29.65 74.37,29.99 75.9,29.99 77.07,31.16 81.89,31.16 83.39,32.66 84.55,32.66 85.04,32.16 86.77,32.16 87.08,31.85 89,31.85 89.17,32.03 90.89,32.03 90.99,31.94 95.29,31.94 96.28,32.93 98.47,32.93 99,33.46 104.52,33.46 104.8,33.19 111.23,33.19 111.91,32.51 148.71,32.51 149.04,32.85 166.2,32.85 166.66,33.31 176.67,33.31 180.46,37.1 185.47,37.1 187.33,35.23 188.79,35.23 190.04,33.98 190.04,33.32 190.69,32.67 190.69,31.71 191.63,30.78 192.27,30.78 192.45,30.95 192.99,30.95 v1(193.28,30.66)
  BOTTOM w0.14: CN16.36 51.14,41.5 v1(51.73,40.91)
CNV_BRI_DT_R: length 6.4
  TOP w0.102: R372.2 200.41,28.76 200.41,28.68 200.91,28.19 203.43,28.19 203.64,27.97 205.16,27.97 U14.AV4
CNV_BRI_RSP: length 172.4
  TOP w0.102: 201.87,26.89 202.02,26.75 203.19,26.75 203.28,26.84 204.09,26.84 U14.AY2
  TOP w0.14: R263.2 50.07,38.87 v1(50.24,39.04) ; 201.87,26.89 201.62,27.14 197.78,27.14 197.7,27.22 R393.2 196.9,26.71 196.18,26.71 196.08,26.61 v1(195.92,26.61)
  IN2 w0.089: v1(50.24,39.04) 50.28,39 50.28,37.37 50.99,36.65 52.37,36.65 54,35.03 54.89,35.03 55.96,33.96 56.3,33.96 56.61,33.64 56.61,33 58.19,31.42 58.19,30.72 58.59,30.33 59.96,30.33 60.32,30.69 61.62,30.69 62.2,30.1 62.92,30.1 63.71,30.89 65.12,30.89 65.63,30.38 66.23,30.38 66.71,29.89 66.71,29.41 67.74,28.38 70.29,28.38 70.61,28.7 76.75,28.7 78.27,30.21 82.44,30.21 83.4,31.17 85.38,31.17 85.73,30.82 89.5,30.82 89.74,31.06 90.51,31.06 90.57,31 95.75,31 96.19,31.43 98.32,31.43 99.27,32.37 103.69,32.37 103.9,32.16 110.44,32.16 111.47,31.13 148.85,31.13 149.61,31.89 166.59,31.89 167.05,32.35 177.33,32.35 181.06,36.07 185.05,36.07 187.93,33.19 188.27,33.19 189.44,32.02 189.44,31.54 190.33,30.65 190.33,29.72 192.02,28.03 193.47,28.03 193.93,27.57 195.58,27.57 195.88,27.27 195.88,26.65 v1(195.92,26.61)
CNV_BRI_RSP_R: length 2.1
  TOP w0.14: v1(48.66,37.86) 48.88,37.86 R263.1
  BOTTOM w0.14: CN16.22 49.05,38 48.91,37.86 v1(48.66,37.86)
CNV_MFUART2_RXD: length 184.2
  TOP w0.102: R384.2 198.21,28.24 197.94,28.51
  TOP w0.14: v1(196.69,29.48) 196.97,29.48 197.94,28.51
  IN2 w0.089: v1(196.69,29.48) 196.54,29.33 196.54,26.3 196.16,25.92 195.05,25.92 194.84,25.71 193.51,25.71 192.6,26.63 191.2,26.63 189.79,28.04 187.99,28.04 187.12,28.91 187.12,29.93 188.14,30.95 188.14,31.65 187.74,32.05 187.44,32.05 184.61,34.88 181.46,34.88 177.8,31.21 167.57,31.21 167.11,30.74 165.72,30.74 165.24,30.27 151.72,30.27 151.42,29.97 110.77,29.97 109.75,28.95 105.15,28.95 102.89,31.2 99.71,31.2 98.81,30.3 97.26,30.3 96.61,29.65 95.98,29.65 95.77,29.87 92.33,29.87 90.31,27.84 87.94,27.84 87.67,28.11 80.66,28.11 79.93,27.38 74.54,27.38 73.96,26.8 73.96,26.04 72.51,24.59 67.43,24.59 66.14,25.88 66.14,26.99 65,28.13 64.57,28.13 64.31,28.38 62.38,28.38 62.16,28.16 61.43,28.16 61.19,28.4 59.45,28.4 58.96,28.9 57.5,28.9 55.62,30.77 55.62,31.78 51.91,35.5 50.49,35.5 49.15,36.84 49.15,38.21 48.8,38.55 48.8,39.1 47.83,40.08 47.83,41.39 48.76,42.33 48.76,43.63 v1(48.23,44.16)
  BOTTOM w0.14: v1(48.23,44.16) 48.58,44.5 CN16.48
CNV_MFUART2_TXD: length 177.9
  TOP w0.14: v1(195.22,25.52) 195.67,25.98 196.38,25.98 R404.2
  IN2 w0.089: v1(195.22,25.52) 193.43,25.52 192.52,26.44 191.13,26.44 189.71,27.85 187.91,27.85 186.93,28.83 186.93,30.01 187.95,31.03 187.95,31.57 187.66,31.86 187.36,31.86 184.53,34.69 181.54,34.69 177.87,31.02 167.65,31.02 167.19,30.55 165.79,30.55 165.32,30.08 151.8,30.08 151.5,29.77 110.85,29.77 109.83,28.76 105.07,28.76 102.81,31.01 99.79,31.01 98.89,30.11 97.34,30.11 96.69,29.46 95.9,29.46 95.69,29.67 93.44,29.67 91.42,27.65 87.86,27.65 87.59,27.92 80.74,27.92 80.01,27.19 74.62,27.19 74.15,26.72 74.15,25.96 72.59,24.4 67.35,24.4 65.95,25.81 65.95,26.91 64.92,27.94 64.49,27.94 64.23,28.19 62.46,28.19 62.24,27.97 61.35,27.97 61.11,28.21 59.38,28.21 58.88,28.7 57.42,28.7 55.43,30.69 55.43,31.7 51.83,35.31 50.41,35.31 48.11,37.6 48.11,38.28 48.55,38.71 48.55,39.09 47.64,40 47.64,41.72 48.2,42.28 v1(48.2,42.77)
  BOTTOM w0.14: CN16.46 48.98,44 48.69,43.7 48.69,43.25 v1(48.2,42.77)
CNV_PA_BLANKING: length 181.5
  IN2 w0.089: v1(51.09,43.68) 50.39,43.68 48.02,41.31 48.02,40.16 49.06,39.12 49.06,38.57 49.34,38.29 49.34,36.92 50.56,35.69 51.99,35.69 55.82,31.86 55.82,30.85 57.58,29.09 59.04,29.09 59.53,28.59 61.27,28.59 61.51,28.35 62.08,28.35 62.3,28.57 64.39,28.57 64.64,28.32 65.08,28.32 67.08,26.32 67.55,26.32 69.08,24.78 72.43,24.78 73.77,26.12 73.77,26.88 74.46,27.57 79.85,27.57 80.58,28.3 87.75,28.3 88.02,28.03 90.23,28.03 92.25,30.06 95.85,30.06 96.06,29.84 96.53,29.84 97.18,30.49 98.73,30.49 99.63,31.39 102.97,31.39 103.48,30.88 109.87,30.88 110.59,30.16 151.34,30.16 151.64,30.46 165.16,30.46 165.64,30.94 167.03,30.94 167.49,31.4 177.72,31.4 181.39,35.07 184.69,35.07 187.52,32.24 187.82,32.24 188.33,31.72 188.33,31.17 189.09,30.41 189.09,29.14 191.41,26.82 192.68,26.82 193.59,25.9 194.76,25.9 194.97,26.11 196.08,26.11 196.35,26.38 196.35,28.5 v1(196.11,28.74)
  BOTTOM w0.14: v1(196.11,28.74) 196.34,28.97 197.28,28.97 198.37,27.88 198.37,27.31 R946.2 ; CN16.44 50.91,43.5 v1(51.09,43.68)
CNV_RCOMP: length 1.7
  TOP w0.203: v1(203.13,25.88) 203.29,25.88 U14.BA1
  BOTTOM w0.254: R961.1 202.64,25.24 203.13,25.72 v1(203.13,25.88)
CNV_RF_RESET#: length 171.4
  TOP w0.14: v1(187.55,31.4) 187.36,31.22 187.36,29.62 187.22,29.48 187.22,27.96 188.24,26.94 189.15,26.94 189.57,26.52 189.57,20.09 190.32,19.34 R473.1 191.77,18.09 Q38.6
  IN2 w0.089: v5(51.03,34.93) 51.03,34.56 51.62,33.97 52.71,33.97 55.24,31.44 55.24,30.61 57.34,28.51 58.8,28.51 60.15,27.16 60.15,26.78 60.37,26.57 62.07,26.57 63.51,28 64.15,28 64.41,27.75 64.84,27.75 65.75,26.83 65.75,25.73 68.07,23.41 72.32,23.41 73.11,24.2 73.11,24.65 74.34,25.89 74.34,26.06 74.64,26.36 75.19,26.36 75.83,26.99 80.09,26.99 80.82,27.73 87.52,27.73 87.78,27.46 91.5,27.46 93.52,29.48 95.61,29.48 95.83,29.27 96.77,29.27 97.41,29.92 98.97,29.92 99.87,30.82 102.73,30.82 104.99,28.57 109.91,28.57 110.93,29.58 151.58,29.58 151.88,29.89 165.4,29.89 165.87,30.36 167.27,30.36 167.73,30.83 178.74,30.83 179.88,29.69 179.88,29.31 181.51,27.67 184.87,27.67 186.73,29.53 186.73,30.58 v1(187.55,31.4)
  BOTTOM w0.14: CN16.10 50.96,35 v5(51.03,34.93)
CNV_RF_RESET#_C: length 37.2
  TOP w0.102: v1(210.35,22.67) 210.35,23.09 210.97,23.71 210.97,24.25 U14.BE16
  TOP w0.14: v1(193.92,19.7) 193.75,19.7 193.09,19.04 193.09,18.7 192.95,18.56 Q38.5
  IN1 w0.086: v1(210.35,22.67) 210.58,22.44 210.58,21.96 207.79,19.16 207.79,17.31 207.4,16.93 204.34,16.93 202.19,14.77 192.01,14.77 190.14,16.64 190.14,18.32 190.43,18.61 192.83,18.61 v1(193.92,19.7)
  BOTTOM w0.102: R988.2 210.55,22.87 v1(210.35,22.67)
CNV_RGI_DT: length 178.7
  TOP w0.14: v1(195.12,26.53) 195.12,26.36 194.68,25.92 194.68,25.37 195.04,25.01 195.54,25.01 196.71,23.84 198.58,23.84 198.92,24.17 R417.2 199.23,25.37 199.23,26.14 R403.1 ; v1(48.63,40.38) 48.63,39.79 R243.1
  IN2 w0.089: v1(195.12,26.53) 195.07,26.58 194.13,26.58 193.24,27.46 191.88,27.46 189.73,29.62 189.73,30.44 188.8,31.36 188.8,31.92 188.01,32.71 187.72,32.71 184.89,35.54 181.19,35.54 177.52,31.87 167.3,31.87 166.84,31.41 165.44,31.41 164.97,30.93 152.57,30.93 152.09,31.41 151.72,31.41 151.52,31.21 151.52,31 151.14,30.63 110.98,30.63 110.25,31.35 103.81,31.35 103.3,31.86 99.44,31.86 98.54,30.96 96.38,30.96 95.95,30.53 92.06,30.53 90.77,29.23 88.77,29.23 88.63,29.1 85.49,29.1 84.86,29.72 80.11,29.72 78.61,28.23 73.15,28.23 72.43,27.51 72.43,26.07 71.79,25.44 70.95,25.44 68.66,27.73 67.73,27.73 66.22,29.24 66.22,29.67 65.99,29.91 65.41,29.91 64.91,30.41 63.89,30.41 63.12,29.63 61.92,29.63 61.62,29.94 61,29.94 60.7,29.63 59.42,29.63 59.31,29.75 57.85,29.75 56.48,31.12 56.48,32.24 55.46,33.26 55.46,33.69 54.63,34.52 53.82,34.52 52.18,36.16 50.76,36.16 49.81,37.11 49.81,38.49 49.54,38.75 49.54,39.47 v1(48.63,40.38)
  BOTTOM w0.14: v1(48.63,40.38) 48.76,40.38 48.88,40.5 CN16.32
CNV_RGI_DT_R: length 6.6
  TOP w0.102: v1(201.42,26.71) 199.95,26.71 R403.2
  TOP w0.14: U14.BA4 205.1,26.79 v1(205.18,26.87)
  IN4 w0.086: v1(201.42,26.71) 201.47,26.66 204.97,26.66 v1(205.18,26.87)
CNV_RGI_RSP: length 172.3
  TOP w0.102: 196.77,30.37 196.82,30.37 198.39,28.81 199.98,28.81 200.81,27.98 203.34,27.98 203.59,27.74 U14.AV3
  TOP w0.14: R215.2 50.93,41.06 51.07,40.92 v1(51.07,40.89) ; v1(196.02,29.7) 196.69,30.37 R366.2 196.77,30.37
  IN2 w0.089: v1(196.02,29.7) 195.64,30.08 193.88,30.08 193.81,30.15 191.54,30.15 190.1,31.6 190.1,32.38 189.24,33.24 189.24,33.59 188.77,34.06 187.82,34.06 185.28,36.59 180.8,36.59 177.04,32.83 166.86,32.83 166.41,32.38 166.39,32.38 166.38,32.37 149.3,32.37 148.94,32.01 111.46,32.01 110.81,32.67 104.24,32.67 103.97,32.94 99.15,32.94 98.62,32.42 96.46,32.42 95.51,31.47 90.77,31.47 90.67,31.56 89.51,31.56 89.28,31.33 86.9,31.33 86.55,31.68 83.21,31.68 82.21,30.69 78,30.69 76.49,29.17 68.79,29.17 67.09,30.87 65.83,30.87 65.32,31.39 63.5,31.39 62.76,30.65 62.32,30.65 61.82,31.16 60.12,31.16 59.83,30.86 59.44,30.86 59.13,31.17 59.13,31.33 57.21,33.26 57.21,33.92 55.59,35.54 54.7,35.54 52.78,37.46 51.48,37.46 50.78,38.16 50.78,40.59 v1(51.07,40.89)
CNV_RGI_RSP_R: length 2.6
  TOP w0.14: R215.1 48.62,41.04 48.54,41.03 v1(48.54,41.03)
  BOTTOM w0.14: CN16.34 48.57,41 48.54,41.03 v1(48.54,41.03)
CNV_WR_CLKN: length 182.8
  TOP w0.14: v1(204.93,25.04) U14.BD4
  IN2 w0.089: v1(204.93,25.04) 204.78,25.04 204.5,25.31 203.58,25.31 203.33,25.06 203.33,24.61 202.66,23.93 200.69,23.93 199.41,25.21 199.41,29.81 199.61,30.01 199.61,31.02 198.44,32.2 197.63,32.2 196.77,33.06 196.77,33.92 195.45,35.23 194.1,35.23 193.7,35.64 193.2,35.64 188.97,39.87 187.83,39.87 186.49,41.2 184.89,41.2 184.52,41.57 182.37,41.57 182,41.2 181.06,41.2 180.97,41.29 180.97,42.1 180.76,42.31 180.32,42.31 180.12,42.11 180.12,41.29 180.03,41.2 179.68,41.2 179.55,41.33 179.55,41.99 179.25,42.29 179.25,43.31 179.43,43.48 179.7,43.48 180.26,42.93 180.77,42.93 180.97,43.13 180.97,43.54 180.71,43.8 180.71,44.47 180.08,45.1 178.75,45.1 178.32,44.67 178.32,41.81 178.6,41.53 178.6,40.62 174.96,36.99 107.18,36.99 107,37.17 100.98,37.17 99.59,38.56 96.39,38.56 95.74,37.91 94.03,37.91 93.51,38.43 92.04,38.43 91.59,37.97 86.42,37.97 86.24,38.15 83.76,38.15 82.45,36.84 81.23,36.84 80.88,37.19 80.11,37.19 78.81,35.89 76.95,35.89 76.89,35.96 74.96,35.96 74.56,36.35 74.56,36.6 73.99,37.18 73.84,37.18 73.72,37.3 72.74,37.3 72.1,37.94 69.49,37.94 68.76,38.67 66.63,38.67 66.38,38.92 64.43,38.92 63.92,38.41 62.14,38.41 61.03,39.52 60.49,39.52 60.15,39.86 60.15,40.06 v1(60.34,40.25)
  BOTTOM w0.14: v1(60.34,40.25) 60.07,39.98 60.07,39.07 58.75,37.75 CN16.21
CNV_WR_CLKP: length 182.8
  TOP w0.14: U14.BE3 v1(204.36,24.71)
  IN2 w0.089: v1(204.36,24.71) 204.52,24.86 204.52,25.03 204.42,25.12 203.66,25.12 203.52,24.98 203.52,24.53 202.74,23.74 200.61,23.74 199.22,25.13 199.22,29.89 199.42,30.09 199.42,30.94 198.36,32.01 197.55,32.01 196.58,32.99 196.58,33.84 195.37,35.04 194.02,35.04 193.62,35.45 193.13,35.45 188.9,39.68 187.75,39.68 186.41,41.01 184.81,41.01 184.44,41.38 182.45,41.38 182.08,41.01 180.98,41.01 180.78,41.21 180.78,42.02 180.68,42.12 180.4,42.12 180.31,42.03 180.31,41.21 180.11,41.01 179.6,41.01 179.36,41.26 179.36,41.91 179.06,42.21 179.06,43.39 179.35,43.68 179.78,43.68 180.34,43.12 180.69,43.12 180.78,43.21 180.78,43.46 180.52,43.72 180.52,44.39 180,44.91 178.83,44.91 178.51,44.59 178.51,41.89 178.79,41.61 178.79,40.55 175.04,36.8 107.11,36.8 106.92,36.98 100.9,36.98 99.51,38.37 96.47,38.37 95.82,37.72 93.95,37.72 93.43,38.24 92.12,38.24 91.66,37.78 86.35,37.78 86.16,37.96 83.84,37.96 82.53,36.65 81.15,36.65 80.8,37 80.19,37 78.89,35.7 76.87,35.7 76.81,35.77 74.88,35.77 74.37,36.27 74.37,36.52 73.91,36.99 73.76,36.99 73.64,37.11 72.66,37.11 72.02,37.75 69.41,37.75 68.68,38.48 66.55,38.48 66.3,38.73 64.51,38.73 64,38.22 62.06,38.22 60.95,39.33 60.41,39.33 59.95,39.78 59.95,40.07 59.94,40.09 59.94,40.16 59.83,40.28 59.7,40.28 v1(59.68,40.25)
  BOTTOM w0.14: CN16.23 58.16,38.25 58.39,38.02 58.64,38.02 59.8,39.18 59.8,40.11 59.68,40.23 v1(59.68,40.25)
CNV_WRXN0: length 182.3
  TOP w0.102: v1(202.2,24.41) 202.04,24.25 201.9,24.25 201.8,24.35 201.8,24.8 202.11,25.11 203.23,25.11 203.61,25.49 204.12,25.49 204.21,25.4 204.21,25.29 204.11,25.19 U14.BB3
  IN2 w0.089: v1(61.65,40.27) 61.51,40.13 61.51,39.97 62.41,39.07 63.63,39.07 64.13,39.58 67.28,39.58 67.51,39.35 69.02,39.35 69.31,39.05 70.59,39.05 70.79,39.24 71.71,39.24 72.23,38.72 73.44,38.72 74.67,37.48 78.04,37.48 78.41,37.85 81.16,37.85 81.36,37.65 82.32,37.65 83.49,38.82 86.67,38.82 86.86,38.63 91.27,38.63 91.76,39.12 95.05,39.12 95.39,39.46 95.66,39.46 96.58,40.39 99.09,40.39 99.66,39.82 99.66,39.43 101.23,37.87 107.28,37.87 107.49,37.66 174.69,37.66 177.26,40.22 177.26,43.06 177.66,43.46 177.66,45.15 178.28,45.76 180.36,45.76 181.37,44.74 181.37,44.07 181.65,43.79 181.65,42.48 181.9,42.23 184.79,42.23 185.16,41.86 187.06,41.86 187.65,41.27 188.51,41.27 192.89,36.89 194.73,36.89 197.53,34.09 197.53,33.64 198.28,32.88 198.68,32.88 200.27,31.3 200.27,29.72 200.47,29.53 201.03,29.53 201.35,29.85 202.04,29.85 202.61,29.28 203.17,29.28 203.61,28.83 203.61,28.2 203.24,27.83 200.55,27.83 200.07,27.35 200.07,25.49 200.53,25.04 201.61,25.04 201.92,24.73 201.92,24.7 v1(202.2,24.41)
  BOTTOM w0.14: v1(61.65,40.27) 61.5,40.11 61.5,39.36 59.43,37.29 59.43,36.59 59.09,36.25 CN16.15
