# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_EE_DO: length 11.1
  TOP w0.089: 256.41,55.11 256.69,54.83 257.92,54.83 U7.AC4
  TOP w0.14: U9.2 252.11,52.34 252.44,52.67 v1(252.44,52.87) 252.44,53.31 253.1,53.97 253.52,53.97 253.75,54.19 254.47,54.19 254.79,54.52 R150.2 255.19,54.65 255.64,55.11 256.41,55.11
  BOTTOM w0.14: R786.1 250.78,51.01 252.44,52.67 v1(252.44,52.87)
TBT_EE_WP_N: length 15.7
  TOP w0.089: v1(260.05,57.12) 260.05,56.8 260.28,56.57 U7.V1
  TOP w0.14: U9.3 250.84,52.06 250.23,52.68 v1(250.21,52.68)
  IN2 w0.089: v1(260.05,57.12) 259.78,56.85 258.5,56.85 258.18,56.53 257.27,56.53 257.04,56.3 254.76,56.3 253.7,55.25 252.98,55.25 251.9,54.16 251.06,54.16 250.64,53.74 250.64,53.13 250.21,52.7 v1(250.21,52.68)
  BOTTOM w0.14: R785.2 249.72,52.21 249.73,52.21 250.19,52.68 v1(250.21,52.68)
TBT_FORCE_PWR: length 83.4
  TOP w0.089: U7.H4 265.26,55.27 v2(265.31,55.27)
  IN2 w0.089: v2(265.31,55.27) 264.91,55.66 264.24,55.66 263.84,56.06 258.81,56.06 257.84,55.1 257.84,52.81 257.41,52.38 256.39,52.38 255.9,51.88 255.9,50.87 254.18,49.15 254.18,46.98 255.41,45.74 255.41,38.11 254.22,36.92 v1(254.22,35.88)
  IN3 w0.089: v1(254.22,35.88) 253.76,36.34 252.88,36.34 252.01,35.47 247.36,35.47 245.08,33.2 244.13,33.2 243.65,33.67 240.73,33.67 239.17,35.24 238.03,35.24 237.65,34.86 237.65,34.27 237.33,33.95 236.47,33.95 236.09,33.57 235.02,33.57 234.31,34.28 233.27,34.28 232.58,33.6 230.88,33.6 229.91,34.56 228.64,34.56 226.8,32.72 226.8,31.55 225.9,30.65 220.34,30.65 220.03,30.33 215.02,30.33 214.67,29.99 214.67,29.49 214.32,29.14 213.77,29.14 213.19,28.55 213.19,28.45 v1(212.77,28.03)
  BOTTOM w0.14: R941.2 213.24,27.56 v1(212.77,28.03) ; v2(265.31,55.27) 265.22,55.36 R759.1 265.4,55.8 265.63,56.02 265.63,56.57 265.42,56.78 R744.1
TBT_FORCE_PWR_R: length 1.3
  TOP w0.14: U14.BA20 212.62,26.73 v1(212.62,26.75)
  BOTTOM w0.14: v1(212.62,26.75) 212.46,26.91 R941.1
TBT_HPD: length 10
  TOP w0.14: R211.2 241.83,41.47 v1(241.75,41.39) ; v1(246.07,46.41) U10.32
  IN2 w0.089: v1(241.75,41.39) 241.75,41.93 242.18,42.36 243.1,42.36 244.98,44.24 244.98,44.69 246.07,45.78 v1(246.07,46.41)
  BOTTOM w0.14: v1(246.07,46.41) 246.69,47.03 R807.1
TBT_HTPLG_NL5: length 91.1
  TOP w0.14: R129.1 258.37,60.34 254.53,60.34 254.13,59.93 D18.2 253.92,59.22 v1(253.4,59.75)
  IN2 w0.089: v1(253.4,59.75) 253.4,58.43 252.36,57.4 252.36,56.6 251.49,55.72 251.1,55.72 247.57,52.19 247.57,49.49 246.49,48.41 246.49,44.73 245.55,43.79 244.94,43.79 243.2,42.05 242.81,42.05 242.41,41.65 242.41,41.08 242.24,40.91 241.05,40.91 240.82,40.68 240.02,40.68 238.8,39.46 238.37,39.46 237.19,38.29 237.19,37.81 237.79,37.21 237.79,36.33 237.27,35.81 236.85,35.81 236.19,35.15 236.19,34.36 235.29,33.45 235.29,30.82 236.49,29.61 236.49,28.44 237.37,27.57 237.37,25.49 236.84,24.97 236.84,21.98 236.44,21.58 235.07,21.58 234.94,21.45 227.02,21.45 225.42,23.05 224.61,23.05 224.15,22.6 224.15,21.37 223.21,20.43 221.31,20.43 220.14,19.26 217.18,19.26 214.4,16.48 211.63,16.48 210.66,15.51 v1(210.61,15.51)
  BOTTOM w0.14: v1(210.61,15.51) 210.76,15.66 210.76,17.87 210.2,18.44 R1055.1
TBT_I2C_SCL: length 32.3
  TOP w0.089: v1(261.36,57.59) 260.5,56.73 260.5,55.93 U7.U2
  TOP w0.14: v1(250.46,39.13) 250.59,39 U13.32
  IN1 w0.086: v1(261.36,57.59) 260.72,56.95 260.44,56.95 260.21,56.72 259.1,56.72 257.65,55.27 256.84,55.27 256.78,55.34 255.28,55.34 254.55,54.61 254.55,49.59 252.48,47.52 252.48,41.86 252.29,41.67 250.37,41.67 249.04,40.34 249.04,39.92 249.83,39.13 v1(250.46,39.13)
  BOTTOM w0.14: v1(261.36,57.59) 260.82,58.13 R132.2
TBT_I2C_SCL1: length 21.4
  TOP w0.14: v1(253.61,37.94) 253.61,37.84 252.94,37.17 U13.27
  IN2 w0.089: v1(247.16,25.78) 246.69,25.78 245.92,26.56 245.92,28.78 248.44,31.3 251.43,31.3 252.39,32.26 252.39,35.37 252.56,35.54 252.56,37.28 253.06,37.79 253.46,37.79 v1(253.61,37.94)
  BOTTOM w0.14: R964.1 247.54,25.78 v1(247.16,25.78) 247.15,25.78 246.59,25.23 Q74.1
TBT_I2C_SDA: length 31
  TOP w0.089: v1(262,57.55) 260.74,56.29 U7.U1
  TOP w0.14: v1(252.34,40.96) 252.34,40.8 251.27,39.72 250.43,39.72 250.03,39.33 250.03,38.88 250.19,38.72 U13.33
  IN1 w0.086: v1(252.34,40.96) 252.34,41.34 252.86,41.85 252.86,47.37 254.74,49.25 254.74,54.53 255.36,55.15 256.7,55.15 256.76,55.08 257.73,55.08 258.9,56.25 259.18,56.53 260.98,56.53 v1(262,57.55)
  BOTTOM w0.14: R133.2 262.77,58.05 262.5,58.05 v1(262,57.55)
TBT_I2C_SDA1: length 19.3
  TOP w0.14: v1(253.16,38.42) 253.08,38.35 253.08,37.87 252.77,37.57 U13.28
  IN2 w0.089: v1(244.89,27.63) 244.93,27.66 244.93,28.41 248.25,31.74 251.25,31.74 251.95,32.44 251.95,35.56 252.11,35.72 252.11,37.47 252.88,38.23 252.97,38.23 253.06,38.32 253.06,38.33 v1(253.16,38.42)
  BOTTOM w0.14: v1(244.89,27.63) 245.47,27.63 R942.1 245.75,27.08 245.59,26.92 Q74.4
TBT_JTAG_TCK: length 1.3
  TOP w0.089: v2(260.76,55.28) 260.81,55.28 U7.T4
  BOTTOM w0.14: v2(260.76,55.28) 260.19,55.85 R753.2
TBT_JTAG_TDI: length 2.5
  TOP w0.089: v2(259.46,54.67) 259.14,55 U7.Y4
  BOTTOM w0.14: v2(259.46,54.67) 259.42,54.67 258.67,55.42 258.31,55.42 258.06,55.67 R756.2
TBT_JTAG_TDO: length 1.5
  TOP w0.089: v2(259.46,55.29) 259.49,55.29 U7.W4
  BOTTOM w0.14: v2(259.46,55.29) 259.21,55.29 258.77,55.73 R755.2
TBT_JTAG_TMS: length 1.3
  TOP w0.089: v2(260.11,55.3) 260.14,55.3 U7.V4
  BOTTOM w0.14: R754.2 259.81,55.57 259.84,55.57 v2(260.11,55.3)
TBT_MAINON: length 8.1
  TOP w0.089: 266.99,57.69 266.48,57.18 266.48,55.93 U7.D2
  TOP w0.14: R139.2 272.2,58.24 R138.1 R137.1 270.04,58.24 269.85,58.04 v1(268.28,58.04) 267.34,58.04 266.99,57.69
TBT_MRESET: length 213.8
  TOP w0.14: v1(69.17,35.45) 69.17,35.37 69.85,34.69 70.27,34.69 71.13,33.82 71.95,33.82 72.23,34.11 U18.125 ; R375.2 R376.2 254.02,29.77 R370.2 254.02,30.26 v1(253.63,30.26)
  IN3 w0.089: v1(69.17,35.45) 71.37,35.45 72.11,34.71 74.84,34.71 75.04,34.52 78.85,34.52 79.43,33.93 82.66,33.93 83.61,34.88 85.69,34.88 86.19,35.37 87.45,35.37 88.91,33.91 90.05,33.91 90.87,33.09 95.25,33.09 95.85,32.49 97.18,32.49 97.53,32.84 98.54,32.84 99.67,33.97 110.96,33.97 111.65,33.28 166.21,33.28 166.39,33.46 179.36,33.46 181.1,35.19 184.74,35.19 189.49,30.44 189.49,27.3 192.38,24.42 192.38,22.79 192.96,22.21 195.31,22.21 195.54,21.98 195.54,21.43 198.06,18.91 199.88,18.91 200.56,19.59 204.91,19.59 205.3,19.2 216.07,19.2 216.31,19.44 218.53,19.44 219.13,20.04 224.79,20.04 225.52,20.78 227.47,20.78 229.91,23.21 230.79,23.21 231.39,22.61 234.15,22.61 234.32,22.44 235.21,22.44 236.41,23.63 240.02,23.63 240.7,24.31 240.7,25.04 241.08,25.42 243.35,25.42 243.62,25.69 243.62,28.05 245.08,29.52 252.88,29.52 v1(253.63,30.26)
TBT_PLTRST#: length 70.9
  TOP w0.089: v2(264.01,55.27) 263.74,55 U7.L4
  TOP w0.14: v1(213.31,51.45) 213.3,51.46 213.3,51.76 211.7,53.36 210.56,53.36 210.08,52.87 R160.2 209.97,52.97 R162.1 209.19,51.97 U6.4
  IN2 w0.089: v2(264.01,55.27) 263.41,55.87 259.2,55.87 258.22,54.89 258.22,52.65 255.15,49.57 255.15,46.69 v1(255.26,46.57)
  IN3 w0.089: v1(213.31,51.45) 213.31,51.48 214.69,52.86 217.8,52.86 221.03,49.63 222.49,49.63 224.3,47.82 228.74,47.82 230.88,45.69 237.12,45.69 238.87,43.93 240.33,43.93 241.01,44.62 243.39,44.62 244.72,45.95 246.35,45.95 247.29,46.89 249.29,46.89 249.7,46.49 253.97,46.49 254.16,46.68 254.96,46.68 255.06,46.57 v1(255.26,46.57)
TBT_RBIAS: length 1.3
  TOP w0.14: U7.J6 v2(264.66,54.02)
  BOTTOM w0.14: R765.1 264.66,54.08 v2(264.66,54.02)
TBT_RESET_C: length 1.1
  TOP w0.14: R352.1 255.14,31.72 255.04,31.62 R361.2
TBT_RESET_N: length 43.8
  TOP w0.089: v2(265.97,55.31) 265.95,55.31 U7.F4
  TOP w0.14: R380.1 R370.1 254.26,30.79 R361.1 254.26,31.29 253.94,31.61 v1(253.74,31.61)
  IN2 w0.089: v1(253.74,31.61) 252.84,32.52 252.84,35.19 253,35.35 253,37.1 253.24,37.34 253.72,37.34 254.12,37.74 254.12,39.06 253.76,39.41 253.76,41.73 253.99,41.95 253.99,49.23 255.56,50.8 255.56,53.39 255.16,53.79 255.16,54.25 255.72,54.8 257.28,54.8 258.73,56.25 263.92,56.25 264.29,55.88 265.39,55.88 v2(265.97,55.31)
  BOTTOM w0.14: R742.1 266.12,58.01 265.65,57.54 265.65,57.04 265.91,56.78 265.91,55.37 v2(265.97,55.31)
TBT_RSENSE: length 1.4
  TOP w0.14: U7.H6 v2(265.31,54.02)
  BOTTOM w0.14: R765.2 265.39,54.02 v2(265.31,54.02)
TBT_SPI_HOLD#: length 2.5
  TOP w0.14: v1(251.99,42.69) 252.11,42.82 U9.7
  BOTTOM w0.14: v1(251.99,42.69) 251.6,43.08 R822.2
TBT_SRC0_CFG1: length 8.6
  TOP w0.089: U7.AA1 258.9,56.42 257.97,57.34 257.17,57.34 257.09,57.27
  TOP w0.14: R148.1 252.59,56.22 255.36,56.22 256.41,57.27 257.09,57.27
TBT_SRC0_DDC_CLK: length 7
  TOP w0.089: U7.Y2 259.13,55.92 259.13,56.44 257.99,57.57 257.4,57.57
  TOP w0.14: R144.1 255.16,56.68 v1(255.59,57.12) 256.05,57.57 257.4,57.57
  BOTTOM w0.14: R745.2 255.92,57.44 v1(255.59,57.12)
TBT_SRC0_DDC_DATA: length 11.5
  TOP w0.089: U7.Y1 259.36,56.46 257.97,57.85 257.68,57.85
  TOP w0.14: 257.68,57.85 v1(255.64,57.85) 255.03,57.24 253.19,57.24 R143.1 252.15,56.21 251.83,56.21 251.32,55.69 251.32,54.79 251.06,54.53 R149.2
TBT_TEST_EN: length 2.3
  TOP w0.089: v1(266.12,57.32) 266.26,57.18 U7.E1
  BOTTOM w0.14: R757.2 266.31,57.12 v1(266.12,57.32)
TBT_TEST_PWRGD: length 2.7
  TOP w0.089: v1(256.71,53.92) 257.09,54.3 257.55,54.3 257.77,54.08 258.2,54.08 U7.AB5
  BOTTOM w0.14: v1(256.71,53.92) 256.4,53.61 R774.2
TBT_WAKE#_EC: length 243.5
  TOP w0.14: R500.1 68.59,19.48 68.3,19.77 v1(68.3,20.05)
  IN1 w0.086: v1(65.25,24.55) 64.99,24.3 64.99,23.61 65.77,22.83 65.77,22.28 68,20.05 v1(68.3,20.05)
  IN2 w0.089: v1(237.01,36.28) 236.93,36.37 236.93,38.3 238.28,39.65 238.73,39.65 239.96,40.89 239.96,41.65 240.91,42.6 242.98,42.6 244.51,44.12 244.51,44.62 245.58,45.69 245.58,47.76 247.38,49.57 247.38,52.27 251.02,55.91 251.41,55.91 251.7,56.2 251.7,57.01 251.42,57.29 251.42,57.73 251.95,58.27 252.33,58.27 252.75,58.68 v1(252.75,59.73)
  IN3 w0.089: v1(72.93,39.82) 72.97,39.78 73.26,39.78 73.7,40.22 75.52,40.22 76.39,39.35 77.51,39.35 78.35,40.19 81.17,40.19 81.49,40.52 86.77,40.52 87.52,39.77 88.97,39.77 89.24,40.03 89.36,40.03 89.39,40.01 91.41,40.01 91.61,39.81 91.91,39.81 92.17,39.55 96.01,39.55 96.95,38.61 100.17,38.61 100.51,38.27 175.98,38.27 179.1,41.39 182.93,41.39 183.1,41.22 186.04,41.22 186.22,41.41 189.99,41.41 192.26,39.14 194.39,39.14 200.03,33.5 202.49,33.5 202.96,33.97 203.86,33.97 204.84,34.95 205.59,34.95 205.73,35.09 209.61,35.09 210.59,34.11 211.27,34.11 211.54,34.38 213.4,34.38 214.54,33.23 219.22,33.23 219.83,32.62 220.62,32.62 220.87,32.87 220.87,33.55 221.18,33.87 222.15,33.87 222.25,33.96 225.97,33.96 227.37,35.36 230.93,35.36 231.41,34.88 232.84,34.88 233.14,35.18 235.35,35.18 236.46,36.28 v1(237.01,36.28)
  BOTTOM w0.14: R737.1 253.38,59.1 v1(252.75,59.73) ; v1(65.25,24.55) 65.88,25.19 65.88,26.74 65.15,27.47 64.99,27.47 64.61,27.85 64.33,27.85 63.84,28.35 63.84,29.21 63.32,29.73 63.32,30.22 65.37,32.27 65.37,34.24 63.92,35.69 63.92,36.17 64.62,36.87 65.27,36.87 65.91,37.52 65.91,38.29 66.44,38.82 67.13,38.82 67.51,38.44 70.45,38.44 71.73,39.72 72.83,39.72 v1(72.93,39.82)
TBT_XTL25_IN: length 6.1
  TOP w0.089: U7.D22 266.95,46.27 266.95,45.71 266.97,45.69
  TOP w0.114: 266.97,45.69 266.97,45.44 v1(267.13,45.28) 267.71,44.7
  TOP w0.14: Y1.1 267.7,41.97 267.7,42.95 C224.2 267.71,43.42 267.71,43.6 267.85,43.74 268.07,43.74 268.21,43.88 268.21,44.16 268.07,44.3 267.85,44.3 267.71,44.44 267.71,44.7
TBT_XTL25_OUT: length 6.2
  TOP w0.114: U7.D23 266.72,45.1 267.18,44.63
  TOP w0.14: Y1.3 266.91,40.64 267.18,40.91 267.18,43 C223.2 267.18,43.39 v1(267.18,44.01) 267.18,44.63
TBTA_AUX_N: length 2.4
  TOP w0.089: v2(259.46,49.47) U7.W15
  BOTTOM w0.14: C758.1 258.61,48.33 259,48.33 259.46,48.79 v2(259.46,49.47)
TBTA_AUX_P: length 2.4
  TOP w0.089: U7.Y15 259.14,49.56 258.99,49.42 258.85,49.42 v2(258.8,49.47)
  BOTTOM w0.14: C751.1 258.46,48.78 258.6,48.64 258.87,48.64 259.14,48.92 259.14,49.21 258.88,49.47 v2(258.8,49.47)
TBTA_CA2HD_0_N: length 29.7
  TOP w0.089: U7.A21 268.02,46.96 arc(267.9,47.07) 268.02,47.19 268.27,47.19 arc(268.32,47.18) 268.35,47.16 268.57,46.94 arc(268.61,46.91) 268.65,46.9 268.84,46.9 arc(268.99,46.93) 269.12,47.02 v1(269.26,47.16)
  TOP w0.14: CN3.B10 293.6,40.42 arc(293.49,40.4) 293.4,40.34 arc(293.35,40.31) 293.3,40.3 293.27,40.3 arc(293.15,40.32) v2(293.05,40.39)
  BOTTOM w0.14: v1(269.26,47.16) arc(269.42,47.05) 269.61,47.01 269.79,47.01 arc(270.22,47.1) 270.58,47.34 270.65,47.41 arc(271.37,47.89) 272.22,48.06 273.4,48.06 arc(276.3,47.48) 278.75,45.84 282.14,42.46 282.52,42.08 arc(284.53,40.73) 286.9,40.26 arc(287.23,40.33) 287.52,40.52 D97.2 arc(287.87,40.36) 288.23,40.29 292.82,40.29 arc(292.95,40.32) v2(293.05,40.39)
TBTA_CA2HD_0_P: length 29.7
  TOP w0.089: U7.B21 267.75,46.85 267.8,46.79 arc(267.87,46.74) 267.95,46.73 268.84,46.73 arc(268.92,46.71) 268.98,46.67 v1(269.26,46.4)
  TOP w0.14: CN3.B11 293.48,39.92 arc(293.46,39.93) 293.45,39.94 293.43,39.95 arc(293.39,39.97) 293.35,39.98 293.29,39.98 arc(293.16,39.95) v2(293.05,39.88)
  BOTTOM w0.14: v1(269.26,46.4) 269.36,46.5 arc(269.57,46.64) 269.81,46.69 arc(270.34,46.8) 270.8,47.1 270.88,47.19 arc(271.49,47.6) 272.22,47.74 273.4,47.74 arc(276.18,47.19) 278.53,45.62 281.91,42.23 282.3,41.85 arc(284.41,40.44) 286.9,39.95 arc(287.25,39.88) 287.54,39.68 D98.2 287.62,39.71 arc(287.92,39.91) 288.26,39.98 292.82,39.98 arc(292.95,39.95) v2(293.05,39.88)
TBTA_CA2HD_1_N: length 26.4
  TOP w0.089: U7.B15 267.77,49.58 267.8,49.55 arc(267.87,49.51) 267.95,49.49 268.3,49.49 arc(268.34,49.5) 268.38,49.52 268.44,49.59 arc(268.48,49.62) 268.52,49.62 269.3,49.62 arc(269.33,49.62) 269.36,49.6 arc(269.41,49.57) 269.47,49.55
  TOP w0.14: 269.47,49.55 271.85,49.55 arc(276.68,48.59) 280.78,45.85 arc(282.57,44.66) 284.68,44.24 286.95,44.24 arc(287.27,44.18) 287.55,43.99 D25.2 287.7,44.1 arc(287.88,44.22) 288.1,44.27 291.51,44.27 arc(291.58,44.25) 291.63,44.22 arc(291.68,44.19) 291.73,44.17 CN3.A10
TBTA_CA2HD_1_P: length 26.4
  TOP w0.089: U7.A15 268.03,49.72 arc(267.92,49.83) 268.03,49.95 268.29,49.95 arc(268.34,49.94) 268.37,49.92 268.46,49.84 arc(268.49,49.81) 268.54,49.8 269.27,49.8 arc(269.33,49.81) 269.38,49.85 arc(269.41,49.87) 269.44,49.87 269.47,49.87
  TOP w0.14: 269.47,49.87 271.85,49.87 arc(276.81,48.89) 281.01,46.08 arc(282.69,44.95) 284.68,44.56 286.95,44.56 arc(287.22,44.61) 287.44,44.76 D24.2 287.7,44.75 arc(287.88,44.63) 288.1,44.58 291.5,44.58 arc(291.57,44.6) 291.63,44.64 arc(291.67,44.66) 291.72,44.67 CN3.A11
TBTA_CC1: length 48.4
  TOP w0.178: v1(253.41,35.86) 253.36,35.86 253.25,35.97 U13.24
  IN1 w0.508: v1(253.41,35.86) 253.41,35.98 253.92,36.49 255.95,36.49 256.84,35.6 256.84,31.94 258.54,30.24 259.61,30.24 260.92,31.56 263.72,31.56 264.61,32.45 267.76,32.45 269.44,34.13 269.44,35.75 272.33,38.65 278.99,38.65 282.59,42.26 288.51,42.26 v1(289.48,41.29)
TBTA_CC2: length 55.5
  TOP w0.178: v1(253.41,36.92) 253.25,36.77 U13.26
  TOP w0.254: CN3.B5 293.09,42.92 v2(293.09,42.93)
  IN1 w0.508: v1(289.22,45.89) 289.22,46.47 288.59,47.11 283.81,47.11 277.26,40.55 277.26,39.92 276.75,39.41 272.14,39.41 271.76,39.02 270.05,39.02 269.74,39.34 264.97,39.34 264.53,38.9 259.2,38.9 257.47,37.18 253.66,37.18 v1(253.41,36.92)
  IN4 w0.381: 293.67,43.02 293.58,42.93 v2(293.09,42.93)
  IN4 w0.508: 293.67,43.02 295.88,45.23 295.88,46.5 295.37,47.01 294.78,47.01 293.78,48.02 292.21,48.02 291.36,47.16 291.36,46.68 290.61,45.93 v1(290.61,45.71)
TBTA_DPSRC_AUX_N: length 40.9
  TOP w0.14: U5.20 282.89,49.59 283.33,49.16 283.33,48.59 283,48.26 282.68,48.26 v1(282.39,47.97) 282.39,48.05 282.25,48.19 281.81,48.19 281.45,48.54 281.45,49.23 281.69,49.47 U5.17
  IN1 w0.086: v1(282.39,47.97) 282.44,48.02 282.44,48.29 282.31,48.41 281.94,48.41 281.07,47.54 273.41,47.54 271.31,49.64 268.21,49.64 266.59,48.02 266.59,46.61 266.26,46.29 263.73,46.29 263.36,46.66 263.36,47.04 262.86,47.54 261.89,47.54 260.93,48.51 257.45,48.51 256.63,47.69 256.63,47.21 v1(256.99,46.85)
  BOTTOM w0.14: C758.2 257.82,48.37 257.35,48.37 256.7,47.71 256.7,47.15 v1(256.99,46.85) ; R803.2 282.19,48.05 282.27,47.97 v1(282.39,47.97)
TBTA_DPSRC_AUX_P: length 40.4
  TOP w0.14: U5.18 282.09,49.42 281.77,49.1 281.77,48.7 281.96,48.51 282.2,48.51 282.34,48.64 v1(282.34,48.83) 282.59,48.58 282.87,48.58 283.01,48.72 283.01,49.02 282.49,49.55 U5.19
  IN1 w0.086: v1(282.34,48.83) 282.11,48.6 281.87,48.6 280.99,47.73 273.49,47.73 271.39,49.83 268.13,49.83 266.4,48.1 266.4,46.69 266.19,46.47 263.81,46.47 263.54,46.74 263.54,47.12 262.94,47.73 261.97,47.73 261.01,48.69 257.37,48.69 256.45,47.77 256.45,47.21 v1(256.09,46.85)
  BOTTOM w0.14: v1(256.09,46.85) 256.38,47.15 256.38,47.84 257.22,48.68 257.76,48.68 C751.2 ; R799.2 282.32,48.81 v1(282.34,48.83)
TBTA_HD2CA_0_N: length 24
  TOP w0.14: CN3.A3 291.79,40.67 arc(291.74,40.66) 291.69,40.63 arc(291.63,40.6) 291.57,40.58 arc(291.38,40.55) 291.22,40.44 291.11,40.33 arc(291.05,40.29) 290.98,40.28 288.05,40.28 arc(287.87,40.31) 287.72,40.41 D29.2 287.4,40.4 arc(287.24,40.3) 287.06,40.26 286.51,40.26 arc(284.62,40.63) 283.03,41.7 280.1,44.63 arc(276.36,47.13) 271.95,48 271.72,48 arc(271.43,48.06) C185.1
TBTA_HD2CA_0_P: length 24
  TOP w0.14: CN3.A2 291.87,40.17 arc(291.82,40.19) 291.77,40.22 arc(291.72,40.25) 291.65,40.27 291.57,40.27 arc(291.5,40.25) 291.44,40.21 291.33,40.1 arc(291.17,40) 290.98,39.96 288.05,39.96 arc(287.88,39.92) 287.74,39.83 D30.2 287.43,39.79 arc(287.26,39.9) 287.06,39.94 286.51,39.94 arc(284.5,40.34) 282.8,41.48 279.87,44.4 arc(276.24,46.83) 271.95,47.69 271.72,47.69 arc(271.43,47.63) C190.1
TBTA_HD2CA_1_N: length 24.6
  TOP w0.14: CN3.B3 293.52,43.92 arc(293.46,43.94) 293.42,43.97 293.4,43.98 arc(293.36,44.01) 293.3,44.02 293.29,44.02 arc(293.19,44) v2(293.1,43.95)
  BOTTOM w0.14: v2(293.1,43.95) arc(292.94,44.05) 292.76,44.09 292.4,44.09 arc(292.17,44.12) 291.95,44.22 arc(291.9,44.24) 291.85,44.25 288.08,44.25 arc(287.86,44.21) 287.68,44.09 D96.2 287.45,44.09 arc(287.26,44.22) 287.03,44.26 284.14,44.26 arc(282.44,44.6) 281,45.56 280.66,45.91 arc(277.55,47.98) 273.89,48.71 271.39,48.71 arc(271.11,48.65) C755.1
TBTA_HD2CA_1_P: length 24.6
  TOP w0.14: v2(293.07,44.45) 293.1,44.42 arc(293.18,44.36) 293.29,44.34 293.37,44.34 arc(293.41,44.35) 293.45,44.38 arc(293.51,44.41) 293.57,44.42 CN3.B2
  BOTTOM w0.14: C748.1 arc(271.07,49.07) 271.31,49.03 273.89,49.03 arc(277.67,48.27) 280.88,46.13 281.22,45.79 arc(282.56,44.89) 284.14,44.58 287.03,44.58 arc(287.24,44.62) 287.42,44.74 D95.2 287.74,44.71 arc(287.9,44.61) 288.08,44.57 291.85,44.57 arc(292,44.55) 292.13,44.49 arc(292.26,44.43) 292.4,44.41 292.95,44.41 arc(293.01,44.42) v2(293.07,44.45)
TBTA_HPD: length 27.8
  TOP w0.127: v2(263.33,55.29) U7.M4
  TOP w0.14: U13.30 251.39,38.69 251.78,39.08 251.78,39.67 v1(253.21,41.09)
  IN1 w0.086: v2(263.33,55.29) 262.98,55.65 258.83,55.65 257.89,54.71 256.61,54.71 256.54,54.77 255.51,54.77 255.12,54.38 255.12,49.09 253.84,47.82 253.84,41.58 253.35,41.09 v1(253.21,41.09)
  BOTTOM w0.14: v2(263.33,55.29) 263.57,55.53 R749.1
TBTA_I2C_INT: length 31.7
  TOP w0.127: U7.J4 264.34,55.01 v2(264.63,55.31)
  TOP w0.14: v1(251.61,41.06) 251.61,40.63 251.03,40.05 250.42,40.05 249.79,39.43 U13.34
  IN1 w0.086: v2(264.63,55.31) 264.11,55.84 258.75,55.84 257.81,54.9 256.69,54.9 256.62,54.96 255.43,54.96 254.93,54.45 254.93,49.17 253.66,47.9 253.66,42.2 252.76,41.31 252.76,40.69 252.55,40.48 251.91,40.48 251.61,40.78 v1(251.61,41.06)
  BOTTOM w0.14: R760.1 264.51,55.45 264.63,55.32 v2(264.63,55.31)
TBTA_I2C_IRQ2Z_EC: length 181.3
  TOP w0.14: v1(87.06,39.28) 86.94,39.41 86.94,40.06 86.19,40.81 85.83,40.81 R227.2 ; v1(252.44,38.39) 252.4,38.35 252.31,38.35 252.28,38.32 U13.29
  IN3 w0.089: v1(87.06,39.28) 87.13,39.22 89.71,39.22 90.12,39.63 91.25,39.63 91.45,39.42 91.76,39.42 92.01,39.17 95.86,39.17 96.8,38.23 100.01,38.23 100.35,37.89 176.13,37.89 178.79,40.55 182.75,40.55 183.23,41.03 186.11,41.03 186.3,41.22 189.91,41.22 192.18,38.95 194.31,38.95 199.95,33.31 202.57,33.31 203.03,33.78 203.94,33.78 204.92,34.76 205.67,34.76 205.81,34.9 209.53,34.9 210.51,33.92 211.35,33.92 211.62,34.19 213.32,34.19 214.47,33.04 218.88,33.04 219.56,32.36 220.79,32.36 221.14,32.72 224.01,32.72 224.96,33.67 226.06,33.67 227.55,35.16 229.86,35.16 231.04,33.98 232.42,33.98 233.43,34.99 235.43,34.99 236.06,35.62 239.64,35.62 239.95,35.31 241.06,35.31 241.6,34.76 246.04,34.76 247.95,36.67 250.97,36.67 252.44,38.14 v1(252.44,38.39)
  BOTTOM w0.14: R843.1 v1(252.44,38.39)
TBTA_LSRX: length 26.3
  TOP w0.089: U7.A4 268.14,54.73 268.62,54.73 269.04,54.3 269.73,54.3 269.8,54.37
  TOP w0.14: v1(272,51.63) 271.71,51.92 271.71,52.92 R158.1 271.95,53.39 271.76,53.59 271.76,53.93 271.32,54.37 269.8,54.37 ; U5.9 281.69,53.55 281.4,53.84 281.4,54.43 281.73,54.75 282.04,54.75 v1(282.24,54.96) 282.44,54.75 282.7,54.75 283.08,54.38 283.08,53.67 282.89,53.48 U5.6
  BOTTOM w0.14: v1(282.24,54.96) 282.24,54.87 282.1,54.73 280.44,54.73 278.11,52.4 278.11,51.31 277.13,50.33 272.41,50.33 271.74,51.01 271.74,51.37 v1(272,51.63)
TBTA_LSTX: length 25.7
  TOP w0.089: 269.82,54.06 269.8,54.06 269.73,54.12 268.97,54.12 268.54,54.55 268.09,54.55 268.03,54.49 268.03,54.38 U7.A5
  TOP w0.14: v1(271.1,51.63) 271.39,51.92 271.39,52.91 R157.1 271.26,53.39 271.44,53.57 271.44,53.8 271.18,54.06 269.82,54.06 ; U5.8 282.09,53.6 281.72,53.97 281.72,54.3 281.86,54.44 282.09,54.44 v1(282.26,54.26) 282.43,54.44 282.57,54.44 282.76,54.25 282.76,53.81 282.49,53.53 U5.7
  BOTTOM w0.14: v1(282.26,54.26) 282.11,54.41 280.58,54.41 278.43,52.26 278.43,51.18 277.26,50.02 272.28,50.02 271.42,50.88 271.42,51.41 271.2,51.63 v1(271.1,51.63)
TBTA_SBU1: length 18.8
  TOP w0.14: v1(290.44,43.76) 290.9,43.3 291.64,43.3 291.76,43.17 CN3.A8 ; U5.1 284.06,50.68 284.14,50.76 285.72,50.76 287.74,48.75 287.74,47.47 D21.2 287.83,46.76 v1(287.83,46.47)
  IN4 w0.086: v1(287.83,46.47) 287.65,46.65 287.65,47.36 287.76,47.48 288.11,47.48 288.2,47.39 288.2,46.98 288.33,46.85 288.49,46.85 288.6,46.96 288.6,47.31 288.7,47.42 288.98,47.42 289.13,47.27 289.13,46.7 289.78,46.04 289.78,45.19 289.88,45.1 290.66,45.1 290.75,45.01 290.75,44.76 290.62,44.63 290.1,44.63 289.98,44.51 289.98,43.92 290.14,43.76 v1(290.44,43.76)
TBTA_SBU2: length 18.8
  TOP w0.14: U5.2 285.86,51.08 288.05,48.88 288.05,47.3 D22.2 288.19,46.84 288.49,46.55 v1(288.49,46.35)
  TOP w0.254: CN3.B8 293.09,41.42 v2(293.07,41.41)
  BOTTOM w0.14: v1(288.49,46.35) 288.59,46.45 291.21,46.45 292.25,45.4 293.28,45.4 293.74,44.94 293.74,41.73 293.42,41.41 v2(293.07,41.41)
TBTA_TX0_N: length 3.3
  TOP w0.089: 269.47,48.02 269.4,48.02 arc(269.36,48.01) 269.33,48 arc(269.29,47.96) 269.23,47.95 268.54,47.95 arc(268.44,47.97) 268.35,48.03 arc(268.26,48.09) 268.16,48.11 268.03,48.11 arc(267.88,48.08) 267.75,47.99 U7.B19
  TOP w0.14: 269.47,48.02 270.24,48.02 arc(270.51,48.07) C185.2
TBTA_TX0_P: length 3.3
  TOP w0.089: 269.47,47.7 269.44,47.7 arc(269.4,47.71) 269.37,47.73 arc(269.32,47.76) 269.27,47.77 268.52,47.77 arc(268.48,47.77) 268.44,47.74 268.37,47.67 arc(268.33,47.65) 268.29,47.64 268.02,47.64 arc(267.99,47.65) 267.96,47.66 267.92,47.7 arc(267.9,47.81) 267.99,47.88 U7.A19
  TOP w0.14: 269.47,47.7 270.15,47.7 arc(270.47,47.64) C190.2
TBTA_TX1_N: length 3.1
  TOP w0.089: U7.B17 267.74,48.69 arc(267.87,48.6) 268.03,48.57 268.26,48.57 arc(268.31,48.58) 268.34,48.61 268.41,48.68 arc(268.45,48.7) 268.49,48.71 268.88,48.71 arc(269.09,48.67) 269.27,48.55 v1(269.33,48.48)
  BOTTOM w0.14: v1(269.33,48.48) 269.36,48.51 arc(269.56,48.64) 269.79,48.69 269.95,48.69 arc(270.2,48.64) C755.2
TBTA_TX1_P: length 3.1
  TOP w0.089: U7.A17 268,48.8 arc(267.96,48.8) 267.92,48.83 arc(267.9,48.87) 267.89,48.91 arc(267.9,48.95) 267.92,48.99 arc(267.97,49.02) 268.02,49.03 268.27,49.03 arc(268.33,49.02) 268.37,48.99 268.44,48.92 arc(268.48,48.9) 268.52,48.89 268.88,48.89 arc(269.06,48.92) 269.21,49.03 v1(269.32,49.13)
  BOTTOM w0.14: C748.2 270.39,49.19 arc(270.19,49.05) 269.94,49 269.62,49 arc(269.46,49.04) v1(269.32,49.13)
TBTA_USB2_D_N: length 90.6
  TOP w0.102: v1(207.66,40.3) 207.66,40.2 207.54,40.07 207.42,40.07 207.19,40.3 206.67,40.3 206.53,40.16 U14.M6
  TOP w0.14: v1(283.93,43.17) 283.75,43 283.75,42.66 283.89,42.52 284.32,42.52 R206.1
  IN3 w0.089: v1(207.66,40.3) 207.66,40.05 207.42,39.8 207.42,39.29 208.1,38.61 210.08,38.61 210.98,39.51 214.89,39.51 215.71,38.69 219.68,38.69 220.22,38.14 220.22,37.78 221.4,36.61 223.93,36.61 224.21,36.88 224.58,36.88 224.74,37.04 226.01,37.04 226.27,37.3 230.48,37.3 230.66,37.13 233.54,37.13 233.73,37.32 234.66,37.32 235.22,37.89 237.88,37.89 238.45,37.32 242.43,37.32 242.45,37.3 246.4,37.3 247.45,38.35 248.83,38.35 250.82,40.34 253.47,40.34 254.87,41.74 257.3,41.74 258.75,43.18 268.21,43.18 271.01,40.39 271.01,39.6 271.64,38.97 280.14,38.97 283.6,42.42 283.6,42.84 v1(283.93,43.17)
TBTA_USB2_D_N_T: length 13.6
  TOP w0.14: v2(293.07,41.91) 293.11,41.95 arc(293.17,42) 293.26,42.02 arc(293.28,42.02) 293.3,42.02 arc(293.32,42.02) 293.35,42.02 arc(293.39,42.01) 293.43,41.98 arc(293.49,41.94) 293.57,41.92 CN3.B7 ; R206.2 285.29,42.44 285.48,42.25 285.95,42.25 D26.2 286.5,42.4 290.35,42.4 v1(290.64,42.69) 291.01,42.32 291.47,42.32 291.83,42.67 CN3.A7
  IN1 w0.086: v1(290.64,42.69) 290.39,42.43 290.11,42.43 290,42.55 290,42.85 290.33,43.18 291.6,43.18 292.71,42.08 292.91,42.08 v2(293.07,41.91)
TBTA_USB2_D_P: length 90.6
  TOP w0.102: v1(207.99,39.74) 207.87,39.87 207.33,39.87 207.1,40.1 207.02,40.1 U14.N8
  TOP w0.14: v1(283.08,43.17) 283.34,43.17 283.49,43.02 283.49,42.55 283.78,42.25 284.55,42.25 284.71,42.1 284.71,41.9 R217.1
  IN3 w0.089: v1(283.08,43.17) 283.41,42.84 283.41,42.5 280.06,39.16 271.72,39.16 271.2,39.68 271.2,40.47 268.29,43.37 258.67,43.37 257.22,41.93 254.79,41.93 253.39,40.53 250.74,40.53 248.75,38.54 247.37,38.54 246.33,37.49 242.53,37.49 242.51,37.51 238.53,37.51 237.96,38.08 235.14,38.08 234.58,37.51 233.65,37.51 233.46,37.32 230.74,37.32 230.56,37.49 226.19,37.49 225.93,37.23 224.66,37.23 224.5,37.08 224.13,37.08 223.85,36.8 221.48,36.8 220.41,37.86 220.41,38.22 219.75,38.88 215.79,38.88 214.97,39.7 210.9,39.7 210,38.8 208.18,38.8 207.61,39.37 207.61,39.72 207.75,39.87 207.87,39.87 v1(207.99,39.74)
TBTA_USB2_D_P_T: length 13.6
  TOP w0.14: R217.2 285.57,41.98 286.12,41.98 D27.2 286.61,42.13 290.54,42.13 v1(290.64,42.03) 290.66,42.05 291.58,42.05 291.7,42.17 CN3.A6 ; v2(293.07,42.42) 293.14,42.36 arc(293.21,42.31) 293.3,42.29 arc(293.35,42.3) 293.4,42.33 293.44,42.37 arc(293.5,42.41) 293.57,42.42 CN3.B6
  IN1 w0.086: v2(293.07,42.42) 292.89,42.24 292.78,42.24 291.67,43.35 290.26,43.35 289.83,42.92 289.83,42.48 290.04,42.27 290.4,42.27 v1(290.64,42.03)
TBTA_VBUS_L: length 4.5
  TOP w0.254: v2(293.07,40.9) 293.1,40.92 CN3.B9 ; v1(291.36,41.06) 291.47,41.17 CN3.A4 ; v1(291.23,43.78) 291.34,43.67 CN3.A9 292.74,43.67 292.97,43.44 v2(293.08,43.44) 293.1,43.42 CN3.B4
  vias: v1(252.37,31.54) v1(252.37,30.88) v1(253.03,31.56) v1(253.03,30.9) v1(284.63,47.92) v1(285.39,47.92) v1(286.15,47.92) v1(286.91,47.92)
TBTB_HPD: length 5.7
  TOP w0.089: 263.94,57.9 264.97,56.87 264.97,56.67 265.11,56.53 265.11,55.92 U7.G2
  TOP w0.14: 263.94,57.9 263.41,58.44 261.98,58.44 R128.1
TBTB_I2C_INT: length 7
  TOP w0.089: U7.E2 266.02,55.93 266.02,56.83 265.73,57.13 265.73,57.57 265.88,57.73 266.54,57.73 266.72,57.9
  TOP w0.14: R136.1 TP22.1 269.15,58.51 267.33,58.51 266.72,57.9
TBTB_LSRX: length 1.3
  TOP w0.089: v2(267.25,54.07) 267.5,54.32 U7.B5
  BOTTOM w0.14: R773.1 267.8,53.52 v2(267.25,54.07)
TBTB_LSTX: length 1.1
  TOP w0.089: U7.B4 267.35,54.78 v2(267.23,54.65)
  BOTTOM w0.14: R769.1 267.55,54.65 v2(267.23,54.65)
TEMP_MBAT#: length 100.2
  TOP w0.14: U18.73 84.25,24.22 83.92,24.55 v1(83.92,25.03) ; v1(92.88,61.47) 93.32,61.92 93.93,61.92 94.41,61.44 95.89,61.44 96.83,60.51 97.21,60.51 97.35,60.37 97.35,59.91 97.59,59.66 98.04,59.66 98.68,59.02 99.13,59.02 PR184.1
  IN1 w0.086: v1(92.88,61.47) 92.69,61.47 92.4,61.18 92.4,60.47 92.82,60.04 92.82,58.94 92.42,58.54 92.35,58.54 90.2,56.39 88.36,56.39 86.28,54.31 84.6,54.31 84.09,53.8 84.09,53 83.62,52.53 81.33,52.53 81.04,52.24 80.41,52.24 80.05,51.88 80.05,50.26 79.87,50.07 78.49,50.07 77.37,51.19 76.14,51.19 75.7,51.64 v1(74.53,51.64)
  IN3 w0.089: v1(83.92,25.03) 83.8,25.03 83.34,25.49 82.95,25.49 82.72,25.26 82.21,25.26 81.93,25.54 80.22,25.54 79.74,25.06 77.68,25.06 77.14,25.6 77.14,26.67 76.28,27.52 74.07,27.52 70.85,30.74 70.85,31.4 69.53,32.72 67.34,32.72 67.14,32.52 66.87,32.52 66.59,32.8 64.42,32.8 v1(64.1,32.47)
  IN4 w0.086: v1(74.53,51.64) 74.5,51.66 70.33,51.66 70.08,51.42 68.38,51.42 68.11,51.15 64.98,51.15 64.42,51.71 61.33,51.71 61.1,51.47 61.1,50.01 62.24,48.87 62.24,45.02 64.98,42.28 64.98,38.34 64.85,38.2 v1(64.85,38.19)
  BOTTOM w0.14: v1(74.53,51.64) 74.15,52.01 PR503.1 73.86,52.01 73.41,52.46 PR504.2 ; v1(64.85,38.19) 64.47,38.19 62.87,36.59 62.87,35.27 64.33,33.8 64.33,32.71 v1(64.1,32.47)
TEMP_MBAT#_CONN: length 2
  BOTTOM w0.254: PR504.1 73.26,52.01 74.18,51.09 PJ22.6
THER_ALERT#: length 23.7
  TOP w0.102: 33.75,93.51 34.11,93.87 34.95,93.87 36.09,95.01 36.74,95.01 36.82,94.92 38.02,94.92 UG1.BJ3
  TOP w0.14: 33.75,93.51 33.45,93.21 31.51,93.21 31.31,93.01 30.8,93.01 30.6,93.21 28.92,93.21 RG30.2 28.19,92.89 27.11,91.81 25.71,91.81 25.25,92.27 25.25,93.76 25.63,94.13 v1(25.92,94.13) 25.92,94.72 24.91,95.72 23.56,95.72 23.34,95.95 23.34,96.69 23.56,96.92 24.78,96.92 24.87,97 RG25.1
THERMDN: length 4.6
  TOP w0.102: 34.41,94.11 34.91,94.11 36.04,95.25 UG1.BJ1
  TOP w0.14: TPG1.1 33.18,94.11 34.41,94.11
THERMDP: length 7.5
  TOP w0.102: 34.36,94.35 34.77,94.35 36,95.59 37.16,95.59 37.5,95.25 UG1.BJ2
  TOP w0.14: 34.36,94.35 32.68,94.35 32.17,93.84 31.23,93.84 TPG2.1
THERMTRIP#: length 20.7
  TOP w0.089: v1(124.82,126.51) 124.59,126.74 U3.J31
  TOP w0.14: v1(117.98,129.73) 116.88,129.73 116.09,128.95 115.52,128.95 115.2,129.26 115.2,129.41 114.81,129.81 114.81,130.36 R51.2 R46.1 113.71,132.47 v1(113.57,132.47) 112.9,131.8 Q5.1
  IN4 w0.102: v1(124.82,126.51) 124.66,126.67 123.1,126.67 122.72,127.06 122.72,128.07 123.09,128.44 123.09,129.61 121.75,130.95 118.77,130.95 117.98,130.16 v1(117.98,129.73)
TI_TBT_EE_CLK: length 29.8
  TOP w0.14: U12.6 242.13,36.87 242.08,36.82 v1(242.06,36.82) ; R154.1 253.95,53.45 253.32,53.45 v1(253.32,53.44) ; U13.38 248.19,39.45 v1(248.38,39.64)
  IN2 w0.089: v1(253.32,53.44) 253.32,53.45 254.28,53.45 254.68,53.05 254.68,51.15 253.1,49.58 253.1,45.81 252.39,45.09 252.39,42.5 252.03,42.14 250.59,42.14 248.84,40.38 248.84,40.1 v1(248.38,39.64) 248.38,39.19 246.16,36.97 245.18,36.97 245,37.15 242.39,37.15 v1(242.06,36.82)
TI_TBT_EE_CS_N: length 33.7
  TOP w0.14: U13.39 247.79,38.88 247.52,39.16 v1(246.81,39.16) ; U12.1 237.28,39.41 237.58,39.72 238.75,39.72 239.39,39.08 v1(239.39,38.01)
  IN2 w0.089: v1(239.39,38.01) 243.15,38.01 243.88,38.75 245,38.75 245.62,38.14 246.04,38.14 246.81,38.9 v1(246.81,39.16) 246.81,39.57 249.04,41.81 249.04,45.46 250.55,46.97 250.55,51.76 249.81,52.5 249.81,53.07 250.05,53.31 v1(250.06,53.31)
  BOTTOM w0.14: v1(250.06,53.31) 250.06,53.39 250.91,54.24 R768.1 ; v1(239.39,38.01) 239.39,37.86 239.74,37.51 R857.1
TI_TBT_EE_DI: length 30.2
  TOP w0.14: v1(248.32,40.32) 248.44,40.32 248.84,39.92 248.84,39.46 248.59,39.22 U13.37 ; v1(251.23,53.76) 251.79,54.32 R153.1 ; v1(241.34,36.87) 241.34,36.69 242.44,35.6 U12.5
  IN2 w0.089: v1(241.34,36.87) 242.09,37.62 243.31,37.62 244.03,38.35 244.85,38.35 245.5,37.69 246.22,37.69 247.38,38.85 247.38,39.37 v1(248.32,40.32) 248.32,40.53 249.5,41.71 249.5,45.08 251.58,47.16 251.58,53.38 251.23,53.74 v1(251.23,53.76)
TI_TBT_EE_DO: length 39.8
  TOP w0.14: U13.36 248.99,39.21 249.17,39.39 249.17,39.8 v1(249.47,40.11) ; U12.2 236.49,38.14 237.1,38.75 237.88,38.75 v1(238.59,38.04) ; R150.1 253.54,54.65 v1(253.32,54.43)
  IN2 w0.089: v1(238.59,38.04) 238.8,38.04 239.66,37.18 240.28,37.18 241.17,36.29 242.33,36.29 242.73,36.68 244.81,36.68 244.99,36.5 246.36,36.5 249.29,39.44 249.29,39.93 v1(249.47,40.11) 249.47,40.35 250.79,41.67 252.22,41.67 252.86,42.3 252.86,44.9 253.59,45.63 253.59,49.4 255.15,50.96 255.15,53.24 253.94,54.45 253.34,54.45 v1(253.32,54.43)
  BOTTOM w0.14: R847.1 239.07,38.52 v1(238.59,38.04)
TI_TBT_EE_WP_N: length 4.5
  TOP w0.14: v1(239.09,36.87) 238.73,37.23 236.88,37.23 236.67,37.02 236.67,37.01 236.53,36.87 U12.3
  BOTTOM w0.14: v1(239.09,36.87) 239.53,36.87 R866.2
TI_TBT_SPI_HOLD#: length 2.4
  TOP w0.14: v1(244.67,37.91) 244.62,37.96 244.62,38 244.48,38.14 U12.7
  BOTTOM w0.14: R851.2 244.41,37.65 v1(244.67,37.91)
TMU_CLK_OUT: length 3.8
  TOP w0.089: U7.V2 260.04,55.93 260.04,56.53 259.64,56.94 259.64,57.42 260.01,57.8 260.01,57.88 260.04,57.9
  TOP w0.14: 260.04,57.9 v1(260.11,57.98) 260.11,58.84 R131.1
TP_LED_CTL_W: length 121
  TOP w0.14: v1(8.83,71.06) 8.91,71.13 U4.1 ; v1(82.92,16.32) 83.47,15.78 Q40.2 83.71,15.31 83.71,14.44 D75.1 83.42,14.15 R593.2
  IN2 w0.089: v1(8.83,71.06) 8.83,64.35 8.96,64.23 8.96,61.66 10.43,60.19 10.43,56.68 11.71,55.41 12.29,55.41 12.9,54.8 15.19,54.8 16.71,53.28 16.71,48.94 17.32,48.34 17.32,47.36 17.09,47.13 17.09,44.57 19.2,42.46 19.2,40.05 22.65,36.6 22.65,35.94 24.95,33.64 25.22,33.64 25.91,32.96 28.62,32.96 29.29,32.29 33.24,32.29 33.72,31.82 37.32,31.82 38.65,30.5 41.95,30.5 42.95,29.5 42.95,29.25 43.48,28.72 43.96,28.72 46.99,25.7 51.04,25.7 51.29,25.44 52.4,25.44 53.17,24.68 53.17,22.76 54.82,21.11 54.82,20.47 56.25,19.04 59.2,19.04 60.53,17.71 62.26,17.71 62.48,17.49 62.48,15.74 62.94,15.28 65.88,15.28 66.78,16.18 67.63,16.18 67.87,16.42 69.53,16.42 69.65,16.55 80.42,16.55 81.7,15.27 82.89,15.27 83.13,15.51 83.13,16.12 v1(82.92,16.32)
TP_LED_EN_W: length 8.6
  TOP w0.508: Q40.3 81.22,16.25 D71.1 79.27,15.49 v1(79.24,15.46)
  BOTTOM w0.254: CN19.27 75.65,18.78 75.95,18.48 76.07,18.48 76.19,18.36
  BOTTOM w0.508: v1(79.24,15.46) 79.24,15.56 76.45,18.36 76.19,18.36
TP_LED_PWR: length 8.1
  BOTTOM w0.254: CN19.28 75.15,19.93 74.9,20.18 74.09,20.18 74.06,20.21
  BOTTOM w0.508: Q76.3 70.16,20.81 70.76,21.4 71.48,21.4 C896.1 71.83,21.05 C901.1 72.91,20.98 D109.1 73.86,20.41 74.06,20.21
TP_LED_PWR_CTL: length 105.2
  TOP w0.14: v1(8.02,72.08) 8.21,72.26 U4.32
  IN2 w0.089: v1(8.02,72.08) 8.38,72.08 9.23,71.23 9.23,69.82 9.02,69.61 9.02,64.43 9.15,64.31 9.15,61.74 10.62,60.27 10.62,56.76 11.79,55.6 12.37,55.6 12.98,54.99 15.27,54.99 16.9,53.35 16.9,49.02 17.52,48.4 17.52,47.26 17.28,47.02 17.28,44.65 19.39,42.54 19.39,40.13 22.84,36.68 22.84,36.02 25.02,33.83 25.3,33.83 25.99,33.15 28.7,33.15 29.37,32.49 33.39,32.49 33.87,32.01 37.4,32.01 38.73,30.69 42.03,30.69 42.55,30.17 44.08,30.17 44.49,29.75 44.49,28.46 47.07,25.89 51.12,25.89 51.37,25.63 52.48,25.63 53.36,24.76 53.36,22.84 55.01,21.19 55.01,20.55 56.33,19.23 59.43,19.23 60.76,17.9 62.4,17.9 v1(63.19,17.11)
  BOTTOM w0.14: R989.2 68.48,22.81 Q76.2 68,22.22 66.94,21.15 v1(66.94,21.14) 66.94,20.8 66.13,20 66.13,19.46 65.24,18.57 65.24,17.76 64.95,17.48 63.56,17.48 v1(63.19,17.11)
TPCLK: length 27.6
  TOP w0.14: U18.89 84.04,30.62 83.56,31.1 83.11,31.1 81.77,29.76 v1(81.77,29.26) ; v1(86.3,18.38) 86.3,19.01 D54.1 86.42,19.21 86.89,19.68 88.15,19.68 C443.2 88.58,19.76 88.84,19.5 v1(89.09,19.5) R482.2
  IN1 w0.086: v1(81.77,29.26) 81.77,28.44 80.42,27.08 80.42,24.02 80.9,23.55 84.24,23.55 84.86,22.92 84.86,20.84 84.46,20.43 84.46,19.63 85.25,18.84 85.97,18.84 86.3,18.51 v1(86.3,18.38)
  BOTTOM w0.14: v1(86.3,18.38) 86.28,18.41 86.28,18.46 86.15,18.58 CN19.6
TPD_EN: length 9
  TOP w0.14: v1(89.39,24.51) 89.1,24.22 R421.1
  BOTTOM w0.14: CN19.11 83.65,19.66 85.49,21.5 85.49,21.59 D110.1 85.89,21.99 86.79,21.99 89.25,24.45 89.33,24.45 v1(89.39,24.51)
TPD_INT#: length 40.9
  TOP w0.14: v1(84.19,14.65) 83.99,14.44 83.99,13.52 R597.1 ; R267.1 69.34,36.74 v1(69.26,36.67) 69.26,36.59 68.88,36.22 R284.1
  IN3 w0.089: v1(68.19,26.56) 68.61,26.14 68.61,22.48 69.31,21.77 71.36,21.77 72.12,21.01 72.12,18.2 74.47,15.86 81.41,15.86 81.73,15.54 81.73,14.42 82.04,14.11 83.66,14.11 v1(84.19,14.65)
  BOTTOM w0.14: v1(68.19,26.56) 68.19,26.58 68.34,26.73 68.34,29.47 67.56,30.25 67.56,34.97 v1(69.26,36.67)
TPD_INT#_PCH: length 185.8
  TOP w0.14: v1(87.56,13.54) 87.1,13.08 R598.1 ; v1(215.48,27.07) 215.2,27.07 214.82,26.69 U14.BA24
  IN3 w0.089: v1(93.63,37.21) 94.01,37.21 94.07,37.28 99.62,37.28 99.96,36.94 176.53,36.94 177.83,38.24 188.34,38.24 188.81,38.71 190.53,38.71 194.01,35.23 195.58,35.23 196.98,33.84 196.98,31.25 198.28,29.95 198.28,25.6 198.6,25.28 203.64,25.28 204.59,26.23 206.09,26.23 206.77,25.54 208.93,25.54 209.75,26.36 210.91,26.36 211.19,26.08 211.19,25.65 211.65,25.19 212.69,25.19 213.18,24.7 213.91,24.7 214.39,25.18 214.39,26.08 215.39,27.07 v1(215.48,27.07)
  BOTTOM w0.102: 216.45,20.77 216.84,21.17 216.84,21.54 216.71,21.67 216.71,25.08 215.92,25.87 215.92,26.62 v1(215.48,27.07)
  BOTTOM w0.14: v1(93.63,37.21) 94.1,36.74 94.1,35.42 96.54,32.99 96.54,31.57 95.07,30.09 95.07,29.19 95.58,28.68 96.61,28.68 97.06,28.23 97.06,24.94 99.4,22.6 99.4,19.72 99.08,19.4 95.86,19.4 94.79,18.33 94.33,18.33 93.69,17.69 93.06,17.69 92.81,17.45 92.81,16.51 89.93,13.63 87.65,13.63 v1(87.56,13.54) ; R1110.2 216.28,17.66 216.59,17.97 216.59,18.91 216.24,19.26 216.24,20.56 216.45,20.77
TPD_INT#_R: length 8.7
  TOP w0.14: v1(84.85,16.73) 84.93,16.73 85.53,17.33 D55.1 85.74,17.36 85.74,16.75 Q42.1 86.08,16.25 85.59,15.76 85.59,15 86,14.59 R572.1 86,14.32 85.69,14.01 R584.2
  BOTTOM w0.14: v1(84.85,16.73) 84.15,17.43 CN19.10
TPDATA: length 29.8
  TOP w0.14: v1(81.15,28.95) 81.15,29.84 82.91,31.6 83.76,31.6 84.34,31.02 U18.90 ; v1(85.62,18.33) 85.41,18.54 D53.1 85.48,19.14 85.99,19.66 86.17,19.66 86.68,20.17 87.72,20.17 87.81,20.26 88.97,20.26 C430.2 89.67,19.99 90.51,19.99 R465.2
  IN1 w0.086: v1(85.62,18.33) 85.13,18.33 84.02,19.45 84.02,20.62 84.42,21.02 84.42,22.7 84.02,23.11 80.71,23.11 79.98,23.84 79.98,27.27 81.15,28.44 v1(81.15,28.95)
  BOTTOM w0.14: CN19.7 85.65,18.36 v1(85.62,18.33)
TPEV_PEG_VIEW_2: length 146.7
  TOP w0.14: v1(111.35,105.78) 111.9,105.78 112.63,106.52 114.09,106.52 114.35,106.78 115.8,106.78 116.5,106.09 118.54,106.09 119.01,105.62 119.6,105.62 120.71,104.51 121,104.51 121.23,104.73 121.23,105.21 122.06,106.04 U3.E3 ; R197.2 196.41,45.66 R190.2 195.85,46.22 194.23,46.22 194.03,46.42 v1(194,46.42)
  IN3 w0.089: v1(191.07,56.71) 191.05,56.73 191.05,57.44 192.84,59.22 193.06,59.22 193.36,58.92 193.36,58.11 196.84,54.63 196.84,48.12 195.14,46.42 v1(194,46.42)
  IN4 w0.086: v1(191.07,56.71) 190.49,56.71 190.26,56.94 189.52,56.94 189.21,57.25 187.15,57.25 185.16,59.24 185.16,59.98 183.05,62.08 182.83,62.08 181.55,63.37 181.43,63.37 180.62,64.19 180.62,64.81 164.92,80.51 125.22,80.51 122.47,83.25 121.62,83.25 109.43,95.45 109.43,102.55 110.32,103.44 110.32,105.55 110.6,105.82 111.3,105.82 v1(111.35,105.78)
TPM_MISO: length 6.1
  BOTTOM w0.14: U44.24 241.93,17.68 242.12,17.87 v1(243.02,17.87) 243.38,18.23 243.38,18.97 R1044.2 243.97,19.37 244.25,19.66 244.25,20.29 243.69,20.86 243.1,20.86 R1016.2
TPM_SCS#: length 4
  BOTTOM w0.14: R1017.2 239.81,20.5 240.32,19.99 240.32,19.36 R1063.2 239.79,18.59 239.93,18.46 U44.20
TPM_VDD: length 2.1
  BOTTOM w0.381: R1145.2 240.43,9.87 239.58,10.72 C939.1
  vias: v1(233.8,15.49) v1(236.16,13.05) v1(242.13,18.41)
TRI_EN#: length 55.1
  TOP w0.14: U18.99 82.63,32.96 81.68,32.01 81.44,32.01 79.95,30.52 79.95,28.9 v1(79.72,28.67)
  IN3 w0.089: v1(44.95,37.9) 45.1,37.9 45.49,38.3 46.97,38.3 48.27,36.99 48.78,36.99 49.73,36.05 52.15,36.05 52.66,35.53 54.05,35.53 54.2,35.69 56.66,35.69 58.59,33.76 62.98,33.76 63.22,33.52 63.91,33.52 64.09,33.7 67.24,33.7 67.63,33.3 70.82,33.3 71.32,32.81 71.94,32.81 72.37,32.38 74.16,32.38 74.28,32.27 74.66,32.27 75.07,31.86 75.07,31.06 75.5,30.62 76.92,30.62 78.2,29.34 78.2,29.02 78.7,28.53 79.58,28.53 v1(79.72,28.67)
  BOTTOM w0.14: PQ55.2 39.52,36.2 40.47,37.15 PR551.1 40.6,37.28 40.84,37.04 41.3,37.04 42.53,38.27 v1(42.53,38.58) 44.28,38.58 v1(44.95,37.9)
TS_SPI1_CLK: length 1
  TOP w0.14: R489.1 209.98,18.12 TP57.1
TS_SPI1_CLK_R: length 5.8
  TOP w0.102: R489.2 209.98,19.94 210.56,20.53 210.56,20.87 211.22,21.53 211.41,21.53 212.37,22.49 212.37,23.97 212.46,24.06 212.46,24.39 U14.BE19
TS_SPI1_CS#: length 1.6
  TOP w0.14: TP53.1 210.13,14.97 210.13,15.58 R551.1
TS_SPI1_CS#_R: length 8.4
  TOP w0.102: 212.57,21.44 212.57,23.8 U14.BF19
  TOP w0.14: 212.57,21.44 212.34,21.2 211.98,21.2 211.58,20.79 211.58,20.62 211.27,20.31 210.69,20.31 210.49,20.11 210.49,17.48 R551.2
TS_SPI1_MISO: length 0.9
  TOP w0.14: R550.1 210.34,12.95 TP55.1
TS_SPI1_MISO_R: length 8
  TOP w0.102: U14.BE18 211.78,24.09 211.78,23.67 211.96,23.49 211.96,22.77 211.13,21.94 211.05,21.94 209.96,20.85 209.96,20.8
  TOP w0.14: R553.2 209.24,18.01 209.24,20.08 209.96,20.8
TS_SPI1_MOSI: length 1.2
  TOP w0.14: TP54.1 208.21,16.28 R553.1
TS_SPI1_MOSI_R: length 11.7
  TOP w0.102: 210.2,20.7 210.2,20.8 211.14,21.73 211.27,21.73 212.17,22.63 212.17,23.66 U14.BF18
  TOP w0.14: R550.2 209.24,14.08 209.24,14.88 209.55,15.18 209.55,16.01 v1(209.34,16.21) 209.34,16.51 209.56,16.72 209.56,20.06 210.2,20.7
TS_VREF: length 5.1
  TOP w0.102: UG1.BF12 44.65,97.35 44.29,97.7 44.29,98.23 43.65,98.88 42.72,98.88 v2(42.66,98.82)
  BOTTOM w0.14: v2(42.66,98.82) 42.52,98.96 41.18,98.96 TPG67.1
TSENSE_4PH_A: length 3.9
  TOP w0.191: PU2.14 174.43,163.2 174.16,162.93
  TOP w0.203: PR72.1 172.88,160.88 PC66.2 v1(173.5,162.27) 174.16,162.93
TX0_HDMI+: length 13.7
  TOP w0.14: v1(65.63,162.7) 65.37,162.96 64.71,162.96 63.65,164.02 63.65,164.56 64,164.91 64,165.11 63.74,165.37 63.54,165.37 63.19,165.02 62.65,165.02 61.69,165.98 61.69,166.96 CN1.7
  BOTTOM w0.14: v1(65.63,162.7) 65.45,162.88 65.23,162.88 65.06,163.05 64.26,163.05 U33.10 64.16,163.05 63.38,163.05 U33.1 63.29,163.05 62.1,163.05 61.89,163.26 60.2,163.26 R636.2
TX0_HDMI-: length 13.7
  TOP w0.14: CN1.9 62.45,167.1 62.11,166.76 62.11,166.15 62.82,165.44 63.02,165.44 63.37,165.79 63.91,165.79 64.42,165.29 64.42,164.74 64.07,164.39 64.07,164.19 64.88,163.38 65.62,163.38 v1(65.63,163.39)
  BOTTOM w0.14: v1(65.63,163.39) 65.53,163.3 65.4,163.3 65.23,163.47 64.24,163.47 U33.9 64.18,163.47 63.37,163.47 U33.2 63.3,163.47 62.27,163.47 62.06,163.68 60.18,163.68 59.99,163.86 59.99,164.06 R635.2
TX1_HDMI+: length 26.2
  IN1 w0.086: v1(67.42,162.84) 67.25,163.01 66.85,163.01 66.54,163.31 66.54,165.61 67.31,166.38 67.92,166.38 68.43,166.89 68.43,167.53 68.24,167.73 60.75,167.73 60.36,168.12 60.36,168.29 CN1.4
  BOTTOM w0.14: v1(67.42,162.84) 67.38,162.88 66.9,162.88 66.73,162.7 66.73,162 66.09,161.36 64.38,161.36 U37.7 64.29,161.37 63.51,161.37 U37.4 63.42,161.36 61.91,161.36 61.67,161.6 60.83,161.6 60.36,162.06 58.49,162.06 R638.2
TX1_HDMI-: length 26.2
  IN1 w0.086: v1(67.43,163.53) 67.43,163.4 67.28,163.25 66.95,163.25 66.78,163.41 66.78,165.52 67.41,166.14 68.02,166.14 68.67,166.79 68.67,167.63 68.34,167.97 60.84,167.97 60.59,168.22 60.59,168.39 60.8,168.6 CN1.6
  BOTTOM w0.14: v1(67.43,163.53) 67.19,163.3 66.73,163.3 66.31,162.88 66.31,162.18 65.92,161.78 64.38,161.78 U37.6 64.3,161.79 63.5,161.79 U37.5 63.42,161.78 62.08,161.78 61.84,162.02 61,162.02 60.54,162.48 58.41,162.48 R637.2
TX2_HDMI+: length 25.2
  IN4 w0.086: CN1.1 58.83,166.82 58.83,166.56 59.23,166.16 65.38,166.16 66.89,164.64 68.13,164.64 68.51,165.03 68.51,165.44 v1(68.65,165.57)
  BOTTOM w0.14: v1(68.65,165.57) 68.65,162.26 66.29,159.9 65.45,159.9 65.39,159.85 64.36,159.85 U37.10 64.32,159.85 63.48,159.85 U37.1 63.44,159.85 61.79,159.85 61.19,160.45 59.96,160.45 R644.2
TX2_HDMI-: length 25.1
  IN4 w0.086: CN1.3 59.35,167.1 59.07,166.82 59.07,166.66 59.33,166.39 65.47,166.39 66.99,164.88 68.03,164.88 68.28,165.13 68.28,165.42 68.12,165.58 v1(67.92,165.58)
  BOTTOM w0.14: v1(67.92,165.58) 68.02,165.58 68.23,165.37 68.23,162.43 66.12,160.32 65.28,160.32 65.22,160.27 64.39,160.27 U37.9 64.28,160.27 63.52,160.27 U37.2 63.41,160.27 61.97,160.27 61.36,160.87 59.93,160.87 59.76,161.05 59.76,161.27 R639.2
TXC_HDMI+: length 21.2
  IN2 w0.089: CN1.10 63.39,168.94 63.39,169.28 63.66,169.55 68,169.55 68.66,168.9 68.66,166.55 68.15,166.05 67.2,166.05 66.69,165.54 66.69,164.97 66.09,164.37 65.71,164.37 v1(65.59,164.25)
  BOTTOM w0.14: R634.2 58.46,164.86 60.88,164.86 61.2,164.54 61.67,164.54 C501.2 62.03,164.55 63.28,164.55 U33.4 63.39,164.55 64.16,164.55 U33.7 64.26,164.55 64.77,164.55 64.89,164.42 65.41,164.42 v1(65.59,164.25)
TXC_HDMI-: length 21.1
  IN2 w0.089: v1(65.59,165.25) 65.38,165.25 65.29,165.16 65.29,164.82 65.47,164.65 65.98,164.65 66.41,165.09 66.41,165.65 67.09,166.33 68.04,166.33 68.38,166.67 68.38,168.78 67.89,169.27 63.78,169.27 63.67,169.16 63.67,168.98 CN1.12
  BOTTOM w0.14: R632.2 58.17,165.42 58.31,165.28 61.05,165.28 61.38,164.96 61.66,164.96 C501.1 62.02,164.97 63.31,164.97 U33.5 63.36,164.97 64.18,164.97 U33.6 64.24,164.97 64.94,164.97 65.07,164.84 65.45,164.84 65.59,164.98 v1(65.59,165.25)
UART2_CTS#: length 9.4
  TOP w0.14: v1(213.91,27.63) 213.58,27.63 U14.AV21
  BOTTOM w0.102: v1(213.91,27.63) 214.33,27.21 214.33,26.76 213.92,26.35 213.92,25.27 213.34,24.7 213.34,23.28 213.51,23.11 213.78,23.11 214.06,22.82
  BOTTOM w0.14: R1048.2 214.26,20.62 v1(214.06,20.82) 214.06,22.82
UART2_RTS#: length 12.2
  TOP w0.14: v1(213.83,27) 213.75,27.08 U14.AW21
  BOTTOM w0.14: R1099.1 209.72,18.06 209.72,19.75 209.89,19.92 R1055.2 v1(210.2,20.73) 210.2,20.87 212.64,23.31 212.64,25.69 213.83,26.89 v1(213.83,27)
UART2_RXD: length 6.5
  TOP w0.14: U14.BD20 213.13,25.11 v1(213.35,25.33)
  BOTTOM w0.14: v1(213.35,25.33) 213.12,25.1 213.12,23 212.75,22.63 R1008.2 213.2,21.83 213.2,21.3 213.4,21.1 213.4,20.06 R1056.2
UART2_TXD: length 5.7
  TOP w0.102: U14.BE20 213.03,23.44 212.79,23.2 212.79,21.34 212.43,20.98 212.09,20.98 211.8,20.69 211.8,20.48 211.18,19.86 R484.2
UART_WAKE_N: length 211.3
  TOP w0.14: v1(217.67,9.95) 216.87,10.74 R620.2
  IN3 w0.089: v1(217.67,9.95) 217.32,10.3 212.42,10.3 212.25,10.47 208.03,10.47 207.42,9.86 206.48,9.86 206.05,10.28 204.35,10.28 203.71,9.65 199.54,9.65 197.33,11.86 195.63,11.86 195.06,12.43 191.34,12.43 190.64,11.73 189.59,11.73 188.95,12.37 188.95,13.9 185.37,17.48 180.25,17.48 178.23,15.46 176.83,15.46 174.46,17.83 174.46,18.81 174.01,19.26 171.74,19.26 171.55,19.07 166.19,19.07 165.52,18.39 159.96,18.39 158.73,19.63 151.32,19.63 148.71,22.23 144.53,22.23 144.17,21.87 134.08,21.87 131.56,19.36 118.03,19.36 115.78,21.61 115.78,22.22 114.61,23.4 111.43,23.4 110.93,23.9 104.72,23.9 101.19,20.37 101.19,19.29 99.37,17.48 95.8,17.48 95.45,17.83 92.95,17.83 92.62,18.15 91.31,18.15 89.33,16.17 88.56,16.17 88.15,16.58 86.86,16.58 86.47,16.2 84.74,16.2 83.34,17.6 81.54,17.6 80.53,16.58 77.49,16.58 71.85,22.22 71.85,22.69 69.84,24.7 69.84,27.73 67.67,29.9 67.67,29.99 67.36,30.31 66.98,30.31 66.69,30.01 66.69,29.26 66.83,29.11 66.83,29.03 67.05,28.82 67.05,28.06 66.74,27.76 66.13,27.76 65.57,28.31 65.44,28.31 65.06,28.7 64.66,28.7 64.41,28.95 63.39,28.95 62.73,29.61 60.92,29.61 60.7,29.39 59.6,29.39 59.33,29.66 56.86,29.66 54.42,32.11 54.42,32.79 53.05,34.16 49.77,34.16 48.99,34.95 48.09,34.95 47.42,35.61 47.01,35.61 46.65,35.97 46.65,36.49 v1(46.88,36.72)
  BOTTOM w0.14: v1(46.88,36.72) 47.48,36.12 v1(47.5,36.12) 47.69,36.12 48.16,36.58 48.16,37 48.54,37.38 48.84,37.38 48.96,37.5 CN16.20
ULT_EDP_HPD_Q: length 2.4
  TOP w0.14: QG8.2 24.6,90.62 24.49,90.51 RG34.1 22.58,90.51 RG33.1
USB2_COMP: length 8.3
  TOP w0.102: R214.1 198.33,43.01 198.09,43.25 v1(198.09,43.65) 198.71,44.26 200.63,44.26 200.96,43.93 201.94,43.93 202.32,43.56 203.21,43.56 203.3,43.46 203.84,43.46 203.9,43.52 204.47,43.52 U14.F4
USB3_RT_0V9: length 10.7
  TOP w0.203: U15.5 264.81,33.37 265.12,33.06 v1(265.32,33.06) ; v1(264.81,35.98) 264.81,35.57 264.61,35.37 U15.10
  IN1 w0.381: v1(265.32,33.06) 263.87,33.06 263.59,32.78 259.25,32.78 258.77,32.3 258.11,32.3 v1(258.06,32.35)
  BOTTOM w0.381: v1(264.81,35.98) 264.37,35.53 C812.2
  vias: v1(268.37,30.57) v1(269.03,30.62) v1(270.27,35.7) v1(270.27,35.04)
USB3_RT_DCDC_GND:
  vias: v1(265.3,34.05) v1(266.62,38.15) v1(267.25,37.68) v1(267.94,38.15) v1(268.12,34.74)
USB3_RT_DCI_CLK: length 1.6
  TOP w0.14: TP35.1 259.76,29.94 260.24,30.42 U15.32
USB3_RT_DCI_DAT: length 2.3
  TOP w0.14: U15.31 259.84,30.53 258.95,29.63 TP34.1
USB3_RT_I2C_ADR_SEL0: length 3.5
  TOP w0.14: R291.1 257.58,34.98 v1(257.72,34.98) 258.1,34.98 258.51,34.57 U15.23
  BOTTOM w0.14: R883.1 258.19,34.98 v1(257.72,34.98)
USB3_RT_I2C_ADR_SEL1: length 3.1
  TOP w0.14: U15.22 258.51,34.97 258.34,35.14 258.34,35.23 v1(258.01,35.55)
  BOTTOM w0.14: v1(258.01,35.55) 258.09,35.47 R876.1 R865.1
USB3_RT_POWER_EN: length 40.2
  TOP w0.14: U15.4 264.81,32.97 265.16,32.62 265.76,32.62 265.83,32.55 R347.1 R359.2 267.19,32.02 268.29,32.02 269.74,30.57 269.74,28.08 v1(269.56,27.91) ; v1(254.58,11.07) 254.09,10.58 R625.1
  BOTTOM w0.14: v1(269.56,27.91) 269.56,27.6 268.9,26.94 267.63,26.94 265.82,25.12 261.07,25.12 260.67,24.73 260.32,24.73 259.94,24.35 259.94,22.5 259.51,22.06 259.33,22.06 258.64,21.38 257.8,21.38 256.56,20.13 256.56,18.47 255.7,17.61 255.7,13.76 256.18,13.28 256.58,13.28 256.79,13.07 256.79,12.11 255.75,11.07 v1(254.58,11.07)
USB3_RT_PU_PWR: length 19.1
  TOP w0.14: R359.1 267.76,31.54 268.06,31.23 268.06,31.21 268.09,31.18 v1(268.09,31.16)
  IN3 w0.089: v1(259.2,30.93) 259.44,31.17 268.08,31.17 v1(268.09,31.16)
  BOTTOM w0.14: R898.2 268.32,31.36 268.14,31.18 268.12,31.18 v1(268.09,31.16) 267.28,30.34 267.28,29.91 266.74,29.38 R915.2 ; v1(259.2,30.93) 259.49,31.22 R883.2 R876.2
USB3_RT_RX1N: length 3
  TOP w0.165: U15.11 263.44,36.79 264.09,37.45 264.09,38.43 C242.2
USB3_RT_RX1P: length 3
  TOP w0.165: C241.2 263.72,38.46 263.72,37.6 263.04,36.92 U15.12
USB3_RT_SCL: length 2.1
  TOP w0.14: U15.24 258.52,34.17 258.24,34.46 R304.1
USB3_RT_SDA: length 2.4
  TOP w0.14: R349.1 257.08,32.56 257.8,33.29 258.31,33.29 258.39,33.37 U15.26
USB3_RT_SSRXN: length 8.1
  TOP w0.165: v1(260.56,29.28) 260.79,29.28 260.96,29.45 260.96,30.24 261.04,30.32 U15.34
  BOTTOM w0.165: v1(260.56,29.28) 260.8,29.04 260.8,28.9 260.58,28.69 260.09,28.69 259.49,29.29 257.6,29.29 256.99,29.9 256.99,30.19 257.2,30.4 257.52,30.4 257.7,30.22 C834.1
USB3_RT_SSRXP: length 8.2
  TOP w0.165: U15.35 261.44,30.2 261.33,30.08 261.33,29.33 v1(261.41,29.25)
  BOTTOM w0.165: v1(261.41,29.25) 261.23,29.08 261.23,28.82 260.73,28.32 259.94,28.32 259.33,28.92 257.45,28.92 256.62,29.75 256.62,29.98 C835.1
