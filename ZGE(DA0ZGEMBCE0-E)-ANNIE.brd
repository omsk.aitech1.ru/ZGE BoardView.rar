# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 50.46,112.77 50.74,112.77 50.86,112.9 51.04,112.9 51.11,112.83 51.11,112.67 50.69,112.25 50.44,112.25 50.22,112.48 50.21,112.49 50.1,112.65 49.92,112.71 49.78,112.68 49.65,112.57 49.63,112.56 49.49,112.56 49.38,112.67 49.38,112.83 49.44,112.89 49.49,112.89 49.82,113.22 50.02,113.22
GND on TOP (solid shape): 195.8,22.39 195.8,22.12 195.21,21.53 194.93,21.53 194.89,21.54 194.44,21.54 194.4,21.53 194.28,21.53 193.72,20.97 193.69,20.97 193.67,20.98 193.62,21.01 193.57,21.04 193.54,21.06 193.54,21.09 193.12,21.09 193.08,21.11 193.07,21.14 193.07,21.17 192.98,21.25 192.98,22.32 193.13,22.47 195.73,22.47
GND on TOP (solid shape): 13.92,165.43 13.92,164.89 13.96,164.85 13.96,164.56 14.24,164.28 14.24,163.64 14.09,163.49 13.63,163.49 13.28,163.14 12.92,163.14 12.76,163.22 12.59,163.25 12.49,163.24 12.39,163.21 12.36,163.24 12.36,163.64 12.41,163.69 12.79,163.69 12.92,163.82 12.92,164.3 12.93,164.32 12.96,164.37 13.23,164.63 13.23,165.45 13.3,165.52 13.84,165.52
GND on TOP (solid shape): 57.46,110.67 57.74,110.67 57.8,110.73 57.83,110.76 57.86,110.79 58.22,111.15 58.39,111.15 58.72,110.82 58.74,110.78 58.76,110.76 58.76,110.61 58.65,110.49 58.08,110.49 57.74,110.15 57.5,110.15 56.64,111.01 56.42,111.01 56.31,110.9 56.07,110.9 55.69,111.28 55.69,111.41 55.76,111.48 55.94,111.48 56.07,111.36 56.3,111.36 56.45,111.51 56.63,111.51
GND on TOP (solid shape): 179.09,45.58 179.09,44.03 178.97,43.91 178.55,43.91 178.12,43.48 177.16,43.48 176.93,43.7 176.93,44.34 177.01,44.42 177.04,44.43 177.09,44.42 177.12,44.42 177.18,44.43 177.25,44.42 177.53,44.54 177.64,44.81 177.63,44.91 177.59,45 178.28,45.69 178.99,45.69
GND on TOP (solid shape): 190.32,36.71 190.32,33.72 190.19,33.6 189.32,33.6 188.86,34.05 188.31,34.05 187.52,34.83 187.52,35.55 187.53,35.57 187.54,35.6 187.52,35.61 187.52,35.78 187.56,35.86 187.65,35.87 187.71,35.86 187.77,35.85 188.09,36.01 188.15,36.36 188.15,36.61 188.39,36.84 190.18,36.84
GND on TOP (solid shape): 55.21,103.81 55.23,103.8 55.25,103.79 55.47,103.7 55.69,103.79 55.7,103.8 55.72,103.81 56.64,103.81 56.68,103.77 56.69,103.75 56.7,103.73 56.7,103.57 56.27,103.14 56.02,103.14 55.85,103.2 55.68,103.14 55.47,103.14 55.02,103.59 55.02,103.75 55.03,103.77 55.04,103.79 55.06,103.81
GND on TOP (solid shape): 160.53,15.19 160.53,11.96 160.51,11.93 160.51,11.76 160.74,11.53 164.07,11.53 164.24,11.35 164.24,10.65 164.13,10.54 163.46,10.54 163.24,10.32 163.24,9.32 163.26,9.29 163.24,9.25 163.03,9.03 157.24,9.03 157.23,9.04 156.12,9.04 155.93,9.23 155.93,12.59 156.09,12.75 157.26,12.75 157.26,12.75 158.1,12.75 158.27,12.57 158.27,11.12 158.55,10.84 159.19,10.84 159.37,11.02 159.37,11.24 159.37,11.24 159.37,13.82 159.37,13.83 159.37,13.99 158.55,14.8 158.55,15.36 158.73,15.54 160.18,15.54
GND on TOP (solid shape): 46.62,120.23 46.68,120.2 46.75,120.2 46.82,120.2 46.88,120.23 46.89,120.24 47.26,120.24 47.49,120.01 47.54,119.94 47.59,119.88 47.6,119.86 47.61,119.84 47.61,119.66 47.57,119.62 47.55,119.61 47.53,119.6 47.43,119.6 47.27,119.76 46.99,119.76 46.9,119.67 46.86,119.64 46.84,119.62 46.7,119.62 46.68,119.63 46.66,119.64 46.62,119.68 45.92,119.68 45.89,119.71 45.89,119.91 46.22,120.24 46.61,120.24
GND on TOP (solid shape): 73.4,129.27 73.57,129.1 73.81,129.04 74.76,129.04 75.96,129.04 76.14,129.08 76.29,129.17 76.34,129.22 76.41,129.24 76.48,129.21 76.66,129.04 74.74,127.12 73.58,127.12 73.54,127.14 73.53,127.17 73.53,128.52 73.35,128.7 72.93,128.7 72.7,128.92 72.7,129.27
GND on TOP (solid shape): 107.6,60.91 107.63,60.9 107.65,60.86 107.65,59.6 107.63,59.56 107.6,59.55 107.08,59.55 107,59.63 106.81,59.63 106.73,59.67 106.72,59.76 106.74,59.84 106.74,59.91 106.63,60.2 106.36,60.33 106.34,60.34 106.16,60.52 106.16,60.86 106.21,60.91
GND on TOP (solid shape): 204.75,23.74 204.77,23.74 204.87,23.64 204.87,23.49 205.12,23.24 205.12,22.98 205.08,22.94 205.08,22.73 205.08,22.72 205.06,22.61 205.08,22.49 205.08,22.48 205.08,22.26 205.19,22.15 205.19,21.87 205.18,21.85 204.57,21.85 204.51,21.91 203.42,21.91 203.32,22.02 203.31,22.03 203.26,22.16 203.17,22.25 203.15,22.27 203.15,22.29 203.15,23.28 203.15,23.3 203.16,23.32 203.43,23.58 203.43,23.58 203.53,23.69 203.86,23.69 203.98,23.82 204.67,23.82
GND on TOP (solid shape): 55.86,106.77 55.86,106.67 55.93,106.61 55.93,106.6 56.04,106.49 56.2,106.45 56.34,106.48 56.46,106.59 56.69,106.82 56.69,106.92 56.81,107.04 56.99,107.04 57.18,106.86 57.18,106.72 57.42,106.49 57.42,106.33 57.01,105.93 56.77,105.93 56.67,106.03 56.41,106.03 56.31,105.93 56.09,105.93 55.99,106.03 55.73,106.03 55.63,105.93 55.42,105.93 55.01,106.35 55.01,106.55 55.09,106.7 55.44,107.05 55.58,107.05
GND on TOP (solid shape): 109.45,93.67 109.47,93.66 109.48,93.65 109.64,93.55 109.83,93.53 110.49,93.53 110.89,93.13 111.68,93.13 111.98,92.82 111.98,91.55 111.95,91.52 110.25,91.52 109.93,91.2 109.46,91.2 109.44,91.22 109.44,91.86 109.53,91.96 109.8,91.96 109.9,92.06 109.9,92.52 109.72,92.7 109.21,92.7 109.17,92.66 109.15,92.66 109.06,92.62 109.01,92.52 109.01,92.5 108.87,92.36 108.57,92.36 108.46,92.46 108.46,93.41 108.72,93.67
GND on TOP (solid shape): 53.52,120.3 53.54,120.3 53.55,120.29 53.75,120.2 53.95,120.29 53.96,120.3 53.98,120.3 54.14,120.3 54.57,119.87 54.57,119.67 54.52,119.62 54.24,119.62 54.12,119.74 53.99,119.74 53.85,119.6 53.69,119.6 53.58,119.71 53.25,119.71 53.16,119.62 53.14,119.61 53.12,119.61 52.97,119.61 52.88,119.7 52.88,119.79 52.88,119.81 52.9,119.82 52.95,119.88 52.99,119.95 53.34,120.3
GND on TOP (solid shape): 58.41,117.51 58.44,117.5 58.45,117.49 58.65,117.4 58.85,117.49 58.86,117.5 58.89,117.51 59,117.51 59.5,117 59.5,116.89 59.5,116.87 59.49,116.86 59.13,116.5 58.88,116.5 58.4,116.99 58.17,116.99 58.11,116.93 58.11,116.88 58.03,116.81 58.02,116.8 58,116.79 57.86,116.79 57.8,116.86 57.8,117.04 57.8,117.06 57.81,117.08 57.85,117.12 57.88,117.17 58.21,117.51
GND on TOP (solid shape): 106.51,48.19 106.51,47.35 105.51,46.36 105.51,44.55 105.17,44.21 105.14,44.21 105.13,44.21 105.05,44.24 104.97,44.24 104.83,44.22 104.7,44.14 103.8,44.14 103.53,44.4 103.29,44.4 103.04,44.64 103.04,44.86 103.07,44.89 103.07,47.65 103.46,48.04 103.49,48.05 103.52,48.05 103.61,48.01 103.71,48 103.88,48.04 104.02,48.14 104.02,48.15 104.04,48.16 104.07,48.16 104.22,48.31 106.38,48.31
GND on TOP (solid shape): 199.05,55.91 199.05,54.99 199.04,54.96 199.01,54.94 198.63,54.55 199.01,54.16 199.04,54.14 199.05,54.11 199.05,53.64 198.93,53.51 197.5,53.51 197.25,53.76 197.25,56.41 197.26,56.45 197.3,56.46 198.5,56.46
GND on TOP (solid shape): 50.92,52.92 50.92,50.57 50.9,50.55 50.88,50.54 50.74,50.46 50.68,50.31 50.68,50.01 50.68,49.96 50.49,49.78 50.21,49.78 50.11,49.87 50.11,51.8 50.33,52.02 50.33,52.39 50.31,52.41 50.31,52.42 50.18,52.54 50.17,52.55 49.64,52.55 49.64,52.54 49.55,52.54 49.22,52.21 48.63,52.21 48.61,52.19 48.1,52.19 48,52.29 48,52.7 48.22,52.92 48.75,52.92 48.83,52.93 48.9,52.98 49.09,53.17 50.67,53.17
GND on TOP (solid shape): 99.02,46.19 99.67,46.19 99.85,46.01 99.85,44.63 99.8,44.54 99.69,44.54 99.63,44.57 99.56,44.58 99.26,44.58 99.09,44.51 99.02,44.34 99.02,44.25 98.67,43.9 98.42,43.9 98.42,43.95 98.37,44.6 98.23,45.24 98.23,45.25 98.23,46.11 98.28,46.15 98.28,46.15 98.35,46.22 99.02,46.22
GND on TOP (solid shape): 251.28,28.72 251.28,27.8 250.97,27.5 248.96,27.5 248.79,27.32 248.55,27.32 248.52,27.34 248.51,27.34 248.38,27.43 248.23,27.46 248.08,27.43 247.95,27.34 247.94,27.34 247.9,27.32 247.54,27.32 247.46,27.41 247.45,27.44 247.46,27.46 247.51,27.56 247.53,27.68 247.48,27.86 247.36,28 247.35,28.01 247.34,28.03 247.34,28.67 247.49,28.82 251.17,28.82
GND on TOP (solid shape): 161.05,24.43 161.49,24.43 161.56,24.35 161.56,23.92 161.26,23.62 161.26,23.62 160.95,23.31 160.95,23.07 160.8,22.92 160.48,22.92 160.38,22.88 160.34,22.78 160.34,22.65 159.91,22.65 159.62,22.94 159.61,23.02 159.58,23.08 159.58,23.27 159.6,23.28 159.65,23.33 159.66,23.4 159.66,23.78 159.65,23.83 159.62,23.88 159.58,23.92 159.66,23.99 159.78,23.99 159.96,24.17 159.96,24.6 160.09,24.73 160.75,24.73
GND on TOP (solid shape): 176.34,30.14 176.34,27.3 176.31,27.27 176.2,27.27 176.12,27.19 175.78,27.19 175.66,27.31 175.66,28.45 174.68,29.43 172.8,29.43 172.76,29.44 172.74,29.48 172.74,29.5 172.7,29.54 172.68,29.57 172.68,29.61 172.68,29.91 172.7,30 172.68,30.1 172.31,30.47 170.32,30.47 170.26,30.42 170.05,30.42 169.98,30.4 169.9,30.35 169.88,30.34 169.71,30.34 169.48,30.11 169.28,30.11 169.27,30.12 169.27,30.77 169.67,31.17 175.31,31.17
GND on TOP (solid shape): 244.21,13.28 244.32,13.28 244.34,13.26 244.99,13.26 245.56,12.69 245.56,9.34 245.25,9.03 234.54,9.03 234.16,9.41 234.16,10.94 233.98,11.12 233.29,11.12 233.14,11.27 233.14,12.67 233.5,13.02 234.28,13.02 234.59,13.33 238.42,13.33 238.46,13.31 238.47,13.28 238.47,10.7 242.73,10.7 242.73,14.4 241.62,14.4 241.62,13.95 241.6,13.92 241.57,13.9 240.88,13.9 240.85,13.92 240.83,13.95 240.83,14.4 240.79,14.4 240.75,14.42 240.73,14.45 240.73,15.38 240.86,15.51 241.98,15.51
GND on TOP (solid shape): 50.41,102.36 50.41,102.18 49.98,101.75 49.71,101.75 49.65,101.78 49.59,101.8 49.52,101.84 49.5,101.91 49.5,101.92 49.19,102.23 48.89,101.92 48.89,101.91 48.87,101.84 48.8,101.8 48.75,101.78 48.69,101.75 48.43,101.75 47.98,102.2 47.98,102.38 48.02,102.41 50.35,102.41
GND on TOP (solid shape): 18.15,167.35 18.15,163.92 17.98,163.74 17.16,163.74 16.6,164.3 15.97,164.3 15.94,164.33 15.94,164.51 15.99,164.59 16.08,164.6 16.14,164.59 16.2,164.58 16.48,164.7 16.6,164.98 16.59,165.04 16.57,165.12 16.59,165.15 16.63,165.17 16.66,165.17 16.83,165.35 16.83,165.93 16.73,166.03 16.48,166.03 16.33,166.18 16.33,166.34 17.01,167.02 17.01,167.33 17.21,167.53 17.98,167.53
GND on TOP (solid shape): 50.5,103.63 50.71,103.63 50.87,103.79 51.04,103.79 51.12,103.72 51.5,103.72 51.58,103.81 51.73,103.81 51.8,103.73 51.8,103.49 51.37,103.05 51.21,103.05 51.05,103.22 50.83,103.22 50.67,103.06 50.5,103.06 50.46,103.09 50.43,103.13 50.39,103.16 50.32,103.23 50.32,103.35 50.01,103.67 49.77,103.67 49.33,103.23 49.08,103.23 48.7,103.62 48.35,103.62 47.88,103.14 47.76,103.14 47.28,103.63 47.28,103.68 47.28,103.7 47.29,103.72 47.4,103.82 47.47,103.82 47.64,103.65 47.93,103.65 48.19,103.91 48.88,103.91 48.95,103.85 49,103.78 49.08,103.72 49.12,103.68 49.35,103.68 49.66,103.98 50.14,103.98
GND on TOP (solid shape): 223.03,13.12 223.04,13.1 223.02,13.03 223.02,12.97 223.13,12.69 223.45,12.56 223.46,12.53 223.46,11.22 223.45,11.21 223.45,10.6 223.18,10.33 221.91,10.33 221.51,10.74 221.51,11.28 221.54,11.36 221.55,11.45 221.54,11.53 221.51,11.62 221.51,11.94 221.54,12.02 221.55,12.11 221.54,12.19 221.51,12.28 221.51,13.17 221.81,13.48 222.68,13.48
GND on TOP (solid shape): 110.54,103.25 110.56,103.25 110.75,103.06 110.75,101.15 110.39,100.79 105.89,100.79 105.76,100.66 105.7,100.66 105.49,100.46 105.49,98.51 105.34,98.36 103.22,98.36 102.73,98.85 102.73,102.41 103.04,102.73 103.63,102.73 103.95,102.41 103.95,101.22 104.22,100.95 104.77,100.95 104.94,101.12 104.94,101.47 105.51,102.04 105.78,102.04 105.81,102.04 105.85,102.05 106.64,102.05 107.32,102.73 107.32,102.77 107.4,102.85 107.4,103.29 107.58,103.46 107.61,103.47 107.68,103.43 107.7,103.41 107.7,103.38 108.16,103.38 108.16,103.39 108.17,103.42 108.2,103.44 108.23,103.45 108.27,103.48 109.16,103.48 109.52,103.83 109.95,103.83
GND on TOP (solid shape): 94.61,27.85 94.61,27.52 95.24,26.89 95.24,24.3 95.07,24.12 94.68,24.12 94.3,23.74 94.3,23.21 94.2,23.11 93.71,23.11 93.64,23.18 93.64,23.68 93.83,23.87 94,23.87 94.3,24.17 94.3,25.26 94.27,25.29 94.27,25.31 94.24,25.36 94.19,25.4 94.17,25.41 94.14,25.45 94.14,25.47 93.41,25.47 93.38,25.48 93.36,25.52 93.36,25.6 93.38,25.64 93.41,25.65 94.14,25.65 94.14,25.7 94.14,25.71 94.23,25.75 94.27,25.83 94.28,25.85 94.3,25.87 94.3,26.99 93.92,27.37 93.92,27.9 93.99,27.97 94.48,27.97
GND on TOP (solid shape): 17.37,96.95 17.37,96.16 17.34,96.13 17.28,96.12 17.24,96.11 17.04,96.11 16.92,95.99 16.92,95.51 17.06,95.37 17.21,95.37 17.29,95.35 17.65,94.99 17.65,94.81 17.81,94.64 18.47,94.64 18.61,94.5 21.63,94.5 21.69,94.45 21.69,93.64 21.65,93.6 20.71,93.6 20.71,93.59 20.68,93.56 18.87,93.56 18.28,92.98 17.75,92.98 17.62,93.11 17.62,93.36 17.58,93.4 17.58,93.42 17.51,93.55 17.38,93.62 17.36,93.62 17.25,93.74 17.25,93.81 17.09,93.97 17.09,94.17 16.91,94.35 16.5,94.35 16.15,94.7 16.15,96.77 16.38,97 17.32,97
GND on TOP (solid shape): 47.32,114.59 47.6,114.59 47.69,114.68 47.91,114.68 48.21,114.38 48.25,114.33 48.29,114.28 48.3,114.27 48.31,114.24 48.31,114.09 48.23,114.01 48.06,114.01 47.96,114.1 47.65,114.1 47.56,114.01 47.34,114.01 47.26,114.1 46.94,114.1 46.86,114.01 46.68,114.01 46.58,114.11 46.3,114.11 45.81,113.62 45.62,113.62 45.49,113.75 45.49,113.91 45.59,114.01 45.59,114.07 45.6,114.12 45.6,114.15 45.6,114.18 45.59,114.26 45.53,114.33 45.48,114.37 45.48,114.56 45.59,114.67 45.8,114.67 45.93,114.55 46.15,114.55 46.27,114.67 46.53,114.67 46.62,114.59 46.88,114.59 46.99,114.69 47.21,114.69
GND on TOP (solid shape): 276.89,14.7 276.93,14.68 276.94,14.65 276.94,13.85 277.08,13.71 277.74,13.71 277.82,13.63 277.82,12.53 277.79,12.51 277.79,11.54 277.82,11.51 277.82,11.44 277.81,11.43 277.78,11.31 277.77,11.11 277.8,11.02 277.77,10.92 277.77,10.82 277.77,10.77 277.76,10.75 277.75,10.73 277.72,10.7 274.79,10.7 274.77,10.73 274.76,10.75 274.76,13.65 274.84,13.72 276.61,13.72 276.7,13.81 276.7,13.85 276.72,13.88 276.75,13.9 276.77,13.9 276.77,14.65 276.78,14.68 276.82,14.7
GND on TOP (solid shape): 53.84,106.6 53.96,106.49 54.1,106.46 54.24,106.49 54.36,106.59 54.39,106.6 54.47,106.6 54.54,106.53 54.54,106.37 54.53,106.35 54.52,106.33 54.44,106.25 52.28,106.25 52.09,106.44 51.86,106.44 51.68,106.26 50.19,106.26 50.07,106.38 50.07,106.49 50.55,106.97 50.66,106.97 51.19,106.43 51.39,106.43 51.92,106.95 52.05,106.95 52.49,106.52 52.51,106.51 52.6,106.47 52.69,106.45 52.87,106.52 52.98,106.68 52.99,106.69 53.31,107.02 53.42,107.02
GND on TOP (solid shape): 79.98,161.74 80,161.73 80.02,161.72 80.42,161.32 80.42,161.17 80.63,160.96 81.33,160.96 81.51,161.14 82.28,161.14 82.31,161.1 82.31,160.82 82.25,160.76 82.06,160.76 81.83,160.7 81.67,160.54 81.67,160.53 81.22,160.09 81.22,159.89 81.21,159.87 81.1,159.71 81.08,159.52 81.08,159.51 80.94,159.38 80.66,159.38 80.1,159.93 80.1,160.25 80.11,160.29 80.11,160.67 80.07,160.77 79.97,160.81 79.94,160.81 79.67,161.08 79.5,161.08 79.29,161.28 79.29,161.61 79.42,161.74
GND on TOP (solid shape): 191.71,56.72 191.72,56.72 191.74,56.71 191.93,56.52 191.93,56.12 191.72,55.92 191.31,55.92 191.09,55.69 191.09,54.58 191.09,54.44 191.08,54.4 191.04,54.38 190.82,54.38 190.18,55.02 190.18,55.24 190.7,55.75 190.7,56.13 190.9,56.33 190.92,56.34 190.95,56.34 191.01,56.32 191.07,56.32 191.34,56.42 191.48,56.71 191.52,56.72
GND on TOP (solid shape): 47.58,112.91 47.6,112.91 47.71,112.84 47.82,112.82 47.93,112.84 48.04,112.91 48.06,112.91 48.26,112.91 48.28,112.91 48.39,112.84 48.5,112.81 48.61,112.84 48.72,112.91 48.74,112.91 48.95,112.91 49,112.86 49,112.69 49,112.67 48.99,112.66 48.58,112.24 48.31,112.24 48.15,112.3 47.99,112.24 47.77,112.24 47.33,112.69 47.33,112.87 47.36,112.91
GND on TOP (solid shape): 91.85,28.67 91.9,28.64 91.97,28.62 92.02,28.57 92.02,26.86 92.42,26.46 92.42,25.24 92.04,24.86 92.04,23.21 91.94,23.11 91.05,23.11 90.74,23.42 90.72,23.53 90.81,23.59 90.86,23.59 91.04,23.78 91.05,23.78 91.13,23.83 91.15,23.91 91.15,24.12 91.12,24.21 91.04,24.25 91.02,24.28 91.02,24.43 90.92,24.52 90.92,24.62 91.1,24.8 91.11,24.81 91.2,24.89 91.24,25.02 91.24,25.16 91.25,25.18 91.72,25.65 91.72,26.65 91.72,26.67 91.58,26.8 91.58,28.66 91.59,28.67
GND on TOP (solid shape): 54.62,102.4 54.8,102.34 54.99,102.4 55.3,102.4 55.49,102.34 55.68,102.4 55.93,102.4 55.95,102.4 55.97,102.39 56.01,102.35 56.01,102.17 55.98,102.14 55.96,102.12 55.58,101.74 55.32,101.74 55.15,101.8 54.98,101.74 54.62,101.74 54.45,101.8 54.28,101.74 54.03,101.74 53.92,101.85 53.61,101.85 53.49,101.73 53.32,101.73 53.21,101.84 53.21,101.87 52.9,102.18 52.9,102.33 52.98,102.4
GND on TOP (solid shape): 206.47,51.65 206.47,50.89 206.29,50.71 205.89,50.71 205.86,50.74 205.86,50.75 205.73,50.95 205.51,51.03 205.47,51.03 205.42,51.02 204.97,51.02 204.4,50.45 204.39,50.45 204.28,50.37 204.2,50.25 204.19,50.24 204.13,50.18 204.13,49.19 203.98,49.04 203.32,49.04 202.46,49.9 202.46,50.24 202.46,50.27 202.48,50.29 202.7,50.64 202.48,50.99 202.46,51.01 202.46,51.03 202.46,51.4 202.91,51.86 202.91,52.37 203.04,52.49 205.63,52.49
GND on TOP (solid shape): 58.15,151.6 58.15,151.41 58.15,151.39 58.07,151.28 58.04,151.16 58.04,151.14 57.99,151.1 57.97,151.09 57.95,151.09 57.73,151 57.64,150.78 57.73,150.57 57.94,150.48 58.01,150.45 58.04,150.39 58.07,150.28 58.15,150.18 58.15,150.16 58.15,149.96 58.15,149.94 58.14,149.92 58.01,149.79 57.91,149.79 56.97,150.73 56.97,151.17 57.37,151.57 57.69,151.57 57.72,151.62 57.83,151.73 58.02,151.73
GND on TOP (solid shape): 281.47,52.44 281.68,52.4 281.89,52.43 281.98,52.41 282.09,52.4 282.19,52.41 282.29,52.43 282.38,52.41 282.49,52.4 282.59,52.41 282.69,52.43 282.83,52.4 282.98,52.41 282.99,52.41 283.02,52.4 283.05,52.37 283.05,52.33 283.05,52.28 283.05,52.23 283.05,51.93 283.05,51.88 283.05,51.83 283.05,51.53 283.05,51.48 283.05,51.43 283.05,51.13 283.05,51.08 283.05,51.03 283.05,50.73 283.05,50.68 283.05,50.59 283,50.54 281.2,50.54 281.15,50.59 281.15,52.32 281.27,52.44 281.47,52.44
GND on TOP (solid shape): 189.66,30.75 189.66,29.65 189.62,29.61 189.62,27.87 189.6,27.85 189.45,27.85 188.97,28.34 188.97,28.6 188.85,28.87 188.57,28.99 188.5,28.98 188.48,28.99 188.38,29.08 188.38,29.93 188.41,30 188.42,30.07 188.44,30.14 188.42,30.34 188.36,30.45 188.34,30.52 188.36,30.58 188.39,30.61 188.46,30.72 188.49,30.83 188.52,30.97 188.59,31 189.4,31
GND on TOP (solid shape): 62.21,106.71 63.54,106.71 63.79,106.95 63.98,106.95 64.08,106.85 64.08,106.69 63.97,106.58 63.97,106.32 64.1,106.19 64.1,106.06 63.99,105.95 63.81,105.95 63.56,106.21 63.5,106.21 63.5,106.21 62.19,106.21 62.02,106.38 61.93,106.38 61.87,106.4 61.8,106.41 61.74,106.4 61.67,106.38 61.6,106.38 61.44,106.21 59.32,106.21 59.3,106.22 59.17,106.22 59.02,106.37 58.85,106.37 58.41,105.94 58.22,105.94 57.78,106.38 57.78,106.48 57.78,106.5 57.8,106.51 57.85,106.57 57.88,106.63 57.89,106.64 58.01,106.64 58.17,106.48 58.44,106.48 58.9,106.94 59.08,106.94 59.1,106.93 59.11,106.92 59.56,106.47 59.84,106.47 60.34,106.98 60.48,106.98 60.93,106.53 61.28,106.53 61.59,106.85 61.59,106.91 61.72,107.03 61.89,107.03
GND on TOP (solid shape): 18,44.09 18,42.43 17.94,42.37 17.69,42.37 17.66,42.37 17.63,42.36 17.55,42.36 17.51,42.37 17.49,42.37 17.19,42.37 17.1,42.34 17.05,42.27 17.05,42.25 17.02,42.23 16.99,42.23 16.99,41.18 17.07,41.1 17.07,40.97 17.1,40.95 17.1,40.4 17.11,40.31 17.11,40.22 17.07,40.18 16.83,40.18 16.78,40.23 16.78,40.62 16.82,40.72 16.83,40.82 16.8,40.98 16.69,41.13 16.69,41.15 16.69,42.23 16.66,42.23 16.63,42.26 16.62,42.27 16.57,42.34 16.49,42.37 16.26,42.37 16.16,42.47 16.16,42.72 16.15,42.73 16.15,44.03 16.3,44.19 17.9,44.19
GND on TOP (solid shape): 57.57,158.8 80.35,158.8 87.52,158.8 87.52,136.6 108.45,136.6 108.45,136.6 115.35,136.6 115.35,136.6 147.75,136.6 155.35,136.6 173.77,136.6 173.77,96.11 173.77,96.05 173.77,88.38 161.81,88.38 161.81,88.35 154.91,88.35 154.91,88.38 118.81,88.38 111.91,88.38 80.89,88.38 73.99,88.38 73.99,89.6 111.91,89.6 111.91,89.6 118.81,89.6 118.81,89.6 154.91,89.6 154.91,89.65 161.81,89.65 161.81,89.6 172.55,89.6 172.55,90.54 172.13,90.96 172.13,91.42 172.55,91.84 172.55,103.1 172.55,123.05 172.55,135.38 155.35,135.38 155.35,135.38 148.45,135.38 148.45,135.38 115.35,135.38 115.35,135.38 108.45,135.38 108.45,135.38 86.3,135.38 86.3,143.05 86.3,143.05 86.3,149.95 86.3,149.95 86.3,157.58 46.85,157.58 46.85,158.8 55.87,158.8 56.37,159.3 57.07,159.3
GND on TOP (solid shape): 59.18,102.76 59.21,102.74 59.24,102.72 59.38,102.58 59.39,102.56 59.43,102.47 59.5,102.39 59.51,102.37 59.52,102.35 59.52,102.18 59.09,101.75 58.81,101.75 58.65,101.8 58.49,101.75 58.11,101.75 57.95,101.8 57.79,101.75 57.41,101.75 57.25,101.8 57.09,101.75 56.84,101.75 56.39,102.2 56.39,102.38 56.43,102.41 57.31,102.41 57.43,102.29 57.75,102.29 57.87,102.41 58.07,102.41 58.09,102.41 58.21,102.32 58.33,102.3 58.5,102.35 58.61,102.48 58.62,102.49 58.89,102.76
GND on TOP (solid shape): 12.31,55.03 15.47,55.03 15.54,54.96 15.54,54.2 15.28,53.94 14.57,53.94 14.12,53.48 13.88,53.48 13.79,53.53 13.78,53.62 13.79,53.68 13.8,53.74 13.4,54.13 13.01,53.74 13.01,53.69 12.99,53.61 12.92,53.57 12.8,53.54 12.7,53.48 12.03,53.48 11.74,53.78 11.74,53.85 11.7,53.95 11.6,53.99 11.53,53.99 11.07,54.45 11.07,54.46 10.92,54.61 10.92,55.14 11.22,55.44 11.91,55.44
GND on TOP (solid shape): 260.36,54.7 260.54,54.7 260.68,54.85 260.82,54.85 260.95,54.72 261.06,54.72 261.22,54.56 261.22,54.31 261.06,54.15 261.06,53.93 261.24,53.75 261.24,53 261.04,52.8 261.04,52.66 261.22,52.48 261.22,52.33 260.98,52.1 260.98,52.01 260.98,51.99 260.97,51.98 260.82,51.83 260.72,51.83 260.48,52.06 260.48,52.17 260.23,52.42 260.01,52.42 259.84,52.24 259.73,52.24 259.49,52.48 259.49,53.06 259.52,53.08 259.53,53.09 259.69,53.19 259.75,53.37 259.67,53.58 259.46,53.66 259.41,53.66 259.37,53.67 259.35,53.71 259.35,53.8 259.22,53.93 259.22,54.07 259.54,54.39 259.55,54.39 259.67,54.46 259.74,54.58 259.74,54.59 260.05,54.9 260.16,54.9
GND on TOP (solid shape): 99.28,42.41 99.28,41.95 98.93,41.6 98.93,40.05 99.28,39.69 99.28,39.59 99.41,39.46 99.41,35.45 99.15,35.2 99.15,35.07 98.82,34.74 98.82,33.98 98.85,33.95 98.85,33.6 98.78,33.52 98.14,33.52 97.38,34.28 97.38,34.81 97.52,34.95 97.52,35.7 97.1,36.12 96.19,36.12 96.11,36.2 96.11,36.41 96.13,36.45 96.16,36.46 97.41,36.46 97.44,36.49 97.88,36.49 97.91,36.52 97.94,36.53 97.98,36.53 98.07,36.48 98.18,36.47 98.46,36.59 98.57,36.86 98.52,37.07 98.35,37.23 98.34,37.25 98.34,38.83 98.93,39.41 98.93,39.77 98.7,40 98.44,40 98.24,40.2 98.24,41.09 98.05,41.29 98.05,41.71 98.47,42.13 98.47,42.31 98.65,42.49 99.21,42.49
GND on TOP (solid shape): 262.52,35.5 262.77,35.37 263.04,35.33 263.14,35.33 263.24,35.35 263.34,35.33 263.51,35.3 263.54,35.22 263.54,31.77 263.49,31.71 263.45,31.71 263.44,31.71 263.25,31.79 263.04,31.81 262.94,31.81 262.84,31.79 262.74,31.81 262.64,31.81 262.42,31.78 262.21,31.7 262.2,31.69 261.88,31.69 261.87,31.7 261.66,31.78 261.44,31.81 261.34,31.81 261.24,31.79 261.14,31.81 261.04,31.81 260.81,31.78 260.6,31.69 259.81,31.69 259.73,31.77 259.73,33.63 259.75,33.64 259.75,33.93 259.73,33.95 259.73,35.12 259.78,35.17 259.87,35.3 259.91,35.45 259.93,35.49 259.96,35.5
GND on TOP (solid shape): 151.61,31.28 151.62,31.25 151.62,31.22 151.56,31.11 151.55,30.99 151.56,30.87 151.62,30.76 151.6,30.74 151.6,26.84 151.57,26.76 151.57,26.69 151.57,26.63 151.58,26.57 151.58,25.21 151.59,25.16 151.6,25.06 151.61,24.98 151.65,24.91 151.68,24.84 151.65,24.77 151.5,24.63 151.5,24.22 151.38,24.1 151.38,23.38 151.53,23.23 151.53,21.63 151.6,21.56 151.6,19.4 151.91,19.09 152.88,19.09 153.28,19.5 153.28,20.06 153.78,20.55 154.67,20.55 154.76,20.46 154.76,18.61 154.45,18.3 154.45,16.55 154.2,16.3 149.88,16.3 149.75,16.42 149.75,17.57 149.6,17.72 147.1,17.72 146.36,18.46 146.36,20.89 147.15,21.68 148.56,21.68 149.83,22.95 149.83,23.52 149.92,23.77 149.83,24.02 149.83,25.26 149.35,25.75 149.35,26.61 149.83,27.09 149.83,30.52 149.5,30.85 149.5,31.33 149.7,31.54 151.35,31.54
GND on TOP (solid shape): 89.23,92.78 89.23,90.72 88.58,90.07 76.88,90.07 76.64,90.31 76.64,91.16 76.65,91.2 76.69,91.21 78.95,91.21 79.03,91.17 79.05,91.08 79.03,91.01 79.02,90.95 79.14,90.67 79.42,90.55 79.69,90.67 79.81,90.94 79.84,91.01 80.17,91.16 80.27,91.43 80.16,91.71 79.88,91.83 79.83,91.82 79.78,91.81 79.76,91.82 79.73,91.85 76.69,91.85 76.65,91.87 76.64,91.9 76.64,92.03 76.5,92.17 76.5,93.04 76.56,93.11 88.9,93.11
GND on TOP (solid shape): 61.73,21 61.73,20.52 61.73,20.5 61.61,20.35 61.58,20.18 61.68,19.92 61.94,19.79 62.01,19.76 62.03,19.69 62.06,19.56 62.13,19.45 62.2,19.45 62.21,19.44 62.32,19.38 62.45,19.36 62.58,19.38 62.7,19.45 63.24,19.45 63.69,19 65.04,19 65.17,18.86 65.17,18.5 65.16,18.49 65.16,18.12 64.87,17.83 64.77,17.83 64.71,17.82 64.64,17.8 64.28,17.8 64.2,17.87 63.34,17.87 62.99,18.22 62.99,18.24 62.95,18.3 62.89,18.34 62.87,18.34 62.83,18.38 61.49,18.38 61.18,18.69 61.18,19.91 61.27,20.16 61.18,20.41 61.18,21.02 61.23,21.07 61.66,21.07
GND on TOP (solid shape): 145.49,107.56 145.52,107.49 145.49,107.42 145.39,107.16 145.5,106.91 145.54,106.83 145.51,106.76 145.39,106.48 145.54,106.22 145.55,106.17 145.53,106.13 145.39,105.85 145.54,105.57 145.54,105.51 145.51,105.46 145.43,105.36 145.4,105.23 145.39,105.1 145.43,104.98 145.44,104.97 145.44,104.82 145.52,104.73 145.85,104.73 146.01,104.58 146.01,104.39 145.82,104.2 145.82,103.86 145.6,103.64 145.26,103.64 145.01,103.89 145.01,104.1 145.18,104.26 145.18,105.77 145.13,105.82 145.13,106.94 144.99,107.08 144.99,107.58 145.09,107.68 145.37,107.68
GND on TOP (solid shape): 256.61,35.73 256.61,34.94 256.59,34.89 256.55,34.85 256.16,34.85 255.99,34.78 255.92,34.61 255.92,34.54 255.72,34.34 255.71,34.34 255.49,34.2 255.4,33.96 255.51,33.68 255.79,33.56 256.04,33.65 256.18,33.87 256.18,33.89 256.36,34.07 256.55,34.07 256.59,34.03 256.61,33.98 256.61,33.37 256.01,32.77 255.99,32.75 255.9,32.66 255.14,32.66 254.83,32.96 254.83,34.59 255.6,35.35 255.64,35.36 255.92,35.48 256.04,35.75 256.05,35.8 256.08,35.83 256.51,35.83
GND on TOP (solid shape): 48.71,105.52 48.71,105.48 48.93,105.25 48.98,105.18 49.07,105.11 49.1,105.11 49.2,105.09 49.3,105.11 49.3,105.11 49.4,105.11 49.85,105.57 50,105.57 50.08,105.48 50.41,105.48 50.5,105.58 50.71,105.58 50.84,105.44 51.05,105.44 51.18,105.57 51.2,105.58 51.22,105.59 51.35,105.59 51.72,105.22 51.76,105.17 51.8,105.12 51.81,105.11 51.82,105.08 51.82,104.98 51.74,104.9 51.57,104.9 51.42,105.05 51.2,105.05 51.02,104.87 50.86,104.87 50.73,105 50.42,105 49.98,104.56 49.8,104.56 49.72,104.64 49.41,104.64 49.31,104.54 49.06,104.54 48.71,104.89 47.99,104.89 47.91,104.97 47.6,104.97 47.17,104.54 47.03,104.54 46.51,105.06 46.28,105.06 46.12,104.9 45.94,104.9 45.88,104.95 45.87,104.97 45.87,104.98 45.87,105.17 46.28,105.57 46.51,105.57 46.53,105.57 46.54,105.56 46.64,105.46 47.01,105.46 47.07,105.52 47.22,105.52 47.32,105.43 47.54,105.43 47.74,105.62 47.9,105.62 48.02,105.5 48.2,105.5 48.3,105.5 48.44,105.64 48.59,105.64
GND on TOP (solid shape): 77.74,169.27 77.28,168.14 78.25,167.39 79.25,167.39 79.5,167.15 79.5,165.32 79.14,164.97 78.46,164.97 77.21,166.22 76.18,166.22 75.69,166.71 73.1,166.71 71.57,168.24 70.72,168.07 69.89,168.32 69.7,168.32 69.58,168.44 69.58,169.17 69.74,169.33 70.24,169.33 71.34,169.3 71.31,170.4 71.31,178.29 77.74,178.29
GND on TOP (solid shape): 84.93,37.71 84.93,37.3 84.94,37.26 84.96,37.22 84.96,37.19 84.97,37.18 84.97,37.09 85.25,36.8 85.25,36.24 85.14,36.13 84.69,36.13 84.61,36.18 84.61,36.29 84.65,36.38 84.66,36.49 84.27,36.88 83.88,36.49 83.89,36.38 83.93,36.29 83.93,36.18 83.85,36.13 83.5,36.13 83.21,36.43 83.21,37.33 83.29,37.41 83.74,37.41 83.96,37.2 84,37.2 84.09,37.17 84.18,37.16 84.46,37.27 84.57,37.55 84.57,37.62 84.55,37.68 84.56,37.78 84.64,37.82 84.82,37.82
GND on TOP (solid shape): 128.66,33.38 128.66,33.29 128.66,33.26 128.67,33.23 128.67,31.51 128.57,31.41 127.2,31.41 126.57,30.79 125.76,30.79 122.97,27.99 121.85,27.99 121.83,27.97 121.82,27.97 121.75,27.92 121.7,27.85 121.68,27.78 121.68,27.75 121.68,27.47 121.68,27.44 121.68,27.4 121.68,27.09 121.48,26.89 121.02,26.89 120.9,27.02 120.9,27.17 120.9,27.19 121.04,27.35 121.09,27.53 121.05,27.71 120.91,27.87 120.9,27.89 120.9,28.83 120.9,28.85 119.37,30.37 119.36,30.37 119.33,30.4 116.17,30.4 115.45,31.12 115.42,31.2 115.47,31.28 115.6,31.42 115.65,31.61 115.54,31.89 115.26,32.01 115.2,32 115.12,32.02 115.08,32.1 115.08,33.19 115.26,33.37 127.12,33.37 127.42,33.67 128.37,33.67
GND on TOP (solid shape): 58.85,48.15 60.21,48.15 60.9,47.46 60.9,44.73 60.63,44.46 59.49,44.46 59.41,44.54 59.37,44.54 59.34,44.55 59.32,44.59 59.34,44.66 59.34,44.72 58.95,45.11 58.55,44.72 58.58,44.57 58.67,44.44 58.7,44.37 58.68,44.3 58.6,44.17 58.58,44.03 58.62,43.85 58.76,43.69 58.77,43.67 58.77,41.23 59.16,40.83 59.16,40.52 59.02,40.38 58.24,40.38 58.15,40.46 58.14,40.49 58.15,40.52 58.21,40.7 58.23,40.88 58.17,41.2 57.99,41.47 57.96,41.5 57.96,41.7 57.56,42.1 57.25,42.41 57.14,42.5 57.02,42.57 57,42.59 56.99,42.62 56.99,48.3 57.19,48.51 58.49,48.51
GND on TOP (solid shape): 95.62,71.87 95.62,70.33 95.63,70.25 95.68,70.18 96.03,69.83 96.03,69.76 95.99,69.73 96.26,69.46 96.26,68.43 96.23,68.35 96.15,68.32 96.12,68.33 95.84,68.21 95.72,67.93 95.73,67.84 95.76,67.75 95.77,67.74 95.77,64.14 95.65,64.02 95.12,64.02 94.75,64.39 94.75,66.85 94.47,67.14 94.46,67.15 94.43,67.26 94.37,67.35 94.39,67.41 94.39,67.48 94.28,67.76 94,67.87 93.83,67.84 93.7,67.73 93.62,67.7 93.55,67.73 93.39,67.89 93.39,68.37 94.2,69.18 94.68,69.18 94.78,69.28 94.83,69.32 94.89,69.38 94.9,69.45 94.9,69.49 94.9,69.92 95.08,70.06 95.14,70.28 95.12,70.4 95.07,70.51 95.07,70.78 94.91,70.93 94.91,71.7 95.1,71.88 95.6,71.88
GND on TOP (solid shape): outline of 108 points within 35.2,14.34 41.08,20.16
GND on TOP (solid shape): 47.61,110.72 47.61,110.59 47.49,110.47 47.48,110.46 47.46,110.46 47.41,110.46 47.39,110.46 47.37,110.47 47.2,110.64 46.99,110.64 46.57,110.22 46.57,110.15 46.57,110.14 46.51,110.04 46.5,109.95 46.51,109.86 46.56,109.78 46.57,109.76 46.57,109.75 46.59,109.75 46.6,109.74 46.75,109.7 46.9,109.74 46.91,109.75 46.94,109.75 46.98,109.78 47.12,109.78 47.14,109.78 47.16,109.77 47.53,109.4 47.56,109.36 47.59,109.33 47.6,109.31 47.61,109.29 47.61,109.16 47.55,109.1 46.59,109.1 46.57,109.12 46.03,109.12 46.01,109.12 45.99,109.13 45.94,109.18 45.94,109.41 45.97,109.46 45.99,109.54 46.18,109.73 46.19,109.74 46.27,109.83 46.3,109.95 46.29,110.04 46.22,110.14 46.22,110.16 46.22,110.24 45.86,110.6 45.84,110.64 45.86,110.67 45.99,110.81 46.18,110.81 46.23,110.77 46.29,110.74 46.34,110.69 46.39,110.69 46.44,110.73 46.45,110.74 46.6,110.82 46.68,110.97 46.68,110.98 46.8,111.1 46.82,111.1 46.89,111.14 46.95,111.19 46.97,111.21 46.99,111.21 47.12,111.21
GND on TOP (solid shape): 78.01,18.53 78.04,18.52 78.08,18.49 78.13,18.48 78.18,18.48 78.23,18.43 78.23,18.25 78.29,18.19 78.29,18.17 78.68,17.81 79.08,18.17 79.08,18.19 79.33,18.44 79.66,18.44 79.67,18.43 79.83,18.43 79.93,18.33 79.93,18.1 79.85,18.03 79.85,17.96 79.82,17.87 79.81,17.79 79.82,17.71 79.85,17.62 79.85,17.39 79.83,17.35 79.83,17.31 79.83,17.11 79.83,17.07 79.85,17.03 79.85,16.96 79.62,16.73 67.84,16.73 67.71,16.86 67.71,17.22 67.74,17.6 67.42,17.83 67.4,17.83 67.35,17.88 67.35,18.46 67.41,18.51 68.29,18.51 68.47,18.33 68.47,18.28 68.78,17.97 68.84,17.97 68.85,17.97 69.06,17.91 69.27,17.97 69.51,17.97 69.9,17.59 76.57,17.59 77.08,18.1 77.11,18.1 77.49,18.48 77.54,18.48 77.59,18.49 77.63,18.52 77.66,18.53 77.69,18.53 77.71,18.52 77.73,18.52 77.94,18.52 77.96,18.52 77.98,18.53
GND on TOP (solid shape): 171.85,60.05 174.14,60.05 174.51,60.41 175.06,60.41 175.25,60.21 175.25,59.38 175.17,59.19 175.14,58.98 175.14,56.27 174.9,56.03 174.21,56.03 174.15,56.01 174.09,56.04 173.97,56.11 173.83,56.14 173.55,56.02 173.44,55.74 173.44,55.7 173.44,55.67 173.42,55.58 173.34,55.55 173.03,55.55 172.85,55.73 172.85,56.08 173.02,56.24 173.02,59.51 172.94,59.59 155.41,59.59 155.38,59.6 155.36,59.64 155.36,59.84 155.75,60.23 159.68,60.23 159.84,60.06 161.41,60.06 161.58,60.23 165.64,60.23 166.36,60.95 166.36,62.83 166.06,63.14 139.74,63.14 138.6,64.28 131.36,64.28 130.68,64.96 125.32,64.96 124.5,64.15 113.08,64.15 113.01,64.19 112.98,64.26 112.99,64.3 112.59,64.7 112.2,64.3 112.2,64.26 112.17,64.19 112.1,64.15 110.71,64.15 110.56,64.3 110.56,64.67 113.19,67.3 164.59,67.3
GND on TOP (solid shape): 232.65,48.86 232.73,48.85 232.82,48.86 232.9,48.89 233.24,48.89 234.21,47.92 234.21,47.46 234,47.26 231.21,47.26 231.08,47.39 229.68,47.39 227.61,45.33 227.15,45.33 227.13,45.31 227.11,45.31 226.95,45.15 226.95,45.12 226.93,45.11 226.93,43.98 226.9,43.95 226.83,44.01 226.74,44.04 226.7,44.06 226.69,44.09 226.69,44.13 226.7,44.14 226.73,44.42 226.55,44.64 226.5,44.68 226.5,44.73 226.51,44.76 226.51,44.8 226.51,44.85 226.49,44.93 226.49,45.05 226.4,45.14 226.25,45.14 226.22,45.14 226.21,45.17 226.16,45.24 226.11,45.31 225.64,45.78 225.64,46.15 225.83,46.34 225.85,46.35 225.87,46.35 225.97,46.33 226.04,46.33 226.39,46.33 226.98,46.92 227.93,46.92 228.17,47.15 228.76,47.15 229.76,48.15 229.98,48.15 229.99,48.14 230.09,48.11 230.19,48.1 230.29,48.11 230.38,48.14 230.39,48.15 230.43,48.15 230.44,48.14 230.54,48.11 230.64,48.1 230.74,48.11 230.83,48.14 230.84,48.15 231.09,48.15 231.6,48.13 231.81,48.59 231.8,48.6 231.81,48.62 232.07,48.89 232.56,48.89
GND on TOP (solid shape): outline of 90 points within 97.69,48.4 104.12,57.79
GND on TOP (solid shape): outline of 91 points within 130.73,26.73 165.96,35.22
GND on TOP (solid shape): 218.97,44.81 219,44.86 219.06,44.86 219.34,44.57 219.39,44.48 219.44,44.41 219.5,44.35 219.5,44.3 219.49,44.29 219.45,44.09 219.5,43.89 219.51,43.87 219.51,43.84 219.5,43.82 219.43,43.75 219.42,43.74 219.4,43.74 218.76,43.74 218.56,43.54 218.47,43.51 218.39,43.57 218.23,43.77 217.99,43.84 217.32,43.84 217.28,43.85 217.27,43.89 217.26,43.93 217.24,44 217.25,44.03 217.41,44.14 217.46,44.29 217.46,44.34 217.45,44.42 217.41,44.49 217.39,44.55 217.42,44.62 217.55,44.75 217.79,44.75 218.12,44.43 218.12,44.42 218.19,44.35 218.29,44.33 218.42,44.38 218.49,44.51 218.49,44.53 218.5,44.54 218.54,44.56 218.62,44.54 218.71,44.47 218.79,44.46 218.93,44.52 218.99,44.66 218.99,44.71 218.99,44.75
GND on TOP (solid shape): 102.63,34.64 104.82,34.64 105.48,33.98 106.18,33.98 106.4,33.75 106.4,31.96 106.36,31.86 106.34,31.75 106.46,31.47 106.74,31.36 107.01,31.47 107.13,31.75 107.11,31.86 107.07,31.96 107.07,32.97 107.25,33.15 108.07,33.15 108.41,33.49 108.41,33.78 108.56,33.92 109.29,33.92 110.31,33.92 110.43,33.8 110.43,33.6 110.09,33.27 109.29,33.27 108.19,32.16 108.19,31.96 108.14,31.86 108.12,31.75 108.24,31.47 108.52,31.36 108.8,31.47 108.91,31.75 108.9,31.82 108.89,31.89 108.88,31.92 109.56,32.6 110.36,32.6 111.04,33.28 111.64,33.28 111.66,33.27 111.72,33.24 111.79,33.23 112.09,33.23 112.26,33.3 112.33,33.47 112.33,33.6 112.57,33.85 113.41,33.85 113.5,33.75 113.5,32.62 113.3,32.43 113.16,32.43 113.07,32.52 112.31,32.52 111.55,31.75 111.55,29.68 111.13,29.26 110.94,29.07 102.44,29.07 102.23,29.27 102.22,29.29 102.22,29.32 102.23,29.38 102.24,29.43 102.23,29.51 102.2,29.6 102.2,30.65 101.69,31.16 101.69,32.3 101.52,32.48 101.52,34.03 101.75,34.26 101.75,34.99 101.85,35.09 102.18,35.09
GND on TOP (solid shape): outline of 100 points within 45.88,116.41 54.61,117.5
GND on TOP (solid shape): outline of 150 points within 6.72,156.05 22.49,159.68
GND on TOP (solid shape): 278.2,8.52 280.69,7.49 281.72,5 281.72,1.52 285.16,1.52 286.02,2.39 286.02,4.01 286.59,4.58 286.78,4.58 286.69,4.84 286.64,5.11 287.1,5.11 287.72,5.73 287.67,5.11 288,4.58 288.31,4.4 288.65,4.34 297.69,4.34 297.69,2 297.26,0.94 296.2,0.51 281.2,0.51 280.85,0.65 280.71,1 280.71,5 279.97,6.77 278.2,7.51 195.12,7.51 195.75,7.87 196.06,8.52
GND on TOP (solid shape): 73.66,43.56 73.69,43.48 73.64,43.4 73.51,43.26 73.46,43.07 73.58,42.79 73.86,42.68 73.9,42.68 73.95,42.69 74.03,42.67 74.07,42.59 74.07,42.38 74.36,42.09 74.36,41.16 74.92,40.61 74.92,40.04 74.88,39.96 74.8,39.94 74.74,39.95 74.69,39.95 74.3,39.56 74.69,39.16 74.84,39.19 74.97,39.27 75.04,39.3 75.11,39.27 75.16,39.22 75.23,39.19 75.25,39.17 75.26,39.14 75.26,38.58 75.2,38.52 74.78,38.52 74.49,38.81 73.67,38.81 73.6,38.88 73.6,39.2 73.69,39.29 73.69,39.86 74.05,40.21 74.05,40.48 74.05,40.52 74.03,40.57 74.03,40.76 73.7,41.09 73.02,41.09 72.8,41.16 72.57,41.09 72.34,41.09 72.12,41.16 71.89,41.09 71.69,41.09 71.45,41.17 71.21,41.09 70.4,41.09 70.07,41.42 70.07,42.16 70.3,42.38 70.4,42.38 70.5,42.37 70.61,42.38 71.15,42.38 71.37,42.6 71.37,43.48 71.65,43.76 73.46,43.76
GND on TOP (solid shape): 178.46,58.13 178.48,58.13 178.54,58.08 178.6,58.07 179.18,58.07 179.44,57.8 179.45,57.79 179.48,57.63 179.55,57.52 179.55,56.12 179.51,56.07 179.49,56.02 179.41,55.96 179.31,55.99 179.17,56.11 179,56.15 178.87,56.12 178.75,56.05 178.68,56.03 178.62,56.06 178.49,56.13 178.35,56.16 177.96,55.76 178.35,55.37 178.49,55.39 178.6,55.46 178.67,55.49 178.74,55.46 178.86,55.38 179,55.36 179.22,55.42 179.37,55.6 179.45,55.67 179.54,55.63 179.66,55.53 179.8,55.48 180.42,54.86 181.12,54.86 181.28,54.69 181.28,54.2 181.28,54.18 181.27,54.16 181.22,54.11 181.18,54.05 181.16,54.02 181.15,53.97 181,53.83 179.51,53.83 179.39,53.94 179.39,54.42 179.39,54.43 179.32,54.57 179.18,54.64 179.16,54.65 178.84,54.65 178.82,54.64 178.71,54.59 178.63,54.5 178.61,54.48 178.59,54.47 177.56,54.47 176.67,55.36 176.67,57.95 176.85,58.13
GND on TOP (solid shape): outline of 102 points within 140.72,124.29 148.99,135.14
GND on TOP (solid shape): 67.09,113.18 67.1,113.12 67.19,112.91 67.41,112.82 67.44,112.82 67.48,112.81 67.5,112.77 67.5,112.76 67.44,112.71 67.4,112.71 67.1,112.4 67.4,112.1 67.6,112.17 67.7,112.35 67.82,112.47 67.82,112.4 67.82,112.37 67.85,112.24 67.93,112.13 67.97,112.04 67.92,111.96 67.8,111.85 67.76,111.7 67.85,111.48 68.07,111.39 68.1,111.39 68.2,111.28 68.21,111.27 68.25,111.2 68.31,111.14 68.21,111.04 67.69,111.04 67.59,111.21 67.4,111.29 67.33,111.31 67.3,111.38 67.23,111.53 67.08,111.6 67.06,111.6 67.02,111.64 67.02,111.66 67.02,111.69 66.93,111.9 66.66,112.02 66.63,112.09 66.63,112.76 66.68,112.81 66.9,112.9 66.99,113.11 66.99,113.14 67,113.18 67.04,113.2
GND on TOP (solid shape): 68.88,114.89 68.9,114.86 68.9,114.85 68.96,114.68 69.11,114.6 69.13,114.6 69.37,114.32 69.77,114.13 69.78,114.1 69.78,114.02 69.79,113.93 69.83,113.85 69.84,113.76 69.78,113.69 69.65,113.61 69.6,113.46 69.58,113.42 69.54,113.41 69.51,113.41 69.44,113.43 69.4,113.49 69.32,113.64 69.18,113.7 69.16,113.7 69.13,113.73 69.12,113.75 69.12,113.81 68.88,114.11 68.54,113.94 68.43,113.84 67.23,113.84 67.11,113.72 66.52,113.72 66.25,113.99 66.25,114.31 66.3,114.37 66.39,114.4 66.46,114.34 66.72,114.18 66.99,114.33 67.01,114.35 67.03,114.36 67.24,114.37 67.64,114.61 67.72,114.6 67.79,114.56 67.81,114.48 67.81,114.45 68.11,114.14 68.42,114.45 68.42,114.52 68.48,114.6 68.5,114.6 68.64,114.68 68.7,114.82 68.74,114.88 68.81,114.91
GND on TOP (solid shape): 55.83,125.57 55.92,125.53 56.02,125.44 56.16,125.41 56.21,125.41 56.24,125.41 56.26,125.4 56.29,125.37 56.3,125.33 56.28,125.29 56.23,125.28 56.2,125.29 56.16,125.29 55.86,124.99 56.16,124.68 56.22,124.68 56.24,124.67 56.3,124.62 56.3,124.61 56.37,124.47 56.49,124.4 56.55,124.36 56.57,124.3 56.57,124.23 56.54,124.2 56.52,124.2 56.37,124.13 56.3,123.97 56.26,123.9 56.19,123.88 56.05,123.84 55.94,123.74 55.86,123.7 55.78,123.73 55.67,123.82 55.54,123.85 55.5,123.84 55.48,123.85 55.42,123.91 55.41,123.93 55.42,123.99 55.46,124 55.5,124 55.8,124.31 55.48,124.61 55.46,124.61 55.44,124.62 55.4,124.66 55.4,124.68 55.32,124.84 55.15,124.9 55.08,124.93 55.06,125.03 55.07,125.05 55.12,125.1 55.15,125.1 55.31,125.16 55.44,125.37 55.5,125.39 55.64,125.43 55.75,125.52
GND on TOP (solid shape): 67.37,109.29 67.47,109.26 67.49,109.24 67.5,109.22 67.57,109.07 67.72,109 67.75,108.98 67.76,108.94 67.76,108.9 67.74,108.83 67.69,108.8 67.56,108.72 67.5,108.59 67.48,108.55 67.44,108.54 67.4,108.55 67.18,108.03 67.7,108.24 67.72,108.28 67.75,108.3 67.77,108.3 67.81,108.28 67.82,108.24 67.82,108.18 67.84,108.06 67.92,107.96 67.95,107.88 67.91,107.8 67.83,107.69 67.8,107.56 67.8,107.52 67.79,107.44 67.72,107.4 67.57,107.33 67.5,107.19 67.5,107.17 67.45,107.13 67.44,107.12 67.39,107.12 67.33,107.14 67.3,107.2 67.22,107.34 67.08,107.4 67.06,107.4 67.02,107.44 67.01,107.46 67.01,107.5 66.92,107.71 66.7,107.8 66.56,107.77 66.45,107.67 66.43,107.65 66.38,107.63 66.34,107.63 66.19,107.63 65.79,108.03 65.79,108.28 65.9,108.39 66.09,108.39 66.19,108.28 66.47,108.28 66.81,108.63 66.95,108.73 67.01,108.9 67.03,108.97 67.09,109 67.23,109.07 67.3,109.21
GND on TOP (solid shape): outline of 84 points within 120.58,123.22 123.66,126.7
GND on TOP (solid shape): outline of 86 points within 69.83,115.72 72.33,117.75
GND on TOP (solid shape): outline of 87 points within 46.72,124.59 48.86,127.68
GND on TOP (solid shape): outline of 87 points within 38.74,127.54 41.92,129.99
GND on TOP (solid shape): outline of 92 points within 53.94,125.84 56.73,130.94
GND on TOP (solid shape): outline of 90 points within 46.69,122.35 48.89,124.76
GND on TOP (solid shape): outline of 136 points within 108.25,46.48 128.57,49.25
GND on TOP (solid shape): outline of 85 points within 68.28,107.12 70.88,109.41
GND on TOP (solid shape): outline of 159 points within 45.87,115.19 60.22,116.14
GND on TOP (solid shape): outline of 90 points within 40.37,124.58 42.58,127.45
GND on TOP (solid shape): outline of 242 points within 108.37,53.38 120.25,60.91
GND on TOP (solid shape): outline of 101 points within 38.08,119.68 41.45,121.9
GND on TOP (solid shape): outline of 109 points within 66.24,109.2 69.64,111.38
GND on TOP (solid shape): outline of 241 points within 50.18,124.47 52.41,127.39
GND on TOP (solid shape): outline of 98 points within 122.56,117.76 125.17,122.82
GND on TOP (solid shape): outline of 288 points within 178.45,31.95 186.35,40.75
GND on TOP (solid shape): outline of 109 points within 68.22,110.51 71.29,112.8
GND on TOP (solid shape): outline of 163 points within 52.88,96.49 62.35,99.64
GND on TOP (solid shape): outline of 105 points within 66.18,115.5 69.82,117.02
GND on TOP (solid shape): outline of 191 points within 48.71,112.2 60.2,114.72
GND on TOP (solid shape): outline of 176 points within 52.18,104.46 64.1,105.63
GND on TOP (solid shape): outline of 101 points within 66.17,104.97 71.83,106.51
GND on TOP (solid shape): outline of 114 points within 68.75,121.82 72.33,124.05
GND on TOP (solid shape): outline of 115 points within 48.31,122.46 50.86,127.52
GND on TOP (solid shape): outline of 133 points within 38.36,110.61 42.58,112.79
GND on TOP (solid shape): outline of 135 points within 58.59,124.43 61.51,128.39
GND on TOP (solid shape): outline of 127 points within 38.31,125.31 40.59,129
GND on TOP (solid shape): outline of 172 points within 38.1,112.93 43.36,116.98
GND on TOP (solid shape): outline of 265 points within 146.5,42.62 179.16,52.37
GND on TOP (solid shape): outline of 188 points within 51.44,122.38 54.5,127.32
GND on TOP (solid shape): outline of 486 points within 59.8,122.47 63.59,127.53
GND on TOP (solid shape): outline of 236 points within 35.11,123.89 40.66,129.99
GND on TOP (solid shape): outline of 229 points within 0.51,7.51 194.57,178.29
GND on TOP (solid shape): outline of 629 points within 182.18,39.39 185.87,50.92
GND on TOP (solid shape): outline of 208 points within 38.31,115.45 43.38,119.79
GND on TOP (solid shape): outline of 333 points within 44.47,93.69 66.87,96.84
GND on TOP (solid shape): outline of 268 points within 33.6,108.36 40.63,112.26
GND on TOP (solid shape): outline of 226 points within 56.3,122.46 59.36,130.94
GND on TOP (solid shape): outline of 950 points within 94.35,13.09 299.18,178.29
GND on TOP (solid shape): outline of 388 points within 137.07,104.04 144.38,113.57
GND on TOP (solid shape): outline of 328 points within 63.47,121.13 68.04,127.69
GND on TOP (solid shape): outline of 967 points within 98.29,61.84 176.58,79.63
GND on TOP (solid shape): outline of 314 points within 40.94,121.14 46.93,127.53
GND on TOP (solid shape): outline of 1013 points within 155.51,116.19 161.33,130.79
GND on TOP (solid shape): outline of 1062 points within 67.23,96.61 89.22,104.54
GND on TOP (solid shape): outline of 1532 points within 35.78,96.4 43.73,109.29
GND on TOP (solid shape): outline of 1420 points within 67.49,116.65 76.76,127.92
GND on TOP (solid shape): outline of 1933 points within 118.87,103.67 138.47,113.58
GND on TOP (solid shape): outline of 1959 points within 145.34,103.64 160.74,114.69
GND on TOP (solid shape): outline of 4953 points within 204.49,24.58 223.16,44.94
GND on BOTTOM (solid shape): 11.6,75.35 11.6,73.42 11.04,72.86 9.29,72.86 8.86,73.3 8.86,75.25 9.34,75.73 11.22,75.73
GND on BOTTOM (solid shape): 54.5,165.59 54.5,161.1 54.43,161.03 49.98,161.03 49.88,161.13 49.88,165.62 50,165.74 54.35,165.74
GND on BOTTOM (solid shape): 89.93,69.13 89.93,65.57 89.43,65.07 22.09,65.07 21.23,65.93 21.23,69.38 21.61,69.76 89.3,69.76
GND on BOTTOM (solid shape): 150.54,166.67 150.54,165.37 150.16,164.99 149.07,164.99 148.74,165.32 148.74,166.79 148.89,166.95 150.26,166.95
GND on BOTTOM (solid shape): 161.31,166.34 161.31,165.3 161.09,165.07 160.01,165.07 159.58,165.51 159.58,166.46 159.84,166.72 160.93,166.72
GND on BOTTOM (solid shape): 179.99,129.64 179.99,124.9 179.65,124.56 177.95,124.56 177.57,124.94 177.57,129.89 177.69,130.01 179.62,130.01
GND on BOTTOM (solid shape): 180.01,118.03 180.01,114.89 179.59,114.46 178.2,114.46 177.41,115.25 177.41,118.07 177.65,118.31 179.74,118.31
GND on BOTTOM (solid shape): 242,16.53 242,13.07 241.9,12.97 238.45,12.97 238.37,13.05 238.37,16.5 238.47,16.6 241.93,16.6
GND on BOTTOM (solid shape): 258.14,40.48 258.14,39.06 256.89,37.81 256.13,37.81 255.59,38.35 255.59,40.66 255.72,40.78 257.84,40.78
GND on BOTTOM (solid shape): 269.16,41.8 269.16,40.43 268.83,40.1 265.83,40.1 265.4,40.53 265.4,41.27 266.39,42.26 268.7,42.26
GND on BOTTOM (solid shape): 13.71,154.73 13.71,147.54 13.48,147.31 9.67,147.31 9.42,147.57 9.42,154.4 10.05,155.03 13.4,155.03
GND on BOTTOM (solid shape): 30.14,58.94 30.14,56.66 29.8,56.32 29.11,56.32 28.37,57.06 28.37,58.87 28.39,58.89 29.43,58.89 29.53,59 30.09,59
GND on BOTTOM (solid shape): 39.8,58.94 39.8,57.12 39.67,56.99 38.09,56.99 38.02,57.06 38.02,58.87 38.04,58.89 39.08,58.89 39.19,59 39.74,59
GND on BOTTOM (solid shape): 49.45,58.94 49.45,57.12 49.32,56.99 47.75,56.99 47.67,57.06 47.67,58.87 47.69,58.89 48.74,58.89 48.84,59 49.4,59
GND on BOTTOM (solid shape): 58.73,98.91 58.73,98.22 58.64,98.12 58.31,98.12 57.7,97.51 57.49,97.51 57.36,97.64 57.36,98.5 57.8,98.95 58.69,98.95
GND on BOTTOM (solid shape): 78.4,58.94 78.4,57.12 77.8,56.52 77.17,56.52 76.63,57.06 76.63,58.67 77.09,59.13 78.22,59.13
GND on BOTTOM (solid shape): 100.42,158.44 101.62,158.44 102.05,158 102.05,156.1 101.72,155.77 100.32,155.77 99.46,156.63 99.46,158.28 99.74,158.56 100.3,158.56
GND on BOTTOM (solid shape): 111.23,154.22 111.23,150.32 109.51,148.59 108.51,148.59 107.98,149.12 106.91,149.12 105.37,150.66 105.37,154.45 106.09,155.17 110.28,155.17
GND on BOTTOM (solid shape): 262.07,17.57 264.69,17.57 265.07,17.19 265.07,15.69 264.94,15.56 261.41,15.56 261.31,15.66 261.31,17.52 261.59,17.8 261.84,17.8
GND on BOTTOM (solid shape): 59.1,58.94 59.1,57.12 58.97,56.99 57.4,56.99 57.32,57.06 57.32,58.74 57.54,58.96 58.3,58.96 58.45,59.11 58.93,59.11
GND on BOTTOM (solid shape): 68.75,58.94 68.75,57.12 68.62,56.99 67.05,56.99 66.97,57.06 66.97,58.54 67.32,58.89 67.94,58.89 68.14,59.09 68.6,59.09
GND on BOTTOM (solid shape): 130.03,166.99 130.03,165.26 129.88,165.1 127.22,165.1 126.8,164.67 126.8,163.03 126.57,162.8 126.12,162.8 126.12,166.47 126.93,167.29 129.74,167.29
GND on BOTTOM (solid shape): 234.66,27.19 234.66,24.1 234.4,23.84 234.04,23.84 234.03,23.83 232.25,23.83 232.13,23.96 232.13,27.26 232.25,27.39 234.47,27.39
GND on BOTTOM (solid shape): 45.8,129.18 45.8,128.25 46.09,127.97 46.09,127.59 45.98,127.48 45.18,127.48 44.91,127.75 44.91,129.23 44.97,129.29 45.69,129.29
GND on BOTTOM (solid shape): 88.06,58.94 88.06,57.57 87.83,57.34 87.45,57.34 87.11,57.01 86.33,57.01 86.28,57.06 86.28,58.87 86.3,58.89 87.34,58.89 87.45,59 88,59
GND on BOTTOM (solid shape): 134.87,161.28 134.87,159.27 134.51,158.92 132.71,158.92 132.17,158.39 132.17,154.83 131.41,154.07 128.31,154.07 127.4,154.98 127.4,161.41 127.68,161.69 134.46,161.69
GND on BOTTOM (solid shape): 140.76,166.51 140.76,164.99 140.61,164.84 138.96,164.84 138.7,165.09 138.7,165.55 138.93,165.78 139.59,165.78 139.82,166.01 139.82,166.54 140.02,166.74 140.53,166.74
GND on BOTTOM (solid shape): 145.59,161.51 145.59,159.27 145.28,158.97 143.53,158.97 142.67,158.11 142.67,154.42 142.33,154.09 139.24,154.09 138.63,154.7 138.63,161.18 139.24,161.79 145.31,161.79
GND on BOTTOM (solid shape): 179.11,54.68 179.11,52.39 179.04,52.32 178.71,52.32 178.63,52.39 178.63,54.11 178.62,54.12 178.11,54.63 178.11,55.09 178.17,55.16 178.63,55.16
GND on BOTTOM (solid shape): 26.46,118.76 26.46,118.1 26.38,118.02 25.57,118.02 25.42,118.18 23.92,118.18 23.79,118.3 23.79,118.53 24.05,118.79 25.24,118.79 25.32,118.86 26.36,118.86
GND on BOTTOM (solid shape): 166.34,160.7 166.34,159.02 165.91,158.59 164.97,158.59 164.64,158.26 164.64,153.38 164.43,153.18 160.9,153.18 159.45,154.63 159.45,160.8 160.04,161.38 165.65,161.38
GND on BOTTOM (solid shape): 213.76,32.9 213.76,31.63 213.69,31.56 212.5,31.56 212.39,31.66 212.39,31.96 212.5,32.07 212.92,32.07 213.1,32.25 213.1,33 213.2,33.11 213.56,33.11
GND on BOTTOM (solid shape): 285.59,17.92 285.59,16.45 285.34,16.2 284.88,16.2 284.65,15.97 284.65,14.98 284.63,14.95 283.94,14.95 283.79,15.1 283.79,17.26 284.6,18.08 285.44,18.08
GND on BOTTOM (solid shape): 155.44,160.93 155.44,159.2 155.11,158.87 154.2,158.87 153.99,158.66 153.99,153.64 153.31,152.95 150.01,152.95 148.56,154.4 148.56,160.87 148.68,161 148.68,161.33 149.09,161.74 154.63,161.74
GND on BOTTOM (solid shape): 239.69,60.21 239.69,56.94 238.68,55.92 237.41,55.92 236.19,54.7 234.41,54.7 234.08,55.03 234.08,58.07 233.76,58.39 233.76,60.17 234.04,60.44 239.46,60.44
GND on BOTTOM (solid shape): 59.99,61.26 59.99,60.11 59.89,60.01 58.26,60.01 58.24,59.99 58.24,59.48 57.99,59.23 52.95,59.23 52.83,59.36 52.83,61.05 53.13,61.36 59.89,61.36
GND on BOTTOM (solid shape): 70.52,94.96 70.52,94.07 70.44,94 70.17,94 68.69,95.48 68.02,95.48 67.9,95.6 67.9,95.87 67.97,95.94 68.2,95.94 68.78,96.51 68.97,96.51
GND on BOTTOM (solid shape): 71.77,53.05 71.77,51.98 71.52,51.73 61.82,51.73 61.45,52.1 61.45,52.81 61.79,53.15 66.76,53.15 66.92,53.31 71.52,53.31
