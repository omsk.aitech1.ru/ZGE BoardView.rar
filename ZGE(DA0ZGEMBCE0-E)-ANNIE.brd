# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_RXP17_TBT_C: length 3.4
  TOP w0.089: 260.62,44.01 260.62,44.03 260.58,44.08 260.58,44.66 260.39,44.85 260.39,45.72 260.5,45.82 260.5,46.14 260.44,46.2 260.31,46.2 260.28,46.17 U7.V23
  TOP w0.14: 260.62,44.01 260.62,43.59 260.76,43.45 C216.1
PCIE_RXP18_TBT: length 64.3
  TOP w0.14: C217.2 261.91,42.73 261.91,42.18 v1(261.72,42) ; v1(222.85,38.7) 222.85,39.02 222.71,39.16 U14.R40
  IN4 w0.086: v1(222.85,38.7) 223.08,38.93 223.08,39.14 222.99,39.24 222.32,39.24 221.8,39.76 221.8,40.19 221.99,40.38 226.61,40.38 226.73,40.49 228.23,40.49 228.69,40.95 229.4,40.95 229.58,40.77 229.58,40 229.67,39.92 230.08,39.92 230.18,40.02 230.18,40.76 230.37,40.95 236.12,40.95 236.56,40.51 236.56,39.85 236.24,39.53 236.24,39.29 236.33,39.21 237.91,39.21 238.36,39.66 238.36,40.03 238.61,40.28 239.1,40.28 239.34,40.03 239.34,39.29 239.43,39.21 239.88,39.21 239.97,39.29 239.97,39.51 240.15,39.69 240.71,39.69 240.89,39.51 240.89,39.29 240.98,39.21 241.4,39.21 241.48,39.29 241.48,39.51 241.67,39.69 242.23,39.69 242.41,39.51 242.41,39.29 242.5,39.21 242.92,39.21 243,39.29 243,39.51 243.19,39.69 243.75,39.69 243.93,39.51 243.93,39.29 244.01,39.21 244.44,39.21 244.52,39.29 244.52,39.51 244.71,39.69 245.26,39.69 245.45,39.51 245.45,39.29 245.53,39.21 245.92,39.21 246.07,39.35 246.07,40.58 246.35,40.85 247.18,40.85 247.37,40.66 247.37,39.08 247.56,38.89 248.62,38.89 248.71,38.99 248.71,39.42 248.91,39.62 249.25,39.62 249.43,39.43 249.43,38.98 249.52,38.89 249.77,38.89 249.87,39 249.87,40 250.1,40.22 250.47,40.22 250.69,40 250.69,39.92 250.78,39.83 251.39,39.83 251.93,39.29 252.24,39.29 252.49,39.54 252.96,39.54 254.22,38.28 254.22,37.21 254.37,37.07 254.67,37.07 254.76,37.16 254.76,37.88 254.94,38.07 255.36,38.07 255.54,37.88 255.54,37.67 255.65,37.56 257.42,37.56 258.64,38.78 259.75,38.78 260.31,39.34 260.31,40.57 260.61,40.87 261.24,40.87 261.97,41.6 261.97,41.76 v1(261.72,42)
PCIE_RXP18_TBT_C: length 3.4
  TOP w0.089: U7.P23 262.12,46.19 262.07,46.24 261.94,46.24 261.88,46.17 261.88,45.85 262.02,45.71 262.02,44.8 261.92,44.69 261.92,44.24 261.89,44.2
  TOP w0.14: 261.89,44.2 261.89,43.69 C217.1
PCIE_RXP19_TBT: length 64.7
  TOP w0.14: C219.2 263.3,43 263.52,42.78 263.52,42.13 263.38,41.99 v1(263.21,41.99) ; v1(223.82,39.46) 223.82,39.88 U14.N42
  IN4 w0.086: v1(263.21,41.99) 263.28,42.06 263.45,42.06 263.56,41.95 263.56,41.37 262.86,40.67 262.86,40.33 262.22,39.69 261.45,39.69 259.98,38.22 258.9,38.22 258.47,37.79 258.47,37.44 259.61,36.3 259.61,36.18 258.94,35.51 258.81,35.51 258.58,35.74 258.58,36.54 258.11,37.01 257.8,37.01 257.22,36.43 256.99,36.43 256.85,36.57 256.85,36.81 256.65,37 256.28,37 256.04,36.76 256.04,35.79 256.23,35.61 257,35.61 257.08,35.52 257.08,35.23 257,35.14 256.24,35.14 256.06,34.96 256.06,34.7 255.91,34.55 254.87,34.55 254.78,34.64 254.78,34.83 255.14,35.19 255.14,35.69 254.78,36.05 254.78,36.25 254.51,36.52 253.21,36.52 251.39,38.34 246.47,38.34 246.3,38.17 245.43,38.17 244.95,38.65 244.12,38.65 243.94,38.47 243.94,37.26 243.85,37.18 243.43,37.18 243.35,37.26 243.35,38.47 243.16,38.65 242.61,38.65 242.42,38.47 242.42,37.47 242.34,37.38 242,37.38 241.83,37.56 241.83,38.47 241.64,38.65 241.09,38.65 240.9,38.47 240.9,37.63 240.81,37.54 240.4,37.54 240.31,37.62 240.31,38.41 240.06,38.65 233.95,38.65 232.39,40.21 231.73,40.21 230.88,39.36 226.82,39.36 226.36,39.82 224.43,39.82 224.07,39.46 v1(223.82,39.46)
PCIE_RXP19_TBT_C: length 3.5
  TOP w0.089: 263.46,44.2 263.5,44.24 263.5,44.65 263.83,44.98 263.83,45.16 263.83,45.77 263.72,45.88 263.72,46.14 263.78,46.2 263.86,46.2 263.96,46.1 U7.K23
  TOP w0.14: C219.1 263.32,43.45 263.46,43.59 263.46,44.2
PCIE_RXP20_TBT: length 64.6
  TOP w0.14: C221.2 264.81,43 264.95,42.86 264.95,42.06 264.81,41.92 v1(264.74,41.92) ; U14.R37 221.08,38.74 221.41,38.41 v1(221.52,38.41)
  IN4 w0.086: v1(221.52,38.41) 221.5,38.43 221.35,38.43 221.27,38.34 221.27,38.16 221.46,37.96 222.59,37.96 222.92,38.29 223.66,38.29 224.11,38.74 225.96,38.74 226.54,38.17 228.67,38.17 229.12,37.72 230.43,37.72 231.33,38.62 232.53,38.62 233.72,37.44 235.53,37.44 235.87,37.77 238.29,37.77 238.51,37.54 239.36,37.54 240.37,36.53 240.83,36.53 241.19,36.17 243.71,36.17 244.77,37.23 246.17,37.23 246.72,37.78 251,37.78 252.75,36.03 252.75,33.33 252.95,33.12 254.26,33.12 254.35,33.21 254.35,33.63 254.44,33.72 254.44,33.73 254.52,33.81 255.01,33.81 255.2,33.62 255.2,32.52 255.37,32.35 256.3,32.35 256.5,32.55 256.5,34.02 257.03,34.56 258.79,34.56 261.28,37.05 261.28,38.17 262.15,39.03 263.3,39.03 263.38,39.12 263.38,39.58 263.57,39.76 264.13,39.76 264.31,39.58 264.31,39.12 264.39,39.03 265.62,39.03 265.74,39.15 265.74,39.7 265.56,39.87 265.19,39.87 265.02,40.04 265.02,41.87 264.91,41.97 264.79,41.97 v1(264.74,41.92)
PCIE_RXP20_TBT_C: length 3.6
  TOP w0.089: 264.83,44.01 264.83,44.12 265.7,45 265.7,45.67 265.56,45.81 265.56,46.18 265.62,46.24 265.69,46.24 265.8,46.14 U7.F23
  TOP w0.14: 264.83,44.01 264.83,43.61 C221.1
PCIE_RXP21_SSD: length 65.2
  TOP w0.14: v1(224.54,38.15) 224.54,38.57 U14.R44
  IN1 w0.086: v1(224.54,38.15) 224.54,38.07 224.69,37.92 224.86,37.92 225.65,38.72 226.11,38.72 227.36,37.47 227.36,36.2 227.48,36.08 229.05,36.08 229.24,35.89 229.24,35.34 229.06,35.15 227.28,35.15 227.2,35.07 227.2,33.82 225.46,32.08 223.75,32.08 223.52,32.31 220.94,32.31 220.65,32.02 219.48,32.02 219.25,32.26 214.38,32.26 212.89,33.75 211.76,33.75 211.19,33.18 210.15,33.18 209.61,33.71 204.92,33.71 204.49,33.29 204.49,33 203.57,32.08 203.38,32.08 202.36,31.06 200.42,31.06 198.86,29.49 198.86,27.73 196.72,25.59 196.72,25.28 196.28,24.85 193.37,24.85 193.29,24.76 193.29,24.47 193.1,24.28 192.54,24.28 192.36,24.47 192.36,24.76 192.27,24.85 190.32,24.85 190.1,24.63 186.76,24.63 186.45,24.32 186.45,23.64 185.52,22.7 185.52,21.6 v1(185.73,21.39)
  BOTTOM w0.14: R1027.1 185.7,20.75 185.55,20.9 185.55,21.21 v1(185.73,21.39)
PCIE_RXP21_SSD_R: length 5.6
  BOTTOM w0.14: CN18.41 188.82,17.95 188.59,17.72 188.35,17.72 186.56,19.51 185.72,19.51 185.57,19.66 185.57,19.85 185.69,19.97 R1027.2
PCIE_RXP22_SSD: length 64.6
  TOP w0.14: v1(223.1,37.49) 222.99,37.6 222.99,37.8 223.19,37.99 U14.U41
  IN1 w0.086: v1(223.1,37.49) 222.99,37.38 222.99,37.26 223.21,37.04 224.61,37.04 224.75,37.18 226.38,37.18 226.64,36.92 226.64,34.25 226.33,33.94 220.5,33.94 219.38,32.82 214.66,32.82 213.16,34.32 211.47,34.32 210.95,33.81 210.3,33.81 209.17,34.93 205.05,34.93 203.42,33.3 203.03,33.3 201.35,31.61 200.09,31.61 198.3,29.82 198.3,27.97 196.27,25.94 194.83,25.94 194.29,25.4 186.73,25.4 185.39,24.06 185.01,24.06 184.83,24.24 184.83,24.52 184.64,24.71 184.32,24.71 184.18,24.57 184.18,24.15 183.99,23.97 182.86,23.97 182.69,23.8 182.69,23.57 182.9,23.36 183.48,23.36 183.64,23.21 183.64,22.75 v1(183.86,22.52)
  BOTTOM w0.14: v1(183.86,22.52) 183.84,22.52 183.7,22.66 183.7,22.82 183.99,23.11 185.04,23.11 185.24,22.91 185.24,22.71 R1000.1
PCIE_RXP22_SSD_R: length 5.2
  BOTTOM w0.14: R1000.2 185.96,22.86 186.11,23.02 186.41,23.02 188.21,21.22 188.21,20.87 188.51,20.57 188.66,20.57 188.78,20.45 CN18.31
PCIE_RXP23_SSD: length 66.5
  TOP w0.14: v1(225.02,36.57) 225.02,36.86 U14.W44
  IN1 w0.086: v1(225.02,36.57) 224.93,36.57 224.75,36.39 224.75,35.98 224.02,35.25 220.29,35.25 219.68,34.64 219.68,34.03 219.07,33.42 214.85,33.42 212.25,36.02 211.03,36.02 210.54,35.52 206.7,35.52 206.25,35.98 205.11,35.98 203.15,34.02 202.92,34.02 201.07,32.17 199.86,32.17 199.7,32 197.82,32 197.41,31.59 197.41,28.71 196.2,27.5 193.88,27.5 193.79,27.41 193.79,26.15 193.6,25.96 193.05,25.96 192.87,26.14 192.87,27.41 192.78,27.5 192.36,27.5 192.28,27.41 192.28,26.14 192.09,25.96 191.53,25.96 191.35,26.14 191.35,27.72 191.26,27.81 190.89,27.81 190.8,27.72 190.8,26.15 190.61,25.96 190.08,25.96 189.9,26.14 189.9,27.67 189.81,27.75 189.39,27.75 189.3,27.67 189.3,26.68 189.12,26.49 187.43,26.49 187.19,26.25 186.52,26.25 185.71,25.44 182.73,25.44 182.46,25.17 182.46,24.85 182.54,24.77 182.7,24.77 v1(182.72,24.78)
  BOTTOM w0.14: R966.1 184.69,25.55 184.27,25.55 183.82,25.1 182.68,25.1 182.59,25.01 182.59,24.91 v1(182.72,24.78)
PCIE_RXP23_SSD_R: length 4.6
  BOTTOM w0.14: CN18.19 188.8,23.45 188.64,23.61 188.32,23.61 186.53,25.4 186.29,25.4 R966.2
PCIE_RXP24_SSD: length 65
  TOP w0.14: v1(223.41,36.15) 223.41,36.61 U14.Y41
  IN1 w0.086: v1(188.03,30.1) 188.29,29.84 189.06,29.84 189.34,30.13 189.34,31.85 189.67,32.17 190.63,32.17 190.83,31.98 190.83,31.58 190.62,31.38 190.31,31.38 190.23,31.3 190.23,30.01 190.34,29.89 190.65,29.89 190.81,30.05 190.81,30.71 190.99,30.89 192.18,30.89 192.63,31.34 196.14,31.34 197.61,32.82 197.61,33.92 197.9,34.2 198.93,34.2 199.14,34 199.14,32.96 199.22,32.87 199.45,32.87 199.67,33.1 199.67,34.96 199.9,35.19 200.4,35.19 200.62,34.97 200.62,33.25 200.77,33.1 200.97,33.1 201.19,33.31 201.19,34.75 201.59,35.15 203.21,35.15 203.66,35.61 203.66,36.78 204.07,37.18 207.12,37.18 207.55,36.76 207.94,36.76 208.12,36.57 208.12,36.33 208.21,36.25 208.59,36.25 208.71,36.37 208.71,36.57 208.9,36.76 209.46,36.76 209.64,36.57 209.64,36.33 209.73,36.25 210.1,36.25 210.23,36.38 210.23,36.57 210.42,36.76 212.55,36.76 213.8,35.51 214.47,35.51 214.55,35.6 214.55,36.05 214.74,36.23 215.27,36.23 215.48,36.02 215.48,35.6 215.56,35.51 215.99,35.51 216.07,35.6 216.07,35.84 216.26,36.02 216.81,36.02 217,35.84 217,35.6 217.08,35.51 218.3,35.51 218.46,35.67 218.46,36.19 218.91,36.64 219.5,36.64 219.58,36.73 219.58,37.62 219.79,37.83 220.32,37.83 220.51,37.65 220.51,36.1 220.64,35.97 221.02,35.97 221.1,36.05 221.1,37.57 221.28,37.76 221.81,37.76 222.03,37.55 222.03,36.73 222.11,36.64 222.8,36.64 223.29,36.15 v1(223.41,36.15)
  BOTTOM w0.14: v1(188.03,30.1) 187.86,29.93 187.86,29.93 187.84,29.92 187.39,29.92 186.94,29.47 186.94,28.58 R934.1
PCIE_RXP24_SSD_R: length 3.5
  BOTTOM w0.14: CN18.7 188.75,26.45 188.72,26.48 187.6,26.48 187.19,26.89 186.96,27.12 186.96,27.37 R934.2
PCIE_TXN9_SSD: length 64.7
  TOP w0.089: 218.38,48.17 218.45,48.17 218.5,48.11 218.78,48.11 219.91,46.98 219.91,44.86 219.96,44.81 U14.C34
  TOP w0.14: v1(217.2,49.22) 217.59,48.84 217.59,48.72 218.13,48.17 218.38,48.17
  IN1 w0.086: v1(182.52,49.8) 182.76,49.56 182.76,49.52 182.76,49.42 182.76,48.9 183.25,48.41 183.89,48.41 184.12,48.64 184.8,48.64 185.03,48.41 185.55,48.41 185.72,48.57 185.72,48.73 185.8,48.82 186.03,48.82 186.11,48.73 186.11,48.59 186.3,48.41 186.66,48.41 186.85,48.59 186.85,48.76 186.93,48.85 187.2,48.85 187.29,48.76 187.29,48.63 187.47,48.45 187.86,48.45 188.05,48.63 188.05,49.11 188.13,49.2 188.34,49.2 188.44,49.1 188.44,48.59 188.62,48.41 188.95,48.41 189.16,48.61 189.16,49.6 189.25,49.68 189.47,49.68 189.56,49.59 189.56,48.87 189.74,48.68 190.1,48.68 190.28,48.87 190.28,49.57 190.39,49.68 190.58,49.68 190.67,49.6 190.67,48.87 190.85,48.68 191.21,48.68 191.39,48.87 191.39,49.59 191.48,49.68 191.7,49.68 191.78,49.6 191.78,48.87 191.97,48.68 192.32,48.68 192.5,48.87 192.5,49.57 192.62,49.68 192.92,49.68 193.01,49.6 193.01,48.95 193.18,48.77 194.53,48.77 194.78,49.03 194.78,50.12 195.02,50.35 197.21,50.35 197.4,50.53 197.4,50.92 197.29,51.03 197.29,51.22 197.47,51.4 197.77,51.4 197.94,51.23 197.94,50.51 198.22,50.22 198.59,50.22 198.79,50.42 198.79,50.79 198.91,50.91 199.13,50.91 200.24,49.8 201.27,49.8 201.46,49.98 201.46,50.29 201.54,50.37 201.73,50.37 201.85,50.26 201.85,49.98 202.03,49.8 202.65,49.8 203.21,50.36 203.21,51.01 203.57,51.37 203.57,52.11 203.68,52.22 207.47,52.22 207.65,52.4 207.65,52.64 207.77,52.76 208.3,52.76 208.48,52.59 208.48,52.07 208.69,51.86 217.67,51.86 218.08,51.45 218.08,50.77 217.49,50.18 217.49,49.33 217.38,49.22 v1(217.2,49.22)
  BOTTOM w0.14: C734.2 183.52,50.71 183.15,50.71 182.73,50.29 182.73,50.02 v1(182.52,49.8)
PCIE_TXN9_SSD_R: length 5.2
  BOTTOM w0.14: CN15.11 188.83,50.5 188.75,50.42 188.62,50.42 188.44,50.61 185.18,50.61 C734.1
PCIE_TXN10_SSD: length 64.3
  TOP w0.089: 219.57,48.28 219.57,48.21 220.46,47.32 220.46,45.39 220.56,45.3 220.56,44.63 U14.C35
  TOP w0.14: v1(216.95,51.17) 217.26,50.85 218.19,50.85 218.8,50.25 218.8,49.06 219.57,48.3 219.57,48.28
  IN1 w0.086: v1(216.95,51.17) 216.71,50.93 216.31,50.93 215.8,51.44 214.59,51.44 214.19,51.05 212.25,51.05 212.16,51.14 212.16,51.28 211.98,51.46 211.62,51.46 211.44,51.28 211.44,50.5 211.35,50.41 211.15,50.41 211.05,50.52 211.05,51.28 210.86,51.46 210.51,51.46 210.32,51.28 210.32,50.75 210.2,50.62 209.95,50.62 209.87,50.71 209.87,51.23 209.69,51.41 209.14,51.41 208.78,51.06 208.47,51.06 208.4,51.13 208.4,51.53 208.1,51.82 207.82,51.82 207.58,51.58 207.58,51.23 207.35,51 206.77,51 206.69,51.08 206.69,51.44 206.3,51.82 205.81,51.82 205.36,51.37 205.15,51.37 205.03,51.49 205.03,51.63 204.84,51.82 204.2,51.82 204,51.63 204,51.25 203.6,50.85 203.6,50.19 202.81,49.41 200.08,49.41 199.75,49.73 199.42,49.73 199.1,49.41 198.71,49.41 198.29,49.83 197.77,49.83 197.59,49.65 197.59,49.48 197.44,49.33 197.22,49.33 197.13,49.41 197.13,49.77 196.94,49.96 196.55,49.96 196.36,49.78 196.36,48.94 196.19,48.77 195.09,48.77 194.63,48.3 194.63,47.98 194.54,47.9 194.15,47.9 194.06,47.98 194.06,48.19 193.87,48.38 193.52,48.38 193.34,48.2 193.34,47.98 193.25,47.9 193.04,47.9 192.95,47.98 192.95,48.12 192.77,48.3 192.41,48.3 192.23,48.12 192.23,47.98 192.14,47.9 191.92,47.9 191.84,47.98 191.84,48.12 191.65,48.3 191.3,48.3 191.12,48.12 191.12,47.98 191.03,47.9 190.81,47.9 190.72,47.98 190.72,48.11 190.54,48.29 190.19,48.29 190,48.11 190,47.98 189.92,47.9 189.75,47.9 189.54,47.7 189.54,46.9 189.42,46.78 189.24,46.78 189.15,46.86 189.15,47.77 188.97,47.96 188.65,47.96 188.36,47.67 188.36,47.47 188.25,47.36 187.75,47.36 187.66,47.45 187.66,47.83 187.48,48.02 186.95,48.02 186.76,47.83 186.76,46.86 186.68,46.78 186.46,46.78 186.37,46.86 186.37,47.83 186.19,48.02 185.84,48.02 185.65,47.83 185.65,47.58 185.54,47.47 185.35,47.47 185.26,47.56 185.26,47.83 185.08,48.02 184.67,48.02 184.45,47.8 184.45,46.66 184.37,46.57 184.12,46.57 184.04,46.66 184.04,47.46 183.87,47.62 183.37,47.62 v1(183.03,47.97)
  BOTTOM w0.14: v1(183.03,47.97) 183.32,47.67 183.53,47.67 C760.2
PCIE_TXN10_SSD_R: length 5.2
  BOTTOM w0.14: C760.1 184.69,47.95 185,47.64 186.99,47.64 187.13,47.5 CN15.23
PCIE_TXN11_SSD: length 64.3
  TOP w0.089: 220.38,48.26 220.83,47.81 220.83,45.55 220.94,45.45 220.94,45.24 U14.B36
  TOP w0.127: 220.36,48.28 220.38,48.26
  TOP w0.14: v1(214.98,49.79) 215.25,49.52 215.33,49.52 215.59,49.78 215.59,51.81 216.01,52.24 218.58,52.24 219.53,51.3 219.53,49.35 220.36,48.52 220.36,48.28
  IN1 w0.086: v1(214.98,49.79) 214.98,49.69 214.75,49.46 212.24,49.46 210.99,48.21 208.74,48.21 208.22,47.69 208.22,46.66 207.59,46.02 206.72,46.02 206.55,46.18 206.55,46.5 206.27,46.78 205.73,46.78 205.58,46.93 205.58,47.12 205.67,47.2 206.34,47.2 206.55,47.41 206.55,47.73 206.09,48.19 197.49,48.19 196.84,47.54 196.84,47.13 196.75,47.04 196.34,47.04 196.1,46.8 196.1,46.51 196.3,46.3 196.7,46.3 196.84,46.17 196.84,46 196.72,45.88 195.31,45.88 195.09,45.66 195.09,45.26 195,45.17 194.74,45.17 194.66,45.25 194.66,45.62 194.41,45.88 194.06,45.88 193.87,45.68 193.87,44.36 193.72,44.22 193.51,44.22 193.41,44.31 193.41,45.13 193.23,45.32 192.88,45.32 192.69,45.13 192.69,44.25 192.61,44.16 192.41,44.16 192.3,44.27 192.3,45.13 192.12,45.32 191.76,45.32 191.58,45.13 191.58,44.47 191.49,44.39 191.3,44.39 191.19,44.49 191.19,45.13 191.01,45.32 190.48,45.32 190.17,45.01 190.17,44.25 190.08,44.17 187.21,44.17 186.39,44.99 183.85,44.99 183.43,44.57 183.33,44.57 v1(182.98,44.92)
  BOTTOM w0.14: C779.2 183.53,44.63 183.28,44.63 v1(182.98,44.92)
PCIE_TXN11_SSD_R: length 5.2
  BOTTOM w0.14: CN15.35 188.56,44.5 188.45,44.39 187.06,44.39 186.83,44.62 185.07,44.62 C779.1
PCIE_TXN12_SSD: length 65.5
  TOP w0.089: U14.D38 221.52,44.41 221.52,44.51 221.43,44.59 221.43,45.48 221.21,45.7 221.21,48.22
  TOP w0.102: 221.16,48.28 221.21,48.22
  TOP w0.14: 221.16,48.28 221.16,48.72 220.29,49.59 220.29,51.78 219.12,52.95 215.52,52.95 214.72,52.15 214.72,51.4 213.5,50.18 213.5,49.02 213.77,48.75 213.77,48.42 213.66,48.3 v1(213.3,48.3)
  IN1 w0.086: v1(213.3,48.3) 213.38,48.22 213.68,48.22 213.81,48.35 214.06,48.35 214.71,47.7 214.71,45.2 214.25,44.74 209.3,44.74 208.83,45.21 206.2,45.21 205.7,45.71 202.31,45.71 202.13,45.89 202.13,46.56 202.33,46.76 203.16,46.76 203.31,46.91 203.31,47.24 203.1,47.45 197.8,47.45 197.57,47.22 197.57,45.35 196.95,44.73 195.59,44.73 193.95,43.09 191.42,43.09 190.95,42.62 189.4,42.62 189.19,42.83 187.07,42.83 185.64,44.26 184.6,44.26 183.71,43.37 183.71,43.12 v1(184.02,42.82)
  BOTTOM w0.14: v1(184.02,42.82) 183.42,42.22 183.42,41.84 183.56,41.7 183.66,41.7 C783.2
PCIE_TXN12_SSD_R: length 5.2
  BOTTOM w0.14: C783.1 185.06,41.58 186.88,41.58 187.07,41.38 188.63,41.38 188.75,41.5 CN15.47
PCIE_TXN14_LAN: length 254
  TOP w0.14: R170.2 221.36,50.69 221.36,50.91 221.17,51.1 v1(221.02,51.1)
  IN1 w0.086: v1(221.02,51.1) 221.25,51.34 221.25,51.83 220.98,52.11 219.94,52.11 218.44,53.6 209.93,53.6 209.02,54.51 207.05,54.51 206.5,53.96 202.34,53.96 201.42,53.05 200.25,53.05 200.15,53.14 196.74,53.14 196.25,52.65 195.51,52.65 195.15,52.3 194.06,52.3 193.45,51.69 192.31,51.69 192.05,51.43 190.58,51.43 190.26,51.74 190.26,53.09 188.98,54.37 186.53,54.37 182.81,50.65 182.34,50.65 182,50.31 182,46.64 182.47,46.16 182.47,45.22 181.84,44.59 181.84,39.13 175.07,32.36 101.07,32.36 100.43,33 92.98,33 92.82,32.84 89.83,32.84 88.55,34.12 86.52,34.12 86.25,34.39 84.78,34.39 84.51,34.65 82.83,34.65 82.73,34.75 74.74,34.75 74.26,35.23 69.96,35.23 69.62,34.88 68.67,34.88 68.35,35.2 64.24,35.2 63.78,35.67 59.78,35.67 59.2,35.09 57.74,35.09 56.42,36.41 53.89,36.41 52.81,37.5 49.8,37.5 49.32,37.01 48.39,37.01 46.69,38.72 38.89,38.72 38.56,39.04 34.34,39.04 33.58,39.81 31.4,39.81 29.93,41.28 28.81,41.28 28.09,40.55 28.09,39.89 25.82,37.62 22.12,37.62 19.54,40.19 19.54,41.88 18.87,42.55 18.12,42.55 17.74,42.17 16.31,42.17 15.53,42.95 15.53,43.67 14.71,44.49 13.7,44.49 12.79,43.57 12.79,39.78 12.37,39.36 12.37,36.3 11.27,35.2 10.77,35.2 10.65,35.09 v1(10.65,34.77)
  BOTTOM w0.14: CN17.43 11.36,35 11.26,35.1 10.99,35.1 v1(10.65,34.77)
PCIE_TXN14_LAN_C: length 6.4
  TOP w0.089: U14.C39 222.16,44.56 222.08,44.49 221.98,44.49 221.93,44.54 221.93,44.85 222.1,45.02 222.1,45.45 222.47,45.82 222.47,47.56 221.96,48.07 221.9,48.07 221.88,48.09
  TOP w0.14: R170.1 221.27,49.59 221.56,49.3 221.56,49.07 221.71,48.93 221.71,48.26 221.88,48.09
PCIE_TXN15_WLAN: length 4.2
  TOP w0.14: v1(55.64,42) 55.81,41.83 56.66,41.83 56.97,41.51 57.13,41.35 57.13,41.15 C232.2
  BOTTOM w0.14: CN16.37 55.89,41.75 v1(55.64,42)
PCIE_TXN15_WLAN_C: length 202.8
  TOP w0.089: 222.87,48.28 222.87,45.57 222.77,45.47 222.77,44.96 222.68,44.88 222.61,44.88 222.52,44.97 U14.B40
  TOP w0.14: v1(223.7,51.79) 223.92,51.58 223.92,51.32 222.87,50.27 222.87,48.28 ; v1(55.62,38.88) 55.87,39.13 56.11,39.13 56.25,39.27 56.73,39.27 56.88,39.41 57.01,39.54 57.01,39.71 C232.1
  IN1 w0.086: v1(223.7,51.79) 223.91,52 223.91,52.66 222.8,53.76 222.2,53.76 221.97,54 220.94,54 219.46,55.48 213.2,55.48 212.74,55.94 210.44,55.94 209.62,56.76 200.48,56.76 199.93,56.21 196.29,56.21 195.75,56.76 192.93,56.76 191.72,57.96 188.57,57.96 188.4,57.79 187.1,57.79 185.12,55.82 184.34,55.82 183.49,54.97 183.49,54.44 182.24,53.19 181.8,53.19 179.84,51.23 179.84,39.8 174.35,34.31 151.24,34.31 151.15,34.22 102.15,34.22 100.56,35.8 96.34,35.8 95.93,36.21 93.22,36.21 92.07,35.07 90.21,35.07 88.72,36.56 85.92,36.56 85.53,36.96 83.58,36.96 83.18,36.57 81.23,36.57 80.8,37 78.82,37 78.72,37.1 74.96,37.1 74.58,37.48 72.17,37.48 72.01,37.63 69.64,37.63 68.81,38.46 66.57,38.46 66.31,38.72 64.45,38.72 64.08,38.35 57.62,38.35 56.7,39.27 56.25,39.27 56.1,39.13 55.86,39.13 v1(55.62,38.88)
PCIE_TXN17_TBT: length 63.7
  TOP w0.089: U7.Y22 259.13,46.27 259.13,45.34 v2(258.94,45.15)
  TOP w0.14: C178.2 225.55,49.36 225.73,49.54 225.73,49.77 225.55,49.95 v1(225.44,49.95)
  IN4 w0.086: v2(258.94,45.15) 259.13,44.96 259.13,44.9 259.02,44.78 258.02,44.78 257.8,44.57 255.14,44.57 254,45.71 250.84,45.71 250.75,45.8 250.75,46.62 250.56,46.81 250.01,46.81 249.83,46.63 249.83,45.8 249.74,45.71 248.58,45.71 248.38,45.91 239.11,45.91 238.84,46.19 238.84,46.31 239.69,47.16 239.69,47.42 239.29,47.82 239.03,47.82 238.18,46.97 238.06,46.97 237.76,47.27 237.76,47.39 240.04,49.67 240.04,49.98 239.67,50.35 239.41,50.35 237.11,48.04 236.99,48.04 236.69,48.34 236.69,48.46 238.25,50.03 238.25,50.29 237.86,50.68 237.6,50.68 236.03,49.12 235.91,49.12 235.54,49.49 235.54,49.74 237.17,51.37 237.17,51.75 236.81,52.11 236.38,52.11 235.16,50.89 234.84,50.89 234.12,51.62 227.77,51.62 226.78,52.61 225.56,52.61 224.98,52.03 224.98,51.27 225.74,50.51 225.74,50.25 v1(225.44,49.95)
PCIE_TXN17_TBT_C: length 4.6
  TOP w0.089: 224.34,47.41 223.95,47.02 223.95,45.72 223.86,45.63 223.77,45.63 223.69,45.7 U14.A42
  TOP w0.14: 224.34,47.41 224.44,47.41 225.71,48.68 225.71,48.83 225.63,48.91 C178.1
PCIE_TXN18_TBT: length 66.9
  TOP w0.089: v2(260.89,45.01) 260.99,45.01 261.13,45.14 261.13,45.69 260.96,45.85 260.96,46.26 U7.T22
  TOP w0.14: C177.2 224.43,49.61 224.43,49.81 224.57,49.95 v1(224.68,49.95)
  IN4 w0.086: v2(260.89,45.01) 261.01,45.01 261.09,44.92 261.09,44.38 260.93,44.21 258.26,44.21 258.05,44.01 254.76,44.01 253.82,44.95 246.52,44.95 246.28,44.71 245.83,44.71 245.48,45.05 244.42,45.05 244.01,44.64 242.84,44.64 242.28,45.2 238.86,45.2 234.97,49.09 234.97,49.98 233.89,51.06 228.57,51.06 227.75,50.24 227.75,49.1 227.66,49.01 225.82,49.01 225.64,48.83 225.64,48.27 225.82,48.09 227.66,48.09 227.75,48 227.75,47.61 227.1,46.96 225.73,46.96 224.75,47.95 224.49,47.95 224.09,47.55 224.09,47.29 225.15,46.24 225.15,46.12 224.85,45.82 224.73,45.82 223.67,46.87 223.42,46.87 223.02,46.48 223.02,46.22 224.07,45.16 224.07,45.04 223.8,44.76 222.77,44.76 222.25,45.28 222.25,47.19 224.3,49.24 224.3,49.83 224.43,49.95 v1(224.68,49.95)
PCIE_TXN18_TBT_C: length 5.3
  TOP w0.089: U14.C42 223.89,44.71 223.84,44.66 223.72,44.66 223.61,44.76 223.61,45.45 223.44,45.62 223.44,47.05 224.31,47.92 224.31,48.12 224.36,48.16 224.36,48.25
  TOP w0.127: 224.36,48.28 224.36,48.25
  TOP w0.14: C177.1 224.53,48.91 224.36,48.73 224.36,48.28
PCIE_TXN19_TBT: length 64.3
  TOP w0.089: v2(263.27,45.03) 263.16,45.15 263.16,45.77 263.26,45.87 263.26,46.05 263.26,46.2 263.04,46.43 U7.M22
  TOP w0.14: v1(228.56,48.98) 228.4,49.14 228.18,49.14 228.02,48.98 C181.2
  IN4 w0.086: v2(263.27,45.03) 263.08,44.84 263.08,44.57 263.17,44.48 263.41,44.48 263.59,44.3 263.59,43.84 263.24,43.49 262.72,43.49 262.72,43.49 258.55,43.49 258.32,43.26 255.1,43.26 254.59,42.75 253.95,42.75 252.6,44.1 246.84,44.1 246.36,43.62 244.44,43.62 243.5,42.68 241.12,42.68 240.08,43.72 239.02,43.72 236.84,45.9 236.32,45.9 236.21,45.79 236.21,45.1 236.01,44.9 235.36,44.9 235.16,45.1 235.16,46.78 234.81,47.13 233.88,47.13 233.43,46.68 233.43,46.14 233.25,45.95 232.69,45.95 232.51,46.14 232.51,46.84 232.42,46.93 232.03,46.93 231.88,46.78 231.88,45.04 231.65,44.81 230.84,44.81 230.6,45.06 230.6,46.67 230.51,46.75 230.11,46.75 230,46.65 230,45.63 229.77,45.39 229.21,45.39 228.94,45.66 228.94,46.97 229.88,47.91 233.13,47.91 233.67,48.45 233.67,49.15 232.52,50.3 230.66,50.3 229.58,49.21 228.8,49.21 228.57,48.98 v1(228.56,48.98)
PCIE_TXN19_TBT_C: length 7
  TOP w0.089: 225.8,47.39 225.78,47.36 225.71,47.36 224.5,46.15 224.5,45.42 224.29,45.21 224.29,44.93 224.36,44.86 U14.C44
  TOP w0.14: C181.1 227.57,49.13 227.4,49.31 227.2,49.31 226.93,49.04 226.93,48.9 227.24,48.58 227.24,48.39 227.17,48.31 226.73,48.31 225.8,47.39
PCIE_TXN20_TBT: length 65
  TOP w0.089: U7.H22 265.1,46.27 265.1,46.08 265.1,45.79 265,45.69 265,45.11 v2(265.14,44.97)
  TOP w0.14: v1(231.36,49.36) 231.13,49.13 230.82,49.13 C174.2
  IN4 w0.086: v2(265.14,44.97) 264.98,44.81 264.98,44.61 264.75,44.38 264.42,44.38 264.31,44.28 264.31,43.96 264.44,43.83 265.54,43.83 265.91,44.2 265.91,44.82 266.12,45.03 267.01,45.03 267.26,44.77 267.26,43.98 267.35,43.89 267.76,43.89 267.87,44 267.87,44.76 268.15,45.04 269,45.04 269.34,44.7 269.34,43.36 268.92,42.93 258.81,42.93 258.53,42.65 255.33,42.65 254.72,42.04 252.99,42.04 252.66,42.37 252.66,43.09 252.29,43.45 249.38,43.45 248.98,43.06 244.89,43.06 243.88,42.04 240.46,42.04 239.67,42.84 238.83,42.84 237.35,44.31 234.74,44.31 233.65,45.4 233.03,45.4 231.81,44.18 229.18,44.18 228.23,45.13 228.23,47.07 230.27,49.11 231.11,49.11 v1(231.36,49.36)
PCIE_TXN20_TBT_C: length 7.2
  TOP w0.089: 226.12,47.07 226.09,47.04 226.02,47.04 225.94,46.96 225.61,46.96 224.88,46.23 224.88,45.89 U14.A44
  TOP w0.14: 226.12,47.07 226.92,47.87 228.47,47.87 229.55,48.95 230.05,48.95 230.19,49.09 C174.1
PCIE_TXN21_SSD: length 88.8
  TOP w0.102: U14.G47 226.43,43.31 227.69,43.31 228.47,44.09 229.36,44.09 229.39,44.06 229.42,44.06
  TOP w0.14: 229.42,44.06 231.05,44.06 231.19,43.92 231.19,43.73 v1(230.99,43.53)
  IN1 w0.086: v1(179.53,18.33) 179.76,18.1 179.76,17.85 180.31,17.3 182.79,17.3 184.15,18.66 188.67,18.66 190.23,20.22 190.23,20.76 190.84,21.37 192.56,21.37 193.32,20.6 195.87,20.6 196.11,20.84 197.55,20.84 198.37,21.66 198.98,21.66 199.66,22.34 199.66,23.99 200.88,25.21 203.3,25.21 203.7,25.61 203.7,27.2 204.61,28.12 205.38,28.12 205.75,28.49 205.8,28.49 206.06,28.75 206.93,28.75 207.2,29.02 208.1,29.02 208.21,28.91 210.77,28.91 211.25,28.44 211.73,28.44 212.36,29.06 221.6,29.06 221.99,28.67 222.62,28.67 223.44,27.84 223.7,27.84 224.04,27.51 224.59,27.51 224.69,27.41 225.91,27.41 227.58,29.07 230.48,29.07 231.33,29.92 231.33,30.9 232.41,31.99 232.41,33.3 233.31,34.19 233.31,39.96 233.01,40.25 233.01,40.89 233.91,41.79 233.91,42.44 233.09,43.27 233.09,43.93 232.76,44.26 231.54,44.26 231.24,43.97 231.24,43.78 v1(230.99,43.53)
  BOTTOM w0.14: C913.2 180.13,19.84 179.83,19.84 179.53,19.54 v1(179.53,18.33)
PCIE_TXN21_SSD_R: length 10.6
  BOTTOM w0.14: CN18.47 188.82,16.45 188.74,16.37 188.67,16.37 186.24,18.8 185.43,18.8 184.6,19.63 184.6,19.75 184.17,20.18 181.96,20.18 181.47,19.69 181.24,19.69 181.1,19.83 C913.1
PCIE_TXN22_SSD: length 80.9
  TOP w0.102: U14.H47 226.19,42.28 226.42,42.06 226.62,42.06 226.75,41.92 227.74,41.92 228.49,41.17 229.22,41.17 229.25,41.14 229.36,41.14
  TOP w0.14: 229.36,41.14 231.77,41.14 232.26,41.64 232.26,41.82 v1(232.49,42.04)
  IN1 w0.086: v1(232.49,42.04) 232.22,41.78 232.22,40.23 232.66,39.8 232.66,34.33 230.84,32.52 230.84,31.94 230.75,31.85 230.75,30.24 230.14,29.63 226.52,29.63 226.35,29.47 225.31,29.47 224.93,29.09 223.72,29.09 222.75,30.06 208.57,30.06 208.11,29.6 206.94,29.6 206.78,29.44 206.23,29.44 205.9,29.78 204.46,29.78 203.67,28.99 203.67,28.38 203.2,27.91 201.95,27.91 200.04,26 200.04,25.24 198.98,24.18 198.98,23.18 198.53,22.74 198,22.74 196.7,21.44 195.74,21.44 195.46,21.16 193.56,21.16 192.65,22.06 190.7,22.06 189.59,20.95 189.59,20.37 188.44,19.22 184.06,19.22 183.26,20.02 181.56,20.02 181.21,20.37 181.21,20.54 v1(180.99,20.77)
  BOTTOM w0.14: v1(180.99,20.77) 181.16,20.94 181.16,21.27 181.46,21.57 182.24,21.57 C899.2
PCIE_TXN22_SSD_R: length 8.8
  BOTTOM w0.14: CN18.35 188.77,19.45 188.54,19.22 188.28,19.22 187.72,19.78 187.72,21.08 186.67,22.13 184.21,22.13 183.6,21.52 183.46,21.52 C899.1
PCIE_TXN23_SSD: length 78
  TOP w0.102: v1(229.73,43.51) 229.51,43.29 229.51,43.1 229.25,42.84 227.51,42.84 227.49,42.82 U14.G49
  IN1 w0.086: v1(180.83,23.09) 180.97,22.95 180.97,22.19 181.29,21.87 181.59,21.87 182.09,21.37 182.7,21.37 183.99,20.08 187.76,20.08 188.42,20.75 188.42,21.72 189.86,23.16 193.13,23.16 193.95,22.33 196.22,22.33 197.94,24.04 197.94,24.58 198.27,24.91 198.87,24.91 199.38,25.42 199.38,26.25 200.63,27.5 200.63,28.96 201.55,29.88 203.4,29.88 203.94,30.43 206.01,30.43 206.36,30.77 207.23,30.77 207.65,31.19 208.7,31.19 208.79,31.27 209.71,31.27 209.92,31.06 211.72,31.06 212.14,30.64 223.27,30.64 223.62,30.28 223.98,30.28 224.18,30.08 225.94,30.08 227.44,31.58 229.69,31.58 230.29,32.18 230.29,32.83 231.34,33.87 231.34,39.75 231.04,40.04 231.04,42.35 230.67,42.73 229.67,42.73 229.52,42.88 229.52,43.3 v1(229.73,43.51)
  BOTTOM w0.14: v1(180.83,23.09) 180.99,23.25 180.99,23.49 181.43,23.93 181.94,23.93 C876.2
PCIE_TXN23_SSD_R: length 8
  BOTTOM w0.14: C876.1 182.91,24 183.08,23.83 183.28,23.83 183.52,24.08 184.01,24.08 184.36,24.44 186.37,24.44 188.46,22.35 188.7,22.35 188.8,22.45 CN18.23
PCIE_TXN24_SSD: length 79.9
  TOP w0.102: U14.G46 225.7,42.86 225.82,42.75 226.9,42.75 227.12,42.53 227.69,42.53 227.81,42.64 229.36,42.64 229.63,42.37 229.63,42.21 v1(229.83,42.02)
  IN1 w0.086: v1(180.87,25.64) 181.08,25.42 181.08,25.28 180.8,25 180.8,24.54 181.95,23.39 181.95,22.29 182.3,21.95 182.96,21.95 184.27,20.64 186.5,20.64 187.03,21.17 187.03,22.6 188.15,23.73 193.42,23.73 194.26,22.89 195.92,22.89 196.7,23.67 196.7,24.44 197.34,25.07 197.34,25.4 199.42,27.48 199.42,29.26 200.6,30.45 202.53,30.45 202.96,30.88 203.36,30.88 204.87,32.38 211.23,32.38 212.4,31.22 223.7,31.22 223.98,30.94 224.21,30.94 224.49,30.66 225.74,30.66 226.19,31.12 226.19,32.03 227.54,33.38 230.01,33.38 230.73,34.11 230.73,39.46 229.62,40.57 229.62,41.81 v1(229.83,42.02)
  BOTTOM w0.14: C862.2 182.34,26.6 181.37,26.6 181.04,26.27 181.04,25.82 v1(180.87,25.64)
PCIE_TXN24_SSD_R: length 7.2
  BOTTOM w0.14: C862.1 183.62,26.53 183.97,26.53 184.29,26.85 186.52,26.85 188.03,25.34 188.66,25.34 188.78,25.45 CN18.11
PCIE_TXP9_SSD: length 64.7
  TOP w0.089: 218.52,48.41 218.64,48.29 218.85,48.29 220.08,47.06 220.08,44.94 220.21,44.81 220.21,44.43 U14.D34
  TOP w0.14: v1(218.05,49.22) 217.85,49.02 217.85,48.83 218.24,48.44 218.5,48.44 218.52,48.41
  IN1 w0.086: v1(183.21,49.8) 182.92,49.52 182.92,49.44 182.92,48.97 183.32,48.57 183.82,48.57 184.05,48.8 184.87,48.8 185.1,48.57 185.48,48.57 185.55,48.64 185.55,48.8 185.73,48.99 186.09,48.99 186.28,48.8 186.28,48.66 186.36,48.57 186.6,48.57 186.68,48.66 186.68,48.83 186.87,49.01 187.27,49.01 187.45,48.83 187.45,48.7 187.54,48.61 187.8,48.61 187.88,48.7 187.88,49.18 188.06,49.37 188.41,49.37 188.6,49.17 188.6,48.66 188.69,48.57 188.89,48.57 188.99,48.68 188.99,49.66 189.18,49.85 189.54,49.85 189.72,49.66 189.72,48.94 189.81,48.85 190.03,48.85 190.11,48.94 190.11,49.63 190.33,49.85 190.65,49.85 190.83,49.66 190.83,48.94 190.92,48.85 191.14,48.85 191.23,48.94 191.23,49.66 191.41,49.85 191.76,49.85 191.95,49.66 191.95,48.94 192.03,48.85 192.25,48.85 192.34,48.94 192.34,49.63 192.55,49.85 192.99,49.85 193.17,49.66 193.17,49.02 193.25,48.94 194.46,48.94 194.62,49.1 194.62,50.19 194.95,50.52 197.14,50.52 197.23,50.6 197.23,50.85 197.12,50.96 197.12,51.29 197.4,51.57 197.84,51.57 198.1,51.3 198.1,50.58 198.29,50.39 198.52,50.39 198.62,50.49 198.62,50.86 198.84,51.07 199.2,51.07 200.31,49.96 201.21,49.96 201.29,50.05 201.29,50.36 201.47,50.54 201.8,50.54 202.01,50.33 202.01,50.05 202.1,49.96 202.58,49.96 203.04,50.42 203.04,51.08 203.4,51.44 203.4,52.18 203.61,52.38 207.4,52.38 207.49,52.47 207.49,52.71 207.7,52.93 208.37,52.93 208.64,52.66 208.64,52.14 208.76,52.02 217.74,52.02 218.24,51.52 218.24,50.7 217.65,50.11 217.65,49.62 v1(218.05,49.22)
  BOTTOM w0.14: v1(183.21,49.8) 183,50.01 183,50.18 183.26,50.44 183.55,50.44 C741.2
PCIE_TXP9_SSD_R: length 5.2
  BOTTOM w0.14: CN15.13 188.82,50 188.66,50.16 188.51,50.16 188.33,50.34 184.83,50.34 184.69,50.2 C741.1
PCIE_TXP10_SSD: length 64.4
  TOP w0.089: U14.B35 220.38,45.15 220.38,45.22 220.28,45.32 220.28,47.25 219.42,48.11 219.42,48.11 219.26,48.28 219.21,48.28
  TOP w0.14: 219.21,48.28 218.53,48.95 218.53,50.13 218.08,50.59 217.21,50.59 v1(216.95,50.32)
  IN1 w0.086: v1(183.03,47.11) 183.03,47.37 183.11,47.46 183.81,47.46 183.87,47.39 183.87,46.59 184.06,46.41 184.43,46.41 184.62,46.59 184.62,47.73 184.74,47.85 185.01,47.85 185.1,47.77 185.1,47.49 185.28,47.3 185.61,47.3 185.82,47.51 185.82,47.77 185.9,47.85 186.12,47.85 186.21,47.77 186.21,46.79 186.39,46.61 186.75,46.61 186.93,46.79 186.93,47.77 187.02,47.85 187.41,47.85 187.5,47.76 187.5,47.38 187.68,47.2 188.32,47.2 188.53,47.4 188.53,47.6 188.72,47.79 188.9,47.79 188.99,47.71 188.99,46.79 189.17,46.61 189.49,46.61 189.71,46.83 189.71,47.63 189.81,47.73 189.98,47.73 190.17,47.92 190.17,48.04 190.25,48.13 190.47,48.13 190.56,48.04 190.56,47.92 190.74,47.73 191.1,47.73 191.28,47.92 191.28,48.05 191.37,48.14 191.59,48.14 191.67,48.05 191.67,47.92 191.85,47.73 192.21,47.73 192.39,47.92 192.39,48.05 192.48,48.14 192.7,48.14 192.78,48.05 192.78,47.92 192.97,47.73 193.32,47.73 193.51,47.92 193.51,48.13 193.59,48.22 193.8,48.22 193.9,48.12 193.9,47.92 194.08,47.73 194.61,47.73 194.79,47.92 194.79,48.24 195.16,48.61 196.26,48.61 196.53,48.88 196.53,49.71 196.61,49.8 196.87,49.8 196.97,49.7 196.97,49.35 197.15,49.16 197.51,49.16 197.75,49.41 197.75,49.58 197.84,49.67 198.22,49.67 198.64,49.24 199.17,49.24 199.49,49.57 199.68,49.57 200.01,49.24 202.88,49.24 203.76,50.13 203.76,50.78 204.17,51.19 204.17,51.56 204.27,51.66 204.77,51.66 204.86,51.56 204.86,51.43 205.08,51.21 205.42,51.21 205.87,51.66 206.23,51.66 206.52,51.37 206.52,51.01 206.7,50.84 207.42,50.84 207.74,51.16 207.74,51.51 207.89,51.66 208.04,51.66 208.23,51.46 208.23,51.06 208.4,50.89 208.85,50.89 209.2,51.25 209.62,51.25 209.7,51.16 209.7,50.64 209.89,50.45 210.27,50.45 210.49,50.68 210.49,51.21 210.58,51.3 210.79,51.3 210.88,51.21 210.88,50.45 211.08,50.25 211.42,50.25 211.6,50.43 211.6,51.21 211.69,51.3 211.91,51.3 211.99,51.21 211.99,51.08 212.19,50.88 214.26,50.88 214.65,51.27 215.73,51.27 216.24,50.77 217.17,50.77 217.26,50.68 217.26,50.5 217.08,50.32 v1(216.95,50.32)
  BOTTOM w0.14: C769.2 183.53,47.41 183.32,47.41 v1(183.03,47.11)
PCIE_TXP10_SSD_R: length 5.2
  BOTTOM w0.14: C769.1 185.02,47.37 186.88,47.37 187.02,47.24 188.54,47.24 188.77,47 CN15.25
PCIE_TXP11_SSD: length 64.3
  TOP w0.089: 220.15,48.11 220.65,47.61 220.65,45.48 220.76,45.37 220.76,44.98 220.92,44.7 U14.C36
  TOP w0.14: v1(214.98,49) 215.24,49.25 215.44,49.25 215.86,49.66 215.86,51.7 216.12,51.97 218.47,51.97 219.26,51.18 219.26,49.24 220.09,48.41 220.09,48.17 220.15,48.11
  IN1 w0.086: v1(214.98,49) 214.69,49.29 212.31,49.29 211.05,48.04 208.81,48.04 208.39,47.62 208.39,46.59 207.65,45.85 206.65,45.85 206.38,46.12 206.38,46.43 206.2,46.62 205.66,46.62 205.42,46.86 205.42,47.18 205.6,47.37 206.27,47.37 206.38,47.48 206.38,47.66 206.02,48.02 197.55,48.02 197,47.47 197,47.06 196.82,46.88 196.41,46.88 196.26,46.73 196.26,46.57 196.37,46.47 196.77,46.47 197,46.24 197,45.93 196.78,45.71 195.38,45.71 195.26,45.59 195.26,45.19 195.07,45 194.68,45 194.49,45.18 194.49,45.55 194.34,45.71 194.13,45.71 194.03,45.61 194.03,44.29 193.79,44.05 193.44,44.05 193.25,44.25 193.25,45.07 193.16,45.15 192.94,45.15 192.86,45.07 192.86,44.18 192.68,43.99 192.35,43.99 192.14,44.2 192.14,45.07 192.05,45.15 191.83,45.15 191.75,45.07 191.75,44.4 191.56,44.22 191.23,44.22 191.02,44.42 191.02,45.07 190.94,45.15 190.55,45.15 190.33,44.94 190.33,44.18 190.15,44 187.15,44 186.32,44.82 183.91,44.82 183.5,44.41 183.22,44.41 v1(182.98,44.17)
  BOTTOM w0.14: C780.2 183.53,44.36 183.17,44.36 v1(182.98,44.17)
PCIE_TXP11_SSD_R: length 5.2
  BOTTOM w0.14: CN15.37 188.56,44 188.45,44.12 186.95,44.12 186.72,44.35 185.05,44.35 C780.1
PCIE_TXP12_SSD: length 65.5
  TOP w0.089: 220.99,48.07 221.04,48.02 221.04,45.63 221.26,45.41 221.26,44.52 221.34,44.43 221.34,43.91 U14.E37
  TOP w0.102: 220.97,48.09 220.99,48.07
  TOP w0.14: 220.97,48.09 220.9,48.17 220.9,48.61 220.02,49.48 220.02,51.67 219,52.68 215.63,52.68 214.99,52.04 214.99,51.29 213.77,50.07 213.77,49.13 214.04,48.86 214.04,48.31 213.68,47.95 v1(213.68,47.76)
  IN1 w0.086: v1(213.68,47.76) 213.68,47.99 213.87,48.18 214,48.18 214.55,47.63 214.55,45.27 214.18,44.91 209.37,44.91 208.9,45.38 206.27,45.38 205.77,45.87 202.38,45.87 202.29,45.96 202.29,46.49 202.39,46.59 203.22,46.59 203.47,46.84 203.47,47.31 203.17,47.62 197.73,47.62 197.41,47.29 197.41,45.42 196.88,44.9 195.53,44.9 193.88,43.25 191.35,43.25 190.88,42.79 189.47,42.79 189.26,42.99 187.14,42.99 185.7,44.43 184.53,44.43 183.55,43.44 183.55,43.03 v1(183.36,42.84)
  BOTTOM w0.14: C784.2 183.91,41.2 183.67,41.43 183.45,41.43 183.15,41.73 183.15,42.33 183.41,42.59 183.41,42.79 v1(183.36,42.84)
PCIE_TXP12_SSD_R: length 5.2
  BOTTOM w0.14: CN15.49 188.75,41 188.64,41.12 186.96,41.12 186.77,41.31 185.06,41.31 C784.1
PCIE_TXP14_LAN: length 254
  TOP w0.14: R169.2 221.78,50.44 221.63,50.6 221.63,50.95 v1(221.78,51.1)
  IN1 w0.086: v1(221.78,51.1) 221.42,51.47 221.42,51.9 221.05,52.27 220,52.27 218.51,53.77 210,53.77 209.09,54.68 206.98,54.68 206.43,54.13 202.27,54.13 201.35,53.21 200.32,53.21 200.22,53.31 196.68,53.31 196.18,52.82 195.44,52.82 195.08,52.46 193.99,52.46 193.38,51.86 192.24,51.86 191.98,51.59 190.65,51.59 190.43,51.81 190.43,53.16 189.05,54.54 186.46,54.54 182.74,50.82 182.27,50.82 181.83,50.38 181.83,46.57 182.31,46.09 182.31,45.29 181.68,44.65 181.68,39.19 175,32.52 101.14,32.52 100.5,33.17 92.91,33.17 92.75,33 89.9,33 88.62,34.28 86.59,34.28 86.32,34.56 84.84,34.56 84.58,34.82 82.9,34.82 82.8,34.91 74.8,34.91 74.33,35.39 69.89,35.39 69.55,35.05 68.74,35.05 68.41,35.37 64.31,35.37 63.85,35.83 59.71,35.83 59.13,35.25 57.81,35.25 56.49,36.57 53.96,36.57 52.88,37.66 49.73,37.66 49.25,37.18 48.46,37.18 46.76,38.88 38.96,38.88 38.63,39.21 34.41,39.21 33.65,39.97 31.47,39.97 30,41.44 28.74,41.44 27.92,40.62 27.92,39.96 25.75,37.79 22.18,37.79 19.71,40.26 19.71,41.95 18.94,42.71 18.05,42.71 17.67,42.33 16.38,42.33 15.69,43.02 15.69,43.74 14.78,44.65 13.63,44.65 12.62,43.64 12.62,39.85 12.2,39.43 12.2,36.37 11.2,35.37 10.9,35.37 v1(10.65,35.62)
  BOTTOM w0.14: CN17.44 11.35,35.5 11.22,35.37 10.9,35.37 v1(10.65,35.62)
PCIE_TXP14_LAN_C: length 6.3
  TOP w0.089: 222.07,48.28 222.08,48.26 222.08,48.2 222.65,47.64 222.65,45.74 222.28,45.38 222.28,44.88 222.4,44.76 222.4,44.43 U14.D39
  TOP w0.14: 222.07,48.28 221.97,48.37 221.97,49.04 221.83,49.18 221.83,49.43 R169.1
PCIE_TXP15_WLAN: length 4.2
  TOP w0.14: C231.2 56.71,40.88 56.87,41.04 56.87,41.24 56.55,41.56 55.81,41.56 55.67,41.42 v1(55.67,41.29)
  BOTTOM w0.14: CN16.35 56.61,41.25 56.37,41.49 55.81,41.49 55.67,41.35 v1(55.67,41.29)
PCIE_TXP15_WLAN_C: length 202.8
  TOP w0.089: 223.13,48.28 223.13,48.26 223.05,48.17 223.05,45.49 222.95,45.4 222.95,44.86 222.68,44.59
  TOP w0.102: 222.68,44.59 U14.C40
  TOP w0.14: v1(55.59,39.57) 55.76,39.4 56,39.4 56.14,39.54 56.62,39.54 56.74,39.65 56.74,39.75 C231.1 ; 223.13,48.28 223.13,50.16 224.19,51.21 224.19,51.59 v1(224.39,51.79)
  IN1 w0.086: v1(224.39,51.79) 224.07,52.11 224.07,52.73 222.87,53.93 222.27,53.93 222.03,54.16 221.01,54.16 219.53,55.64 213.27,55.64 212.81,56.11 210.51,56.11 209.69,56.93 200.41,56.93 199.86,56.38 196.36,56.38 195.81,56.93 193,56.93 191.79,58.13 188.5,58.13 188.33,57.95 187.03,57.95 185.06,55.98 184.27,55.98 183.33,55.04 183.33,54.51 182.17,53.35 181.73,53.35 179.67,51.29 179.67,39.87 174.28,34.48 151.17,34.48 151.08,34.38 102.22,34.38 100.63,35.97 96.41,35.97 96,36.38 93.15,36.38 92,35.23 90.28,35.23 88.79,36.73 85.99,36.73 85.59,37.13 83.51,37.13 83.11,36.73 81.3,36.73 80.87,37.16 78.89,37.16 78.79,37.27 75.03,37.27 74.65,37.64 72.23,37.64 72.08,37.8 69.7,37.8 68.88,38.62 66.64,38.62 66.38,38.88 64.38,38.88 64.01,38.52 57.69,38.52 56.77,39.44 56.18,39.44 56.03,39.29 55.87,39.29 v1(55.59,39.57)
PCIE_TXP17_TBT: length 63.6
  TOP w0.089: v2(259.49,45.15) 259.31,45.32 259.31,45.54 259.59,45.82 259.59,46.16 259.53,46.22 259.4,46.22 259.36,46.17 U7.Y23
  TOP w0.14: C179.2 226,49.57 226,49.75 v1(226.21,49.95)
  IN4 w0.086: v1(226.21,49.95) 225.91,50.25 225.91,50.58 225.15,51.34 225.15,51.96 225.63,52.44 226.71,52.44 227.7,51.45 234.05,51.45 234.78,50.72 235.22,50.72 236.45,51.95 236.74,51.95 237.01,51.68 237.01,51.44 235.38,49.8 235.38,49.42 235.84,48.95 236.1,48.95 237.67,50.52 237.79,50.52 238.09,50.22 238.09,50.1 236.52,48.53 236.52,48.27 236.92,47.88 237.18,47.88 239.48,50.18 239.6,50.18 239.88,49.91 239.88,49.73 237.6,47.46 237.6,47.2 237.99,46.8 238.25,46.8 239.1,47.65 239.22,47.65 239.52,47.35 239.52,47.23 238.67,46.38 238.67,46.12 239.05,45.75 248.31,45.75 248.51,45.55 249.81,45.55 249.99,45.73 249.99,46.56 250.08,46.65 250.49,46.65 250.59,46.55 250.59,45.73 250.77,45.55 253.93,45.55 255.07,44.4 257.87,44.4 258.09,44.62 259.09,44.62 259.29,44.83 259.29,44.96 v2(259.49,45.15)
PCIE_TXP17_TBT_C: length 4.7
  TOP w0.089: U14.B42 223.86,45.37 224.13,45.64 224.13,46.94 224.39,47.2 224.61,47.2 224.72,47.31
  TOP w0.14: 224.72,47.31 225.86,48.46 225.98,48.57 225.98,48.68 C179.1
PCIE_TXP18_TBT: length 66.9
  TOP w0.089: U7.T23 261.2,46.13 261.28,46.22 261.36,46.22 261.43,46.15 261.43,45.79 261.3,45.66 261.3,45.14 v2(261.43,45.01)
  TOP w0.14: C176.2 224.16,49.59 224.16,49.71 v1(223.92,49.95)
  IN4 w0.086: v2(261.43,45.01) 261.26,44.83 261.26,44.31 260.99,44.05 258.32,44.05 258.12,43.84 254.69,43.84 253.75,44.78 246.59,44.78 246.35,44.54 245.76,44.54 245.42,44.89 244.49,44.89 244.08,44.48 242.77,44.48 242.22,45.04 238.79,45.04 234.8,49.03 234.8,49.91 233.82,50.89 228.64,50.89 227.92,50.17 227.92,49.03 227.73,48.85 225.89,48.85 225.8,48.76 225.8,48.34 225.89,48.25 227.73,48.25 227.92,48.07 227.92,47.54 227.17,46.8 225.67,46.8 224.68,47.78 224.56,47.78 224.26,47.48 224.26,47.36 225.31,46.31 225.31,46.05 224.92,45.65 224.66,45.65 223.61,46.71 223.48,46.71 223.18,46.41 223.18,46.29 224.24,45.23 224.24,44.97 223.86,44.6 222.7,44.6 222.09,45.22 222.09,47.26 224.14,49.3 224.14,49.74 v1(223.92,49.95)
PCIE_TXP18_TBT_C: length 5.3
  TOP w0.089: 224.09,48.28 224.09,48.18 224.13,48.14 224.13,47.99 223.26,47.12 223.26,45.55 223.43,45.38 223.43,44.69 U14.D42
  TOP w0.14: 224.09,48.28 224.09,48.74 C176.1
PCIE_TXP19_TBT: length 64.3
  TOP w0.089: v2(262.73,45.03) 262.77,45.03 262.98,45.24 262.98,45.68 262.8,45.87 262.8,46.09 262.88,46.17 262.95,46.17 263.04,46.08 U7.M23
  TOP w0.14: C171.2 228.02,49.53 228.14,49.4 228.38,49.4 228.57,49.6 v1(228.57,49.65)
  IN4 w0.086: v2(262.73,45.03) 262.92,44.84 262.92,44.5 263.1,44.32 263.34,44.32 263.43,44.23 263.43,43.91 263.18,43.65 262.79,43.65 262.79,43.65 258.48,43.65 258.26,43.43 255.03,43.43 254.52,42.92 254.02,42.92 252.67,44.26 246.77,44.26 246.29,43.78 244.37,43.78 243.43,42.84 241.19,42.84 240.15,43.89 239.09,43.89 236.91,46.06 236.25,46.06 236.04,45.85 236.04,45.17 235.94,45.07 235.42,45.07 235.33,45.17 235.33,46.85 234.88,47.29 233.81,47.29 233.27,46.75 233.27,46.21 233.18,46.12 232.76,46.12 232.67,46.21 232.67,46.91 232.49,47.09 231.96,47.09 231.72,46.85 231.72,45.11 231.58,44.98 230.91,44.98 230.76,45.13 230.76,46.73 230.58,46.92 230.04,46.92 229.84,46.71 229.84,45.7 229.7,45.56 229.28,45.56 229.11,45.73 229.11,46.91 229.95,47.75 233.2,47.75 233.83,48.38 233.83,49.21 232.59,50.46 230.59,50.46 229.51,49.37 228.66,49.37 228.57,49.46 v1(228.57,49.65)
PCIE_TXP19_TBT_C: length 7.1
  TOP w0.089: 225.61,47.58 225.57,47.53 225.57,47.47 224.32,46.22 224.32,45.49 224.11,45.28 224.11,44.85 224.31,44.65 U14.D43
  TOP w0.14: 225.61,47.58 226.67,48.63 226.67,49.15 227.09,49.57 227.45,49.57 C171.1
PCIE_TXP20_TBT: length 65
  TOP w0.089: v2(264.59,44.97) 264.71,44.97 264.82,45.08 264.82,45.68 264.64,45.86 264.64,46.16 264.72,46.24 264.81,46.24 264.88,46.18 U7.H23
  TOP w0.14: v1(231.36,48.51) 231.36,48.51 231.01,48.86 230.79,48.86 230.64,48.71 C184.2
  IN4 w0.086: v1(231.36,48.51) 231.44,48.59 231.44,48.83 231.32,48.95 230.34,48.95 228.4,47 228.4,45.19 229.25,44.35 231.74,44.35 232.96,45.56 233.72,45.56 234.81,44.48 237.42,44.48 238.9,43 239.74,43 240.53,42.21 243.81,42.21 244.82,43.22 248.91,43.22 249.31,43.62 252.36,43.62 252.82,43.15 252.82,42.43 253.05,42.21 254.65,42.21 255.26,42.82 258.46,42.82 258.74,43.09 268.85,43.09 269.18,43.42 269.18,44.63 268.94,44.87 268.22,44.87 268.04,44.69 268.04,43.93 267.83,43.73 267.28,43.73 267.1,43.91 267.1,44.7 266.94,44.86 266.19,44.86 266.08,44.75 266.08,44.13 265.61,43.66 264.37,43.66 264.15,43.89 264.15,44.35 264.35,44.55 264.68,44.55 264.81,44.68 264.81,44.86 264.7,44.97 v2(264.59,44.97)
PCIE_TXP20_TBT_C: length 7.2
  TOP w0.089: 226.04,46.78 226.02,46.78 226.01,46.79 225.68,46.79 225.05,46.16 225.05,45.68 224.8,45.43 U14.B44
  TOP w0.14: C184.1 230.05,48.69 229.66,48.69 228.58,47.6 227.03,47.6 226.2,46.78 226.04,46.78
PCIE_TXP21_SSD: length 88.8
  TOP w0.102: 229.44,44.33 229.42,44.33 229.39,44.3 228.39,44.3 227.61,43.52 226.33,43.52 U14.F46
  TOP w0.14: 229.44,44.33 231.16,44.33 231.46,44.03 231.46,43.67 231.6,43.53 v1(231.84,43.53)
  IN1 w0.086: v1(180.21,18.35) 180.04,18.35 179.93,18.23 179.93,17.91 180.37,17.47 182.72,17.47 184.08,18.83 188.6,18.83 190.06,20.29 190.06,20.82 190.77,21.53 192.63,21.53 193.39,20.77 195.8,20.77 196.04,21.01 197.49,21.01 198.3,21.82 198.91,21.82 199.49,22.4 199.49,24.06 200.81,25.38 203.24,25.38 203.53,25.68 203.53,27.27 204.54,28.28 205.31,28.28 205.68,28.66 205.74,28.66 205.99,28.91 206.86,28.91 207.13,29.19 208.17,29.19 208.28,29.08 210.84,29.08 211.31,28.6 211.66,28.6 212.29,29.23 221.66,29.23 222.06,28.83 222.69,28.83 223.51,28.01 223.77,28.01 224.1,27.67 224.66,27.67 224.76,27.58 225.85,27.58 227.51,29.24 230.41,29.24 231.16,29.99 231.16,30.97 232.25,32.06 232.25,33.37 233.14,34.26 233.14,39.89 232.85,40.18 232.85,40.95 233.75,41.85 233.75,42.37 232.92,43.2 232.92,43.86 232.69,44.1 231.61,44.1 231.41,43.9 231.41,43.65 231.53,43.53 v1(231.84,43.53)
  BOTTOM w0.14: C920.2 180.32,19.43 180.18,19.57 179.94,19.57 179.8,19.43 179.8,18.76 v1(180.21,18.35)
PCIE_TXP21_SSD_R: length 10.6
  BOTTOM w0.14: CN18.49 188.81,15.95 188.65,16.1 188.56,16.1 186.13,18.53 185.32,18.53 184.33,19.51 184.33,19.64 184.06,19.92 182.07,19.92 181.58,19.42 181.4,19.42 181.1,19.13 C920.1
PCIE_TXP22_SSD: length 80.8
  TOP w0.102: U14.H48 226.63,42.32 226.74,42.32 226.79,42.28 226.79,42.17 226.84,42.12 227.82,42.12 228.57,41.37 229.26,41.37 229.29,41.41 229.36,41.41
  TOP w0.14: 229.36,41.41 231.66,41.41 232,41.75 232,41.9 231.81,42.08 231.51,42.08 v1(231.46,42.03)
  IN1 w0.086: v1(181.8,20.77) 181.46,20.77 181.37,20.68 181.37,20.43 181.62,20.18 183.33,20.18 184.13,19.38 188.37,19.38 189.43,20.44 189.43,21.02 190.63,22.23 192.72,22.23 193.63,21.32 195.39,21.32 195.67,21.61 196.64,21.61 197.93,22.9 198.46,22.9 198.81,23.25 198.81,24.25 199.88,25.31 199.88,26.06 201.89,28.07 203.13,28.07 203.51,28.45 203.51,29.06 204.39,29.94 205.97,29.94 206.3,29.61 206.71,29.61 206.87,29.76 208.04,29.76 208.5,30.23 222.82,30.23 223.79,29.25 224.86,29.25 225.24,29.63 226.28,29.63 226.45,29.8 230.07,29.8 230.59,30.31 230.59,31.92 230.68,32.01 230.68,32.59 232.49,34.4 232.49,39.73 232.06,40.16 232.06,42.01 231.94,42.14 231.56,42.14 v1(231.46,42.03)
  BOTTOM w0.14: C904.2 182.43,21.15 182.29,21.3 181.57,21.3 181.43,21.16 181.43,20.91 181.57,20.77 v1(181.8,20.77)
PCIE_TXP22_SSD_R: length 8.8
  BOTTOM w0.14: CN18.37 188.17,18.95 187.45,19.67 187.45,20.97 186.56,21.86 184.32,21.86 183.21,20.75 C904.1
PCIE_TXP23_SSD: length 78
  TOP w0.102: U14.G48 227.04,43.03 227.1,43.09 227.37,43.09 227.41,43.04 229.16,43.04 229.3,43.19 229.3,43.35 229.15,43.5 v1(229.07,43.5)
  IN1 w0.086: v1(181.48,23.11) 181.4,23.11 181.13,22.83 181.13,22.26 181.35,22.04 181.65,22.04 182.16,21.53 182.77,21.53 184.05,20.25 187.69,20.25 188.26,20.82 188.26,21.78 189.79,23.32 193.2,23.32 194.02,22.5 196.16,22.5 197.77,24.11 197.77,24.65 198.2,25.07 198.8,25.07 199.22,25.49 199.22,26.32 200.46,27.57 200.46,29.02 201.49,30.05 203.33,30.05 203.87,30.59 205.95,30.59 206.29,30.93 207.17,30.93 207.58,31.35 208.63,31.35 208.72,31.44 209.77,31.44 209.99,31.22 211.79,31.22 212.21,30.8 223.34,30.8 223.69,30.45 224.05,30.45 224.25,30.24 225.87,30.24 227.37,31.74 229.62,31.74 230.12,32.24 230.12,32.9 231.17,33.94 231.17,39.68 230.88,39.97 230.88,42.28 230.6,42.56 229.6,42.56 229.35,42.81 229.35,43.38 229.23,43.5 v1(229.07,43.5)
  BOTTOM w0.14: C885.2 182.21,23.24 182.21,23.52 182.07,23.66 181.54,23.66 181.25,23.38 181.25,23.28 181.43,23.11 v1(181.48,23.11)
PCIE_TXP23_SSD_R: length 8
  BOTTOM w0.14: C885.1 183.31,23.56 183.38,23.56 183.64,23.82 184.12,23.82 184.47,24.17 186.26,24.17 188.35,22.08 188.67,22.08 188.8,21.95 CN18.25
PCIE_TXP24_SSD: length 79.9
  TOP w0.102: U14.G45 225.59,42.69 225.73,42.54 226.82,42.54 227.04,42.32 227.78,42.32 227.89,42.43 229.28,42.43 229.43,42.28 229.43,42.12 229.33,42.02 v1(229.16,42.02)
  IN1 w0.086: v1(229.16,42.02) 229.3,42.02 229.46,41.86 229.46,40.5 230.56,39.4 230.56,34.17 229.94,33.55 227.47,33.55 226.03,32.1 226.03,31.19 225.67,30.83 224.55,30.83 224.28,31.11 224.05,31.11 223.77,31.39 212.46,31.39 211.3,32.55 204.8,32.55 203.29,31.04 202.9,31.04 202.46,30.61 200.53,30.61 199.25,29.33 199.25,27.55 197.17,25.47 197.17,25.14 196.54,24.51 196.54,23.74 195.85,23.05 194.33,23.05 193.49,23.89 188.08,23.89 186.86,22.67 186.86,21.24 186.43,20.8 184.34,20.8 183.03,22.11 182.37,22.11 182.12,22.36 182.12,23.46 180.97,24.61 180.97,24.93 181.25,25.21 181.25,25.52 181.4,25.67 181.52,25.67 v1(181.55,25.64)
  BOTTOM w0.14: C869.2 182.67,25.96 182.67,26.19 182.53,26.33 181.48,26.33 181.31,26.16 181.31,25.81 181.48,25.64 v1(181.55,25.64)
PCIE_TXP24_SSD_R: length 7.2
  BOTTOM w0.14: CN18.13 188.77,24.95 188.66,25.07 187.92,25.07 186.41,26.58 184.4,26.58 184.08,26.27 183.76,26.27 C869.1
PCIE_WAKE#: length 320.2
  TOP w0.14: v1(235.3,23.23) 235.22,23.16 235.22,21.5 235.07,21.35 233.78,21.35 R449.2 ; Q22.3 v1(252.2,58.98) ; v1(53.43,43.2) 53.97,43.73 Q26.3
  IN2 w0.089: v1(235.3,23.23) 235.3,23.69 237.18,25.57 237.18,27.49 235.86,28.8 235.86,29.82 235.1,30.59 235.1,33.39 234.83,33.66 234.83,34.7 236.34,36.21 236.34,38.11 237.94,39.71 237.94,41.71 239.09,42.85 240,42.85 240.01,42.84 242.96,42.84 244.32,44.2 244.32,44.7 245.39,45.77 245.39,47.84 247.19,49.64 247.19,52.35 250.94,56.1 251.33,56.1 251.51,56.28 251.51,56.83 251.21,57.13 251.21,57.97 252.2,58.95 v1(252.2,58.98)
  IN3 w0.089: v1(53.43,43.2) 53.36,43.12 53.36,38.64 54.41,37.59 59.09,37.59 60.29,36.4 61.57,36.4 61.93,36.04 63.19,36.04 63.94,36.8 66.26,36.8 67.45,35.6 68.76,35.6 69.01,35.85 69.53,35.85 69.7,35.68 71.41,35.68 72.19,34.9 74.92,34.9 75.12,34.71 78.93,34.71 79.51,34.12 82.58,34.12 83.53,35.07 85.62,35.07 86.11,35.56 87.52,35.56 88.99,34.1 90.13,34.1 90.95,33.28 95.41,33.28 95.95,32.75 97.16,32.75 97.45,33.03 98.46,33.03 99.59,34.16 111.04,34.16 111.73,33.47 166.14,33.47 166.31,33.65 179.28,33.65 181.02,35.38 184.82,35.38 189.68,30.52 189.68,27.38 192.57,24.5 192.57,22.87 193.04,22.4 195.39,22.4 195.73,22.05 195.73,21.51 197.46,19.78 205.05,19.78 205.44,19.39 215.99,19.39 216.23,19.63 218.45,19.63 219.22,20.4 223.63,20.4 224.25,21.02 227.45,21.02 229.85,23.43 235.1,23.43 v1(235.3,23.23)
  IN4 w0.086: v1(53.43,43.2) 54.04,43.2 54.93,42.31 54.93,41.44 55.62,40.76 55.62,40.4 55.31,40.1 55.11,40.1 54.72,40.49 52.35,40.49 51.73,39.87 49.61,39.87 49.15,39.41 48.22,39.41 47.62,40.01 45.5,40.01 43.63,38.14 37.29,38.14 35.32,36.17 30.29,36.17 27.44,39.02 26.48,39.02 24.97,37.51 20.98,37.51 19.39,39.09 18.14,39.09 17.03,40.21 14.36,40.21 12.89,38.73 12.89,35.64 12.05,34.8 12.05,31.73 v1(11.02,30.7)
  BOTTOM w0.14: CN17.34 11.22,30.5 v1(11.02,30.7) ; v1(252.2,58.98) 252.41,58.78 R130.1
