# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_I2C_SDA_3V3OR1V8: length 60.7
  TOP w0.14: R507.2 256.65,18.46 256.42,18.23 256.42,17.12 256.01,16.71 256.01,16.46 255.54,15.99 255.54,15.82 v1(255.09,15.36) 255.49,14.95 R583.2 254.84,14.53 254.41,14.1 Q47.3 ; v1(281.86,38.55) 281.86,37.52 R278.2 ; R349.2 256.3,31.83 v1(256.19,31.73)
  IN2 w0.089: v1(281.86,38.55) 281.4,38.09 280.66,38.09 280.14,38.61 270.01,38.61 269.33,39.28 260.3,39.28 257.08,36.07 257.08,34.76 256.66,34.34 256.66,32.63 256.19,32.16 v1(256.19,31.73) 255.96,31.5 255.96,26.98 256.97,25.98 256.97,24.81 257.18,24.59 257.18,23.22 256.77,22.81 256.12,22.81 254.95,21.64 254.95,19.81 255.76,19 255.76,16.03 v1(255.09,15.36)
  BOTTOM w0.14: R1114.2 254.91,15.54 v1(255.09,15.36)
USB_OC0#: length 105.4
  TOP w0.14: v1(221.35,33.13) 221.35,32.88 U14.AH36 ; U26.13 280.6,20.76 280.6,21.36 279.92,22.04 279.56,22.04 v1(279.04,22.04)
  IN1 w0.086: v1(243.62,23.11) 243.47,23.26 239.01,23.26 237.68,24.59 237.68,26.64 237.38,26.95 237.38,27.65 237.33,27.7 237.33,28.79 235.32,30.8 235.32,32.83 234,34.15 234,37.92 v1(234.11,38.02)
  IN2 w0.089: v1(279.04,22.04) 278.24,22.04 278,22.29 277.41,22.29 276.6,21.48 276.6,17.27 274.67,15.33 271.57,15.33 270.6,16.3 269.74,16.3 268.88,15.43 268.7,15.43 268.09,16.04 263.7,16.04 262.92,15.27 261.75,15.27 258.92,12.44 257.36,12.44 256.76,11.84 255.55,11.84 255.02,12.37 252.41,12.37 252.05,12.72 250.05,12.72 249.65,13.12 246.53,13.12 246.4,13.25 244.75,13.25 244.24,13.76 244.24,14.77 245.13,15.66 245.13,16.85 243.71,18.27 243.71,18.99 244.09,19.37 244.09,22.29 243.62,22.76 v1(243.62,23.11) ; v1(221.35,33.13) 221.97,32.52 224.01,32.52 224.58,31.94 226,31.94 226.36,31.59 226.36,30.37 227.15,29.58 229.8,29.58 230.92,30.7 230.92,36.33 231.83,37.24 232.45,37.24 233.24,38.02 v1(234.11,38.02)
  BOTTOM w0.14: R844.2 233.62,38.57 234.46,38.57 234.66,38.78 EC8.2 235.21,38.42 235.17,38.37 C799.1 234.22,37.91 v1(234.11,38.02)
USB_OC1#: length 251.6
  TOP w0.14: v1(223.41,31.79) 222.86,31.24 U14.AL40 ; U8.13 17.58,47.3 v1(17.85,47.03)
  IN3 w0.089: v1(56.06,44.28) 55.81,44.28 55.01,43.48 55.01,43.16 55.22,42.94 55.22,41.61 55.11,41.49 55.11,41.28 55.51,40.89 56.73,40.89 58.19,39.42 68.89,39.42 69.2,39.11 70.17,39.11 70.61,39.56 72.15,39.56 72.83,38.88 77.67,38.88 78.45,38.1 79.35,38.1 79.47,37.98 80.58,37.98 82.36,39.75 85.26,39.75 86.42,38.6 87.25,38.6 87.49,38.83 90.09,38.83 90.49,38.44 91.91,38.44 92.07,38.6 93.23,38.6 94.02,37.81 94.2,37.81 94.35,37.66 99.78,37.66 100.11,37.32 176.37,37.32 178.34,39.29 187.71,39.29 187.93,39.51 190.27,39.51 194.17,35.61 195.75,35.61 197.53,33.84 197.53,33.01 199.31,31.23 199.31,28.95 200.88,27.37 201.64,27.37 202.46,26.55 203.64,26.55 206.14,29.05 207.79,29.05 208.03,28.81 210.59,28.81 210.92,28.48 211.8,28.48 212.15,28.82 212.15,29.92 212.56,30.33 213.8,30.33 214.31,30.84 219.91,30.84 220.09,31.03 222.65,31.03 v1(223.41,31.79)
  IN4 w0.086: v1(17.85,47.03) 17.93,46.96 17.93,40.43 18.76,39.59 19.81,39.59 21.52,37.88 24.82,37.88 28.19,41.26 29.21,41.26 29.79,40.68 29.79,38 31.06,36.73 35.08,36.73 37.06,38.7 43.4,38.7 45.27,40.58 47.85,40.58 48.46,39.97 48.92,39.97 50.8,41.85 51.2,41.85 53.99,44.64 55.7,44.64 v1(56.06,44.28)
  BOTTOM w0.14: R873.2 228.69,35.27 228.53,35.11 v1(228.53,34.63) 228.53,34.52 227.88,33.87 227.4,33.87 227.1,33.57 C816.1 227.1,33.29 226.06,32.26 225.07,32.26 224.89,32.08 223.7,32.08 v1(223.41,31.79)
USB_OC2#: length 239.6
  TOP w0.14: U14.AJ44 224.8,31.38 v1(224.85,31.32) ; U11.13 16.34,40.92 v1(16.44,40.82)
  IN3 w0.089: v1(224.85,31.32) 224.37,30.84 220.17,30.84 219.98,30.65 214.39,30.65 213.88,30.14 212.64,30.14 212.34,29.84 212.34,28.74 211.88,28.29 210.84,28.29 210.51,28.62 209.47,28.62 209.04,28.19 207.26,28.19 207.02,27.94 206.36,27.94 205.95,27.53 204.89,27.53 203.72,26.36 202.38,26.36 201.56,27.18 200.8,27.18 199.12,28.87 199.12,31.15 197.34,32.93 197.34,33.76 195.67,35.42 194.09,35.42 190.61,38.9 188.67,38.9 188.47,38.7 187.15,38.7 186.75,39.1 178.42,39.1 176.45,37.13 100.03,37.13 99.7,37.47 94.24,37.47 94.08,37.62 93.94,37.62 93.32,38.24 90.41,38.24 90.01,38.64 87.57,38.64 87.33,38.41 85.86,38.41 85.4,38.86 83.63,38.86 82.42,37.65 79.53,37.65 79.27,37.91 78.37,37.91 77.59,38.69 72.75,38.69 72.07,39.37 70.69,39.37 70.25,38.92 69.12,38.92 68.81,39.23 58.11,39.23 56.65,40.7 55.31,40.7 v1(55.2,40.59)
  IN4 w0.086: v1(16.44,40.82) 16.77,40.82 18.26,39.34 19.8,39.34 21.44,37.69 24.89,37.69 26.4,39.2 27.53,39.2 30.38,36.36 35.24,36.36 37.21,38.33 43.55,38.33 45.42,40.2 47.69,40.2 48.3,39.59 49.07,39.59 50.95,41.47 54.32,41.47 v1(55.2,40.59)
  BOTTOM w0.14: v1(224.85,31.32) 224.93,31.32 225.3,31.7 226.38,31.7 226.67,31.98 C825.1 227.21,31.98 227.52,31.68 v1(227.74,31.68) 227.94,31.68 228.13,31.86 229.97,31.86 230.4,32.3 230.4,32.79 231.21,33.6 232.42,33.6 R885.2
USB_OC3#: length 9.7
  TOP w0.14: v1(224.2,31.61) 223.59,31 U14.AL41
  BOTTOM w0.14: R882.2 230.12,32.9 230.12,32.41 229.85,32.14 227.45,32.14 227.29,32.3 226.59,32.3 226.27,31.98 225.19,31.98 224.99,31.78 224.37,31.78 v1(224.2,31.61)
USB_OC4#: length 11.7
  TOP w0.102: U14.AV47 226.22,27.95 227.9,27.95 228.21,28.26 v1(228.21,28.57)
  BOTTOM w0.14: v1(228.21,28.57) 228.21,28.76 228.65,29.19 230.33,29.19 231.25,30.12 232.05,30.12 232.33,30.39 232.33,30.67 232.59,30.94 234.7,30.94 R910.2
USB_OC5#: length 27.1
  TOP w0.14: v1(220.27,28.34) 220.27,29 U14.AR35
  IN2 w0.089: v1(234.66,40.38) 234.66,40.3 235.12,39.84 235.12,39.44 234.78,39.09 234.78,37.86 234.34,37.42 234.03,37.42 232.73,36.12 232.73,35.55 232.23,35.04 231.74,35.04 231.31,34.61 231.31,29.7 229.74,28.14 225.92,28.14 225.48,28.58 223.96,28.58 223.51,28.13 223.06,28.13 222.4,28.79 220.72,28.79 v1(220.27,28.34)
  BOTTOM w0.14: R830.2 234.66,40.78 v1(234.66,40.38)
USB_OC6#: length 26.6
  TOP w0.14: U14.AR37 221.27,29.25 v1(221.27,29.63)
  IN2 w0.089: v1(221.27,29.63) 221.28,29.63 221.65,30 222.77,30 223.7,29.06 224.58,29.06 225.29,29.77 226.32,29.77 226.82,29.28 229.76,29.28 231.11,30.62 231.11,35.22 231.95,36.06 232.4,36.06 233.95,37.61 234.26,37.61 234.59,37.94 234.59,39.16 234.05,39.69 234.05,41.81 v1(234.31,42.07)
  BOTTOM w0.14: R828.2 234.4,42.15 v1(234.31,42.07)
USB_OC7#: length 15.1
  TOP w0.14: U14.AV43 223.8,27.94 223.8,28.33 v1(223.31,28.82)
  BOTTOM w0.14: R905.2 235.4,31.25 232.51,31.25 232.31,31.05 231.67,31.05 231.4,30.78 231.4,30.66 230.21,29.47 228.12,29.47 227.75,29.1 226.37,29.1 225.94,29.53 225.44,29.53 224.8,28.9 223.39,28.9 v1(223.31,28.82)
USB_RBIAS: length 1.5
  TOP w0.102: v2(40.81,100.5) UG1.BA6
  BOTTOM w0.14: v2(40.81,100.5) 40.81,100.5 RG137.1
USB_RESET: length 13.1
  TOP w0.14: R522.1 246.92,16.8 246.36,16.23 245.72,16.23 244.88,17.07 243.85,17.07 R556.1 243.26,16.91 Q37.2 242.49,17.68 U27.4 240.59,18.1 240.94,18.46 241.32,18.46 241.98,19.11 242.47,19.11 242.87,19.51 242.87,20.01 243.1,20.23 243.1,20.86 R1135.2
USB_RESET_BUFF: length 8.7
  TOP w0.14: R625.2 252.42,10.53 252.06,10.18 252.06,9.74 251.87,9.55 U32.4 ; R625.2 R614.2 R608.2 253.03,12.46 252.53,11.96 U29.4 ; R625.2 253.25,10.35 R629.2 R630.2
USB_RESET_BUFF_D: length 1.3
  TOP w0.14: D77.2 254.13,12.36 R608.1
USB_RESET_BUFF_R: length 6.6
  TOP w0.14: R628.2 259.55,10.41 259.12,10.84 D79.1 257.07,10.84 256.3,11.6 254.13,11.6 R614.1
USB_RESET_OPTION: length 19.1
  TOP w0.14: U32.2 250.21,10.2 250.34,10.33 250.34,10.71 250.19,10.85 U32.1 248.8,10.85 248.58,11.07 248.58,12.28 248.91,12.61 U29.2 250.16,12.61 250.24,12.7 250.24,13.17 250.14,13.26 U29.1 248.6,13.26 248.1,12.77 245.81,12.77 245.11,13.47 244.42,13.47 243.48,14.42 243.48,15.4 v1(243.25,15.63) 243.05,15.63 242.48,16.2 R556.2 242.41,16.55 R555.1
USB_RESET_R: length 8
  TOP w0.14: v1(247.14,23.36) 246.96,23.54 246.26,23.54 R424.2 245.38,24.04 244.42,23.08 244.42,21.1 v1(244.02,20.7) 243.48,20.16 Q37.3
  BOTTOM w0.14: v1(247.14,23.36) 247.61,23.36 R987.1
USB_TERMP0: length 1.1
  TOP w0.102: v2(40.76,96.3) 40.76,96.33 UG1.BG6
  BOTTOM w0.14: RG157.1 40.76,96.31 v2(40.76,96.3)
USB_TERMP1: length 25.6
  TOP w0.102: v2(40.13,95.62) 40.15,95.65 40.15,95.7 40.25,95.8 40.3,95.8 UG1.BH6
  IN1 w0.109: v2(40.13,95.62) 40.07,95.57 40.07,93.56 39.54,93.03 38.96,93.03 38.28,92.35 37.82,92.35 37.53,92.07 36.67,92.07 36.54,92.19 36.22,92.19 34.93,90.9 33.91,90.9 32.93,89.92 25.73,89.92 24.7,90.96 v1(24.7,91.78)
  BOTTOM w0.14: RG165.1 25.01,95.99 25.01,93.67 24.7,93.35 v1(24.7,91.78)
USB_VBUS_Q: length 4.9
  TOP w0.203: PQ12.3 104.08,144.37 v1(103.78,144.67) 103.78,145.46 103.99,145.67 PQ12.1
  BOTTOM w0.203: v1(103.78,144.67) 103.81,144.64 PR470.2 105.58,144.65 PC329.2
USBC_PD_ADD: length 10.8
  TOP w0.203: PR107.2 98.64,150.03 v1(98.74,149.93) ; PU7.4 100.08,155.26 99.78,155.56 v1(99.49,155.56) 98.27,155.56 97.59,156.24 PR84.1
  BOTTOM w0.203: v1(99.49,155.56) 99.72,155.32 99.72,152.71 98.74,151.73 v1(98.74,149.93)
USBC_VBUS: length 58
  TOP w0.254: v1(290.32,29.35) 290.47,29.2 CN4.A9 ; v1(290.21,26.58) 290.33,26.7 CN4.A4
  IN2 w0.508: v1(249.65,13.88) 250.31,13.22 251.66,13.22 251.89,13.45 254.5,13.45 255.71,12.24 256.59,12.24 258.08,13.72 258.08,18.83 258.72,19.47 259.78,19.47 262.47,22.17 265.25,22.17 266.16,23.08 266.16,23.84 269.06,26.74 270.45,26.74 271.49,27.78 278.1,27.78 279.34,29.02 279.34,29.94 281.96,32.55 283.58,32.55 285.51,30.62 286.41,30.62 287.26,30.27 287.36,30.18 289.49,30.18 v1(290.32,29.35)
  BOTTOM w0.508: R1136.1 249.65,13.06 v1(249.65,13.88)
  vias: v1(107.74,140.88) v1(289.2,37) v1(289.53,35.81) v1(289.68,35.09) v1(289.99,36.39) v1(290.19,37.02) v3(111.78,143.55) v3(111.78,142.79) v3(112.67,143.55) v3(112.67,142.79)
USBP1+: length 206.1
  TOP w0.102: U14.J2 204.43,41.62 204.5,41.7 204.5,41.76 204.41,41.85 203.76,41.85 203.73,41.82 202.51,41.82 202.18,41.49 200.32,41.49 199.98,41.83 199.98,42.32 v1(199.63,42.66)
  TOP w0.14: v1(28.83,40.21) 28.57,39.95 28.31,39.95 28.15,40.11 28.15,43.46 27.81,43.81 27.81,44.11 25.96,45.95 25.54,45.95 25.23,46.26 23.19,46.26 21.41,48.04 21.41,48.89 21.02,49.27 21.02,49.52 20.76,49.78 20.54,49.78 20.42,49.9 U8.3
  IN1 w0.086: v1(199.63,42.66) 199.89,42.4 199.89,42.14 198.96,41.2 193.17,41.2 191.81,39.84 187.6,39.84 185.43,37.67 181.6,37.67 175.23,31.3 168.48,31.3 167.83,30.64 152.18,30.64 152.08,30.54 149.48,30.54 148.81,31.21 105.8,31.21 105.59,31.42 97.78,31.42 97.47,31.73 88.06,31.73 87.89,31.56 87.16,31.56 86.72,32 85.97,32 84.64,33.34 82.76,33.34 82.2,33.9 77.31,33.9 76.6,33.18 75.1,33.18 73.94,34.35 70.29,34.35 69.71,33.77 68.02,33.77 67.47,34.32 63.91,34.32 63.72,34.51 59.83,34.51 59.5,34.18 57.34,34.18 55.97,35.55 52.99,35.55 52.49,36.05 50.9,36.05 49.99,35.13 47.92,35.13 47.11,35.94 45.79,35.94 45.35,36.38 42.5,36.38 41.73,37.15 40.36,37.15 39.64,37.87 38.54,37.87 38.21,38.2 32.97,38.2 32,37.22 31.29,37.22 30.18,38.33 30.18,39.15 29.45,39.88 29.16,39.88 v1(28.83,40.21)
USBP1+_C: length 32.1
  TOP w0.14: v1(14.3,49.87) 14.32,49.85 16.15,49.85 16.19,49.9 U8.10
  IN1 w0.086: v1(10.03,29.15) 10.03,28.94 10.17,28.81 10.64,28.81 10.98,29.14 10.98,29.66 10.74,29.9 9.63,29.9 8.69,30.85 8.69,36.14 9.99,37.44 9.99,40.26 10.85,41.13 10.85,41.51 10.22,42.13 10.22,47.9 11.91,49.58 14.03,49.58 14.3,49.85 v1(14.3,49.87)
  BOTTOM w0.14: v1(10.03,29.15) 10.34,28.84 11.21,28.84 11.37,29 CN17.31
USBP1-: length 206.1
  TOP w0.102: v1(200.3,42.67) 200.18,42.55 200.18,41.92 200.4,41.7 202.09,41.7 202.42,42.03 203.64,42.03 203.67,42.06 204.5,42.06 204.77,41.78 U14.J3
  TOP w0.14: U8.2 20.39,49.4 20.51,49.51 20.65,49.51 20.76,49.41 20.76,49.16 21.14,48.78 21.14,47.93 23.08,45.99 25.12,45.99 25.43,45.69 25.85,45.69 27.54,44 27.54,43.7 27.88,43.35 27.88,40 28.2,39.68 28.5,39.68 v1(28.83,39.36)
  IN1 w0.086: v1(200.3,42.67) 200.06,42.43 200.06,42.07 199.03,41.04 193.24,41.04 191.88,39.68 187.67,39.68 185.5,37.51 181.67,37.51 175.3,31.13 168.55,31.13 167.9,30.48 152.25,30.48 152.15,30.38 149.41,30.38 148.74,31.05 105.73,31.05 105.52,31.26 97.71,31.26 97.4,31.56 88.13,31.56 87.96,31.4 87.09,31.4 86.65,31.84 85.91,31.84 84.57,33.17 82.69,33.17 82.13,33.73 77.38,33.73 76.66,33.02 75.03,33.02 73.87,34.18 70.35,34.18 69.78,33.61 67.95,33.61 67.4,34.16 63.85,34.16 63.65,34.35 59.9,34.35 59.57,34.02 57.27,34.02 55.9,35.38 52.92,35.38 52.42,35.88 50.97,35.88 50.06,34.97 47.85,34.97 47.04,35.77 45.72,35.77 45.28,36.22 42.43,36.22 41.66,36.98 40.3,36.98 39.57,37.7 38.47,37.7 38.14,38.03 33.04,38.03 32.06,37.06 31.22,37.06 30.02,38.26 30.02,39.08 29.38,39.71 29.19,39.71 v1(28.83,39.36)
USBP1-_C: length 32.1
  TOP w0.14: U8.11 16.19,49.4 16.01,49.58 14.67,49.58 v1(14.31,49.22)
  IN1 w0.086: v1(10.03,28.3) 10.37,28.64 10.71,28.64 11.15,29.07 11.15,29.73 10.81,30.06 9.7,30.06 8.85,30.91 8.85,36.07 10.15,37.37 10.15,40.2 11.01,41.06 11.01,41.58 10.39,42.2 10.39,47.83 11.98,49.42 14.08,49.42 14.28,49.22 v1(14.31,49.22)
  BOTTOM w0.14: CN17.30 11.39,28.5 11.32,28.58 10.31,28.58 v1(10.03,28.3)
USBP2+: length 217
  TOP w0.102: U14.N15 210.33,40.09 v1(210.33,40.48)
  TOP w0.14: v1(18.66,36.95) 18.66,37.05 18.85,37.24 19.16,37.24 20.08,38.17 20.08,40.73 19.91,40.91 19.91,43.21 19.61,43.5 19.45,43.5 19.37,43.58 U11.3
  IN1 w0.086: v1(18.66,36.95) 18.66,37.2 18.75,37.29 19.69,37.29 21.44,35.54 23.45,35.54 23.98,35.01 28.68,35.01 29.93,36.25 32.04,36.25 33.15,37.35 36.04,37.35 37.12,36.28 38.3,36.28 39.41,35.16 42.05,35.16 42.42,35.53 44.95,35.53 45.58,34.9 46.84,34.9 47.53,34.22 53.08,34.22 54.36,32.94 56.99,32.94 57.5,33.45 59.78,33.45 60.02,33.69 62.84,33.69 63.25,33.28 64.62,33.28 64.89,33.55 67.09,33.55 67.58,33.05 70.01,33.05 70.57,33.61 73.33,33.61 73.97,32.96 73.97,32.52 74.44,32.05 75.15,32.05 75.56,32.46 76.61,32.46 76.92,32.15 82.96,32.15 83.43,32.62 84.08,32.62 84.47,32.23 84.47,31.78 85.54,30.72 88.25,30.72 88.48,30.95 96.32,30.95 96.88,30.39 98.24,30.39 99.11,29.52 100.89,29.52 102.14,28.26 109.9,28.26 112.13,30.49 148.48,30.49 149.19,29.78 152.38,29.78 152.52,29.92 168.23,29.92 168.42,29.73 171.66,29.73 172.49,30.56 175.53,30.56 181.73,36.76 186.07,36.76 187,37.68 187.88,37.68 189.29,39.09 192.14,39.09 193.37,40.33 204.29,40.33 204.59,40.02 206.67,40.02 207.44,40.78 208.03,40.78 208.35,40.47 208.35,40.07 208.65,39.77 209.87,39.77 210.14,40.03 210.14,40.29 v1(210.33,40.48)
USBP2+_C: length 27.5
  TOP w0.14: U11.10 14.97,43.58 14.78,43.4 14.78,43.28 14.7,43.19 14.4,43.19 v1(14.33,43.26)
  IN1 w0.086: v1(14.33,43.26) 14.33,43.08 14.18,42.94 13.9,42.94 13.63,42.67 13.63,39.39 13.21,38.97 13.21,35.94 11.54,34.27 11.54,26.34 11.21,26.01 10.52,26.01 10.1,26.43 10.1,27.48 10.28,27.66 v1(10.51,27.66)
  BOTTOM w0.14: v1(10.51,27.66) 10.26,27.66 10.09,27.49 10.09,25.83 11.13,24.79 11.13,24.53 11.27,24.39 11.34,24.39 11.46,24.5 CN17.22
USBP2-: length 217
  TOP w0.102: v1(209.68,40.45) 209.78,40.45 210.13,40.11 210.13,39.78 210.02,39.68 209.83,39.68 209.72,39.79 U14.N13
  TOP w0.14: v1(18.46,37.58) 18.54,37.51 19.05,37.51 19.82,38.28 19.82,40.62 19.64,40.8 19.64,43.1 19.5,43.24 19.36,43.24 19.21,43.08 U11.2
  IN1 w0.086: v1(209.68,40.45) 209.8,40.45 209.98,40.28 209.98,40.1 209.81,39.93 208.72,39.93 208.51,40.14 208.51,40.54 208.1,40.95 207.37,40.95 206.6,40.19 204.66,40.19 204.35,40.49 193.3,40.49 192.07,39.26 189.22,39.26 187.81,37.85 186.93,37.85 186,36.92 181.66,36.92 175.46,30.73 172.42,30.73 171.6,29.9 168.48,29.9 168.3,30.09 152.45,30.09 152.31,29.95 149.26,29.95 148.55,30.66 112.06,30.66 109.83,28.43 102.21,28.43 100.96,29.68 99.18,29.68 98.31,30.55 96.95,30.55 96.39,31.11 88.41,31.11 88.18,30.88 85.61,30.88 84.64,31.85 84.64,32.3 84.15,32.78 83.36,32.78 82.89,32.31 76.99,32.31 76.68,32.62 75.49,32.62 75.08,32.21 74.51,32.21 74.13,32.59 74.13,33.03 73.39,33.77 70.5,33.77 69.94,33.22 67.65,33.22 67.15,33.71 64.82,33.71 64.55,33.44 63.32,33.44 62.91,33.85 59.96,33.85 59.72,33.61 57.43,33.61 56.92,33.11 54.42,33.11 53.15,34.38 47.6,34.38 46.91,35.07 45.64,35.07 45.02,35.69 42.35,35.69 41.98,35.32 39.48,35.32 38.37,36.44 37.19,36.44 36.11,37.52 33.08,37.52 31.98,36.41 29.86,36.41 28.61,35.17 24.05,35.17 23.52,35.7 21.51,35.7 19.75,37.46 18.59,37.46 v1(18.46,37.58)
USBP2-_C: length 27.6
  TOP w0.14: U11.11 14.97,43.08 14.45,42.57 v1(14.33,42.57)
  IN1 w0.086: v1(14.33,42.57) 14.12,42.77 13.97,42.77 13.8,42.6 13.8,39.32 13.38,38.9 13.38,35.88 11.7,34.2 11.7,26.28 11.28,25.85 10.45,25.85 9.94,26.36 9.94,27.38 v1(9.66,27.66)
  BOTTOM w0.14: CN17.21 11.44,24 11.32,24.12 11.16,24.12 10.86,24.42 10.86,24.68 9.83,25.72 9.83,27.49 v1(9.66,27.66)
USBP3+: length 108.2
  TOP w0.102: v1(202.07,40.98) 202.2,40.98 202.35,41.12 202.35,41.36 202.58,41.6 203.87,41.6 204.07,41.39 204.54,41.39 204.67,41.26 U14.K3
  TOP w0.14: U26.3 277.77,18.29 277.63,18.44 277.47,18.44 277.34,18.31 v1(277.34,18.18)
  IN4 w0.086: v1(277.34,18.18) 277.34,18.58 277.43,18.67 277.66,18.67 277.81,18.51 277.81,16.91 277.07,16.17 277.07,14.76 276.5,14.19 275.91,14.19 273.56,11.84 272.87,11.84 271.36,10.33 270.53,10.33 269.45,9.25 258.81,9.25 255.44,12.61 255.44,13.81 255.85,14.22 255.85,17.85 254.4,19.3 254.4,20.06 252.62,21.84 252.62,22.6 251.9,23.32 249.48,23.32 247.43,25.38 246.74,25.38 245.71,26.41 244.63,26.41 243.53,27.5 243.53,27.85 242.8,28.58 239.53,28.58 237.99,30.12 235.48,30.12 234.32,31.27 231.53,31.27 230.04,29.79 227.04,29.79 226,30.83 224.34,30.83 223.84,31.33 220.19,31.33 218.9,32.63 214.52,32.63 212.97,34.18 210.94,34.18 210.38,34.74 210.38,35.47 209.95,35.91 208.71,35.91 207.81,36.81 207.18,36.81 206.81,37.18 205.66,37.18 205.54,37.29 205.54,37.81 205.02,38.33 205.02,40.02 203.4,41.65 202.72,41.65 202.42,41.35 202.42,41.22 202.17,40.98 v1(202.07,40.98)
USBP3+_C: length 4.4
  TOP w0.14: U26.10 281.95,18.29 282.13,18.47 282.37,18.47 282.52,18.33 v1(282.52,18.25)
  BOTTOM w0.14: v1(282.52,18.25) 282.52,18.32 282.36,18.48 282.15,18.48 281.95,18.28 281.95,17.5 282.16,17.29 282.16,16.64 282.39,16.41 R1112.1
USBP3+_C_R: length 13.1
  IN1 w0.086: CN7.3 287.95,12 286.72,10.77 286.06,10.77 285.3,11.54 284.3,11.54 283.4,10.63 282.56,10.63 282.37,10.82 282.37,10.94 v1(282.62,11.19)
  BOTTOM w0.14: R1112.2 282.37,15.38 282.37,14.24 282.67,13.93 282.67,12.8 D112.1 282.19,12.32 282.19,11.98 282.34,11.82 282.34,11.47 v1(282.62,11.19)
USBP3-: length 108.2
  TOP w0.102: v1(202.72,40.96) 202.55,41.13 202.55,41.27 202.67,41.39 203.78,41.39 203.98,41.19 204.45,41.19 204.61,41.03 205.16,41.03 U14.K4
  TOP w0.14: v1(277.35,19.1) 277.35,18.94 277.49,18.79 U26.2
  IN4 w0.086: v1(202.72,40.96) 202.58,41.09 202.58,41.28 202.79,41.48 203.33,41.48 204.86,39.95 204.86,38.26 205.38,37.74 205.38,37.22 205.59,37.01 206.74,37.01 207.11,36.64 207.74,36.64 208.64,35.74 209.88,35.74 210.22,35.41 210.22,34.67 210.87,34.01 212.9,34.01 214.45,32.47 218.83,32.47 220.12,31.17 223.78,31.17 224.28,30.67 225.93,30.67 226.98,29.62 230.11,29.62 231.6,31.11 234.25,31.11 235.41,29.95 237.92,29.95 239.46,28.41 242.73,28.41 243.36,27.78 243.36,27.44 244.56,26.24 245.64,26.24 246.67,25.21 247.36,25.21 249.42,23.16 251.83,23.16 252.46,22.53 252.46,21.77 254.23,19.99 254.23,19.23 255.68,17.78 255.68,14.28 255.28,13.88 255.28,12.55 258.74,9.08 269.52,9.08 270.6,10.16 271.43,10.16 272.94,11.67 273.63,11.67 275.98,14.02 276.57,14.02 277.23,14.69 277.23,16.1 277.98,16.84 277.98,18.58 277.72,18.83 277.54,18.83 277.35,19.02 v1(277.35,19.1)
USBP3-_C: length 4.4
  TOP w0.14: U26.11 281.98,18.79 282.03,18.74 282.35,18.74 v1(282.52,18.91)
  BOTTOM w0.14: v1(282.52,18.91) 282.35,18.75 282.04,18.75 281.68,18.39 281.68,17.39 281.89,17.18 281.89,16.67 R1113.1
USBP3-_C_R: length 13.1
  IN1 w0.086: CN7.2 287.95,11.11 287.84,11.22 287.4,11.22 286.79,10.61 285.99,10.61 285.23,11.37 284.37,11.37 283.47,10.47 282.49,10.47 282.21,10.75 282.21,10.94 v1(281.96,11.19)
  BOTTOM w0.14: v1(281.96,11.19) 282.07,11.31 282.07,11.71 281.92,11.87 281.92,12.33 D112.2 281.5,12.75 281.5,13.68 282.1,14.28 282.1,15.33 281.81,15.63 R1113.2
USBP4+: length 2.7
  TOP w0.14: v1(208.63,40.99) 208.56,40.92 U14.L9
  BOTTOM w0.14: TP71.1 209.34,41.39 208.94,40.99 v1(208.63,40.99)
USBP4-: length 2.5
  TOP w0.14: v1(209.01,40.45) 208.4,40.45 U14.M10
  BOTTOM w0.14: TP75.1 209.47,41.14 209.01,40.68 v1(209.01,40.45)
USBP5+: length 5.5
  TOP w0.102: U14.L2 203.92,40.76 203.83,40.85 203.37,40.85 203.04,40.53 200.67,40.53 200.55,40.65 200.55,40.76 v1(200.76,40.96)
  BOTTOM w0.14: TP73.1 201,41.71 200.58,41.29 200.58,41.14 v1(200.76,40.96)
USBP5-: length 4.8
  TOP w0.102: v1(200.11,40.97) 200.35,40.74 200.35,40.56 200.58,40.33 203.13,40.33 203.4,40.6 U14.M1
  BOTTOM w0.14: TP74.1 200.32,41.41 200.32,41.18 v1(200.11,40.97)
USBP6+: length 108.1
  TOP w0.102: U14.K6 206.28,41.77 206.55,41.77 206.73,41.59 206.92,41.59 v1(207.06,41.73)
  TOP w0.14: R66.1 180.24,126.69 180.38,126.82 180.68,126.82 v1(180.98,126.53)
  IN2 w0.089: v1(207.06,41.73) 207.29,41.73 207.43,41.87 207.43,43.59 207.02,44 207.02,44.92 206.15,45.78 206.15,47.22 205.23,48.15 203.99,48.15 203.23,48.91 203.23,49.71 203.6,50.08 203.6,52.78 201.46,54.92 199.96,54.92 198.14,56.75 195.66,56.75 194.15,58.26 194.15,59.08 193.84,59.39 193.28,59.95 192.06,59.95 191.51,60.49 190.5,60.49 189.88,61.12 188.66,61.12 186.91,62.86 185.27,64.5 185.27,64.72 179.55,70.45 179.55,83.85 182.6,86.9 182.6,88.9 181.24,90.26 181.24,94.21 180.85,94.6 180.85,102.58 180.62,102.81 180.62,104.97 180.34,105.25 180.34,112.09 181.46,113.2 181.46,126.73 181.28,126.91 181.09,126.91 180.98,126.8 v1(180.98,126.53)
USBP6+_C: length 6.2
  TOP w0.14: v1(176.5,126.53) 176.78,126.81 177.74,126.81 D11.1 178.83,126.85 179.02,126.85 R66.2
  BOTTOM w0.14: v1(176.5,126.53) 176.5,126.61 176.36,126.75 176.16,126.75 176.02,126.61 176.02,126.16 175.72,125.87 175.53,125.87 175.41,125.75 CN10.28
USBP6-: length 108.1
  TOP w0.102: U14.K7 207.38,41.26 v1(207.69,41.57)
  TOP w0.14: v1(180.98,127.38) 180.68,127.09 180.4,127.09 180.24,127.25 R64.1
  IN2 w0.089: v1(207.69,41.57) 207.62,41.64 207.62,43.67 207.21,44.08 207.21,45 206.34,45.86 206.34,47.3 205.3,48.34 204.07,48.34 203.42,48.99 203.42,49.63 203.79,50 203.79,52.86 201.54,55.11 200.04,55.11 198.22,56.94 195.74,56.94 194.34,58.34 194.34,59.16 193.97,59.53 193.97,59.53 193.36,60.14 192.13,60.14 191.59,60.68 190.58,60.68 189.96,61.31 188.74,61.31 187.1,62.94 185.46,64.58 185.46,64.8 179.74,70.53 179.74,83.78 182.79,86.83 182.79,88.98 181.43,90.34 181.43,94.29 181.04,94.68 181.04,102.66 180.81,102.89 180.81,105.05 180.53,105.33 180.53,112.01 181.65,113.12 181.65,126.81 181.36,127.1 181.11,127.1 180.98,127.23 v1(180.98,127.38)
USBP6-_C: length 6.3
  TOP w0.14: v1(176.5,127.38) 176.81,127.08 177.72,127.08 D10.1 178.78,127.11 179.02,127.11 R64.2
  BOTTOM w0.14: v1(176.5,127.38) 176.5,127.25 176.27,127.02 176.04,127.02 175.75,126.72 175.75,126.27 175.61,126.13 175.53,126.13 175.41,126.25 CN10.29
USBP7+: length 140.2
  TOP w0.102: v1(201.18,39.39) 201.33,39.39 201.53,39.59 201.53,39.86 201.8,40.12 203.26,40.12 203.44,40.3 203.67,40.3 203.89,40.52 204.49,40.52 204.6,40.63 204.6,40.78 U14.L3
  IN4 w0.086: v1(201.18,39.39) 201.39,39.18 201.39,38.98 201.3,38.89 200.84,38.89 199.46,40.28 199.46,40.91 197.14,43.23 195.59,43.23 195.55,43.28 191.44,43.28 191.01,42.85 190.57,42.85 189.14,44.28 187.25,44.28 186.84,43.86 186.84,41.91 186.07,41.14 185.14,41.14 184.69,41.58 181.9,41.58 174.06,33.75 100.62,33.75 99.46,32.59 95.8,32.59 95.31,33.08 88.65,33.08 88.09,33.63 87.53,33.63 87.13,33.23 87.13,33.06 86.63,32.56 v1(86.51,32.56)
  BOTTOM w0.14: v1(86.51,32.56) 86.51,32.55 86.76,32.31 86.76,30.53 86.82,30.46 86.82,29.42 87.52,28.72 87.52,28.42 87.78,28.19 88.24,27.74 88.24,26.83 88.24,26.16 88.1,26.02 88.1,24.41 87.57,23.89 87.39,23.89 87.25,24.03 R980.1
USBP7+_C: length 2.5
  BOTTOM w0.14: CN10.22 172.38,122.75 TP62.1
USBP7+_R: length 9.7
  BOTTOM w0.14: R980.2 86.11,23.86 85.77,23.86 D107.1 85.48,23.83 85.26,23.61 84.2,23.61 84.08,23.5 83.68,23.5 81.95,21.77 81.95,21.51 81.61,21.18 80.9,21.18 80.27,20.54 80.27,19.99 80.15,19.88 CN19.18
USBP7-: length 140.2
  TOP w0.102: v1(201.85,39.34) 201.73,39.45 201.73,39.77 201.88,39.92 203.34,39.92 203.52,40.1 203.76,40.1 203.98,40.32 204.58,40.32 204.98,40.71 U14.L4
  IN4 w0.086: v1(87.17,32.54) 87.17,32.87 87.29,32.99 87.29,33.16 87.6,33.47 88.02,33.47 88.58,32.91 95.24,32.91 95.73,32.43 99.53,32.43 100.69,33.59 174.13,33.59 181.96,41.42 184.63,41.42 185.07,40.98 186.14,40.98 187,41.84 187,43.79 187.32,44.11 189.07,44.11 190.5,42.68 191.08,42.68 191.51,43.11 195.48,43.11 195.52,43.07 197.07,43.07 199.29,40.84 199.29,40.21 200.78,38.73 201.37,38.73 201.55,38.91 201.55,39.04 v1(201.85,39.34)
  BOTTOM w0.14: R993.1 87.27,23.21 88.36,24.3 88.36,25.91 88.51,26.05 88.51,26.72 88.51,26.72 88.51,27.85 87.96,28.39 87.79,28.54 87.79,28.83 87.09,29.53 87.09,30.57 87.03,30.64 87.03,32.38 87.17,32.53 v1(87.17,32.54)
USBP7-_C: length 3
  BOTTOM w0.14: CN10.23 173.61,123.25 TP61.1
USBP7-_R: length 9.7
  BOTTOM w0.14: CN19.17 80.65,19.88 80.53,19.99 80.53,20.43 81.01,20.91 81.72,20.91 82.21,21.4 82.21,21.66 83.79,23.23 84.19,23.23 84.31,23.35 85.2,23.35 85.48,23.06 D108.1 85.8,23.15 85.8,23.46 85.94,23.59 86.28,23.59 86.47,23.4 R993.2
USBP8+: length 1.4
  TOP w0.102: v1(205.62,43.26) 205.54,43.18 U14.G5
  BOTTOM w0.14: v1(205.62,43.26) TP70.1
USBP8-: length 1.5
  TOP w0.102: v1(205.06,43.61) 205.1,43.58 U14.G4
  BOTTOM w0.14: v1(205.06,43.61) 205.06,42.98 TP69.1
USBP14+: length 182.2
  TOP w0.089: U14.F6 206.18,43.07 206.18,43.03 205.98,42.83 205.98,42.48 205.91,42.41 205.91,42.15 v1(205.83,42.06)
  IN4 w0.086: v1(205.83,42.06) 205.66,42.06 205.48,41.88 205.48,41.73 205.15,41.39 204.41,41.39 203.59,42.22 202.42,42.22 201.71,41.51 199.44,41.51 196.23,44.72 195.6,44.72 195.12,44.24 192.29,44.24 192.23,44.3 189.9,44.3 188.9,45.3 187.41,45.3 186.42,44.3 186.42,42.14 185.81,41.53 185.4,41.53 184.92,42.02 181.59,42.02 173.72,34.14 100.46,34.14 99.3,32.98 95.96,32.98 95.47,33.47 88.94,33.47 88.38,34.02 86.87,34.02 85.74,32.9 85.74,31.77 83.86,29.89 81.48,29.89 80.56,28.97 80.56,28.67 79.77,27.88 79.34,27.88 78.42,26.95 77.76,26.95 76.03,25.23 73.98,25.23 73.2,24.45 73.2,23.87 72.48,23.16 71.24,23.16 71.06,23.33 70.71,23.33 70.24,22.87 68.53,22.87 66.86,21.2 65.37,21.2 64.75,20.58 63.55,20.58 61.85,22.28 60.53,22.28 59.28,23.54 59.28,29.98 60.29,30.99 60.29,32.31 60.7,32.72 60.97,32.72 61.29,33.04 61.29,33.19 61.14,33.34 60.93,33.34 v1(60.83,33.25)
  BOTTOM w0.14: v1(60.83,33.25) 61.03,33.25 61.17,33.39 61.17,33.68 60.9,33.94 59.16,33.94 58.62,33.4 58.4,33.4 58.25,33.25 CN16.3
USBP14-: length 182.3
  TOP w0.089: U14.E5 206.01,43.51 206.01,43.09 205.82,42.9 205.82,42.59 205.63,42.41 205.43,42.41 v1(205.19,42.17)
  IN4 w0.086: v1(61.68,33.25) 61.68,33.2 61.04,32.56 60.77,32.56 60.45,32.24 60.45,30.92 59.44,29.91 59.44,23.6 60.6,22.44 61.92,22.44 63.62,20.74 64.68,20.74 65.3,21.37 66.79,21.37 68.46,23.03 70.17,23.03 70.64,23.5 71.13,23.5 71.31,23.32 72.42,23.32 73.03,23.94 73.03,24.52 73.91,25.4 75.96,25.4 77.69,27.12 78.35,27.12 79.27,28.05 79.71,28.05 80.4,28.74 80.4,29.04 81.41,30.05 83.8,30.05 85.58,31.84 85.58,32.97 86.8,34.19 88.45,34.19 89.01,33.63 95.54,33.63 96.03,33.15 99.23,33.15 100.39,34.31 173.65,34.31 181.52,42.18 184.99,42.18 185.47,41.7 185.74,41.7 186.25,42.21 186.25,44.37 187.34,45.46 188.97,45.46 189.97,44.47 192.3,44.47 192.36,44.4 195.05,44.4 195.53,44.89 196.3,44.89 199.51,41.67 201.64,41.67 202.36,42.38 203.66,42.38 204.48,41.56 205.08,41.56 205.32,41.8 205.32,42.04 v1(205.19,42.17)
  BOTTOM w0.14: CN16.5 58.26,33.75 58.34,33.67 58.51,33.67 59.05,34.21 61.01,34.21 61.43,33.79 61.43,33.5 v1(61.68,33.25)
VA: length 152.3
  TOP w0.508: v1(88.23,50.08) 88.05,49.9 PD6.1
  IN1 w0.508: v1(95.17,51.76) 95.07,51.86 92.98,51.86 92.12,50.99 90.98,50.99 90.01,50.03 88.28,50.03 v1(88.23,50.08)
  IN2 w0.508: v3(118.79,164.68) 118.79,163.14 v1(111.91,156.25)
  IN3 w0.508: v1(111.91,156.25) 110.99,155.34 110.99,154.17 111.65,153.51 111.65,151.5 110.43,150.28 107,150.28 106.52,149.8 106.52,148.4 107.38,147.55 107.38,144.29 108.43,143.24 108.43,138.59 107.7,137.86 107.7,136.01 105.39,133.7 105.39,125.49 106.19,124.68 106.19,108.95 105.91,108.66 105.91,103.79 109.23,100.47 109.85,100.47 116.02,94.3 116.02,68.79 115.16,67.93 108.39,67.93 105.8,65.34 105.8,62.98 105.1,62.29 102.93,62.29 101.04,60.4 101.04,56.56 100.21,55.72 100.21,53.85 99.41,53.05 98.5,53.05 97.86,52.42 96.86,52.42 96.2,51.76 v1(95.17,51.76)
  BOTTOM w0.203: v1(88.23,50.08) 88.24,50.08 PR500.1
  vias: v3(118.79,165.45) v3(119.55,165.45) v3(119.55,164.68) v3(120.31,165.45) v3(120.31,164.68) v3(121.08,165.45) v3(121.08,164.68) v3(121.84,165.45) v3(121.84,164.68)
VGA_XTALIN: length 14.7
  TOP w0.102: 37.05,90.82 37.69,91.46 38.79,91.46 39.77,92.44 40.17,92.44 40.79,93.06 40.79,93.3 40.45,93.64 UG1.BL6
  TOP w0.14: 37.05,90.82 35.22,88.99 35.22,87.34 34.38,86.5 34.38,86.09 33.64,85.36 CG80.1 32.02,85.36 YG1.1
VGA_XTALOUT: length 3.5
  TOP w0.14: YG1.3 31.03,86.02 32.18,86.02 32.42,86.27 RG44.2
VGA_XTALOUT_R: length 9
  TOP w0.102: 36.71,91.14 37.28,91.71 38.62,91.71 39.55,92.64 39.96,92.64 40.45,93.13 UG1.BM6
  TOP w0.14: 36.71,91.14 34.7,89.13 RG41.1
VGPU_CORE_SENSE: length 145.2
  TOP w0.105: UG1.BK45 68.06,94.02 68.08,93.7 69.08,92.7 71.79,92.7 72.18,92.3
  TOP w0.127: 72.18,92.3 72.82,91.66 79.65,91.66 v1(79.88,91.43)
  IN3 w0.127: v1(36.13,50.6) 36.37,50.36 37.46,50.36 37.94,49.88 37.94,49.11 37.33,48.51 36.65,48.51 35.45,47.31 35.45,41.59 37.22,39.82 38.41,39.82 38.91,39.33 43.76,39.33 44.73,40.3 46.55,40.3 48.05,41.8 48.61,41.8 49.99,43.18 49.99,49.77 50.85,50.63 53.78,50.63 55.33,52.19 57.76,52.19 59.54,50.4 61.14,50.4 61.55,49.99 61.6,49.99 63.05,48.54 64.19,48.54 66.98,51.33 70.09,51.33 71.23,52.47 75.34,52.47 76.75,53.88 77.55,53.88 77.98,53.45 79.04,53.45 79.15,53.56 80.71,53.56 81.64,54.49 86.06,54.49 86.81,55.24 86.81,56.14 87.77,57.1 87.77,58.85 89.84,60.92 89.84,61.41 90.93,62.5 90.93,66.96 93.69,69.72 93.69,73.34 94.49,74.15 94.49,74.89 94.21,75.18 93.56,75.18 92.95,74.57 90.88,74.57 85.34,80.11 85.34,92.08 85.21,92.21 80.22,92.21 79.88,91.86 v1(79.88,91.43)
  BOTTOM w0.127: PR513.2 v1(36.13,50.6)
VGT_VCCSENSE: length 21.7
  TOP w0.254: U3.AH38 139.51,133.39 139.95,133.82 v1(139.95,133.87) ; v1(127.53,140.45) 128.06,140.45 TP1.1
  IN4 w0.254: v1(127.53,140.45) 127.09,140.02 127.09,138.98 127.91,138.17 127.91,137.36 130.86,134.41 139.65,134.41 139.95,134.11 v1(139.95,133.87)
VGT_VSSSENSE: length 21.6
  TOP w0.254: TP2.1 128.67,139.79 v1(127.58,139.79) ; v1(140.05,133.19) 139.91,133.05 139.91,131.26 U3.AH37
  IN4 w0.254: v1(127.58,139.79) 127.45,139.67 127.45,139.13 128.26,138.31 128.26,137.51 131.01,134.76 139.79,134.76 140.48,134.08 140.48,133.62 v1(140.05,133.19)
VL: length 3.9
  TOP w0.203: PU28.13 120.41,21.1 120.32,21 120.32,20.59 120.52,20.38 121.18,20.38 v1(121.49,20.69) 121.67,20.51 121.67,20.04 121.46,19.84 PC273.1
VMA_CLK0: length 32.5
  TOP w0.122: UG1.AG45 67.42,110.98 v2(67.39,110.98) ; v2(93.14,120.3) VRAM6.J10
  IN1 w0.114: v2(93.14,120.3) 92.98,120.46 92.98,120.67 92.73,120.92 91.15,120.92 90.35,120.12 85.93,120.12 85.01,119.2 85.01,118.33 84.51,117.82 84.25,117.82 77.19,110.76 71.88,110.76 71.43,111.22 70.81,111.22 70.48,111.55 68.5,111.55 67.88,110.93 67.45,110.93 v2(67.39,110.98)
VMA_CLK0#: length 32.6
  TOP w0.102: UG1.AG46 68.45,110.74 68.35,110.84 68.22,110.84 68.12,110.74 v2(68.12,110.33)
  TOP w0.122: v2(92.39,120.3) 92.3,120.3 92.02,120.02 VRAM6.K10
  IN1 w0.114: v2(68.12,110.33) 68.04,110.4 68.04,110.79 68.59,111.34 70.39,111.34 70.72,111 71.34,111 71.8,110.53 77.28,110.53 84.34,117.59 84.6,117.59 85.24,118.23 85.24,119.11 86.03,119.9 90.45,119.9 91.24,120.69 92.64,120.69 92.75,120.58 92.75,120.42 92.63,120.3 v2(92.39,120.3)
VMA_CLK1: length 31.1
  TOP w0.122: v2(68.12,108.18) 68.15,108.21 68.15,108.25 UG1.AK46
  TOP w0.14: v2(91.68,107.3) 91.64,107.34 91.64,107.95 91.76,108.07 91.91,108.07 92.02,107.97 VRAM8.J10
  IN4 w0.102: v2(68.12,108.18) 68.26,108.32 69.82,108.32 69.89,108.4 70.52,108.4 70.8,108.67 73.56,108.67 73.69,108.54 75.46,108.54 75.47,108.53 75.56,108.53
  IN4 w0.114: 75.56,108.53 75.57,108.54 81.07,108.54 82.52,110 82.54,110 84.03,111.48 90.32,111.48 91.5,110.31 91.5,109.56 91.05,109.12 91.05,108.56 92.03,107.58 92.03,107.42 91.91,107.3 v2(91.68,107.3)
VMA_CLK1#: length 31.1
  TOP w0.122: UG1.AK45 67.44,108.24 v2(67.4,108.24)
  TOP w0.14: v2(92.39,107.3) VRAM8.K10
  IN4 w0.102: 75.56,108.77 73.75,108.77 73.64,108.88 70.72,108.88 70.44,108.6 69.81,108.6 69.73,108.52 68.34,108.52 68.32,108.55 67.92,108.55 v2(67.4,108.24)
  IN4 w0.114: 75.56,108.77 80.97,108.77 82.43,110.22 82.45,110.22 83.93,111.71 86.09,111.71 86.1,111.7 90.41,111.7 91.73,110.38 91.73,109.49 91.27,109.03 91.27,108.65 92.25,107.67 92.25,107.44 v2(92.39,107.3)
VMA_DQ0: length 34
  TOP w0.168: UG1.U51 72.3,117.3 v2(72.35,117.3) ; v2(93.89,125.56) 94.27,125.93 VRAM6.G2
  IN2 w0.14: v2(72.35,117.3) 72.36,117.29 72.36,117.24 72.85,116.75 74.43,116.75 78.78,121.1 78.78,121.83 81.71,124.76 81.71,127.37 83.92,129.58 93.16,129.58 94.03,128.71 94.03,127.57 94.27,127.33 94.27,125.93 v2(93.89,125.56)
VMA_DQ1: length 41.7
  TOP w0.168: v2(97.64,124.81) VRAM6.B3 ; v2(70.13,118.05) 70.13,118.02 69.85,117.67 UG1.U48
  IN1 w0.127: v2(70.13,118.05) 70.51,117.67 71.7,117.67 71.98,117.4 71.98,117.15 72.36,116.76 74.74,116.76 78.55,120.57 78.55,121.22 80.82,123.5 80.82,127.26 83.83,130.26 95.13,130.26 96.39,129.01 96.39,128.29 96.51,128.16 96.51,126.91 96.52,126.9 96.52,126.46 96.52,125.34 96.68,125.18 97.27,125.18 v2(97.64,124.81)
VMA_DQ2: length 35.3
  TOP w0.168: UG1.U50 v2(71.54,118.07) ; v2(94.64,126.31) 95.02,125.93 VRAM6.F2
  IN2 w0.14: v2(71.54,118.07) 71.78,118.07 72.18,117.67 73.34,117.67 73.46,117.55 74.46,117.55 78.05,121.14 78.05,121.87 80.94,124.76 80.94,127.65 83.61,130.32 93.39,130.32 94.76,128.95 94.76,128.34 95.02,128.08 95.02,126.68 v2(94.64,126.31)
VMA_DQ3: length 39.2
  TOP w0.168: v2(70.91,117.28) 70.91,117.29 UG1.U49 ; VRAM6.E3 96.15,124.8 v2(96.15,124.74)
  IN1 w0.127: v2(70.91,117.28) 70.92,117.28 71.29,116.91 71.73,116.91 72,116.64 72,116.38 72.15,116.23 74.96,116.23 79.08,120.35 79.08,121 81.35,123.28 81.35,127.04 83.84,129.53 95.11,129.53 95.77,128.87 VRAM6.E3 96.15,124.8 v2(96.15,124.74)
VMA_DQ4: length 42.7
  TOP w0.15: v2(98.39,123.33) 98.39,124.06 VRAM6.B4
  TOP w0.168: v2(72.32,118.71) 72.31,118.76 UG1.R51
  IN1 w0.127: v2(72.32,118.71) 72.53,118.5 73.24,118.5 73.29,118.45 74.01,118.45 74.02,118.45 74.92,118.45 77.48,121.01 77.48,121.67 79.75,123.94 79.75,127.7 83.55,131.5 95.41,131.5 98.78,128.13 98.78,124.39 98.39,124 v2(98.39,123.33)
VMA_DQ5: length 41.4
  TOP w0.168: VRAM6.B2 98.02,125.93 v2(98.39,125.56) ; UG1.R50 71.23,119.05 70.98,118.79 v2(70.98,118.61)
  IN1 w0.127: v2(70.98,118.61) 71.03,118.61 71.11,118.69 71.44,119.01 71.71,119.01 71.94,118.78 71.94,117.92 72.19,117.67 73.34,117.67 73.45,117.56 74.78,117.56 78.01,120.79 78.01,121.45 80.29,123.72 80.29,127.48 83.7,130.89 95.26,130.89 97.01,129.14 97.01,128.65 98.04,127.62 98.04,126.48 98.02,126.46 98.02,126.15 98.02,126.15 98.02,125.93 v2(98.39,125.56)
VMA_DQ6: length 39.1
  TOP w0.168: VRAM6.E2 v2(95.39,125.56) ; UG1.R47 v2(69.54,118.65)
  IN2 w0.14: v2(95.39,125.56) 95.77,125.93 95.77,128.78 93.68,130.86 83.39,130.86 80.12,127.59 80.12,124.71 77.5,122.09 77.5,121.36 74.93,118.79 72.93,118.79 72.48,119.23 71.28,119.23 71.06,119 70.57,119 70.56,118.99 69.88,118.99 v2(69.54,118.65)
VMA_DQ7: length 46.9
  TOP w0.168: v2(99.29,124.81) VRAM6.A3 ; v2(68.82,118.03) 68.76,117.97 68.76,117.96 68.45,117.65 UG1.U46
  IN1 w0.127: v2(99.29,124.81) 99.6,125.11 99.6,128.51 98.76,129.35 98.76,129.78 96.29,132.24 83.54,132.24 79.22,127.92 79.22,124.16 76.94,121.89 76.94,121.23 74.7,118.99 73.45,118.99 73.28,118.82 73.05,118.82 72.47,119.4 71.49,119.4 71.1,119 69.82,119 69.75,119.03 69.29,119.03 69.13,118.87 69.13,118.33 68.83,118.03 v2(68.82,118.03)
VMA_DQ8: length 41.6
  TOP w0.168: v2(98.39,119.58) 98.02,119.2 VRAM6.B11 ; v2(68.09,117.26) 68.14,117.26 68.45,116.95 UG1.V46
  IN4 w0.102: v2(68.09,117.26) 68.13,117.27 68.17,117.23 68.47,117.24 68.65,117.25 69.09,117.68 73.33,117.68 73.42,117.59 74.51,117.59 74.69,117.77 75.56,117.77
  IN4 w0.127: v2(98.39,119.58) 98.4,119.57 98.4,119.57 98.82,119.98 98.82,121.38 97.27,122.93 97.27,125.71 97.05,125.93 91.05,125.93 90.29,126.69 85,126.69 76.08,117.77 75.56,117.77
VMA_DQ9: length 33.2
  TOP w0.168: v2(67.44,115.19) 67.44,115.24 UG1.Y45 ; VRAM6.G13 v2(93.89,118.06)
  IN4 w0.102: 75.56,113.47 70.88,113.47 70.51,113.84 70.51,114.17 70.22,114.45 69.22,114.45 68.84,114.84 67.82,114.84 67.47,115.19 v2(67.44,115.19)
  IN4 w0.127: 75.56,113.47 78.42,113.47 85.86,120.92 89.56,120.92 89.78,120.7 89.78,120.15 90.75,119.18 91.81,119.18 91.97,119.02 91.97,118.6 92.14,118.43 93.52,118.43 v2(93.89,118.06)
VMA_DQ10: length 41.6
  TOP w0.168: v2(68.81,115.21) UG1.Y47 ; v2(95.39,118.06) VRAM6.E13
  IN1 w0.127: v2(95.39,118.06) 95.39,118.23 95.02,118.61 95.02,119.02 94.7,119.33 94.7,121.01 94.18,121.53 93.59,121.53 92.82,122.31 91.14,122.31 90.37,123.07 90.37,124.13 90.72,124.48 90.72,126.24 90.28,126.68 89.24,126.68 89.23,126.69 85.36,126.69 83.15,124.48 83.15,122.97 80.56,120.39 80.56,119.72 75.57,114.73 72.15,114.73 71.79,115.09 70.7,115.09 70.25,114.64 69.39,114.64 v2(68.81,115.21)
VMA_DQ11: length 34.7
  TOP w0.168: v2(68.18,116.08) 68.25,115.94 UG1.Y46 ; VRAM6.F13 v2(94.64,117.31)
  IN4 w0.102: 75.56,114.08 72.23,114.08 71.32,115 70.58,115 70.35,114.78 69.42,114.78 69.17,115.03 69.17,115.37 68.96,115.57 68.59,115.57 68.18,115.98 v2(68.18,116.08)
  IN4 w0.127: v2(94.64,117.31) 94.27,117.68 94.27,118.96 94.04,119.19 93.7,119.19 93.52,119.36 93.52,119.77 93.36,119.93 91.44,119.93 89.82,121.54 85.51,121.54 78.05,114.08 75.56,114.08
VMA_DQ12: length 33.6
  TOP w0.168: v2(96.16,118.82) VRAM6.E12 ; UG1.V50 71.29,116.94 v2(71.58,116.53)
  IN4 w0.102: v2(71.58,116.53) 71.74,116.36 72.49,116.36 72.9,115.95 75.56,115.95
  IN4 w0.127: 75.56,115.95 76.92,115.95 85.4,124.43 89.96,124.43 89.97,124.42 90.63,124.42 91.36,123.68 93.87,123.68 94.32,123.23 94.32,122.74 96.52,120.54 96.52,119.18 v2(96.16,118.82)
VMA_DQ13: length 37.6
  TOP w0.168: v2(68.8,116.64) 69.11,116.95 UG1.V47 ; VRAM6.B12 v2(97.65,118.8)
  IN4 w0.102: 75.56,116.6 73.06,116.6 72.85,116.82 72.25,116.82 72.15,116.92 69.08,116.92 v2(68.8,116.64)
  IN4 w0.127: v2(97.65,118.8) 97.27,119.18 97.27,120.62 95.16,122.74 95.16,123.6 94.33,124.43 91.09,124.43 90.35,125.17 89.97,125.17 89.96,125.18 85.3,125.18 76.73,116.6 75.56,116.6
VMA_DQ14: length 41.3
  TOP w0.168: VRAM6.B13 v2(98.39,117.31) ; UG1.U52 72.65,117.69 v2(73.02,118.1)
  IN4 w0.102: v2(73.02,118.1) 73.29,118.37 75.56,118.37
  IN4 w0.127: 75.56,118.37 75.8,118.37 85.1,127.67 90.22,127.67 91.21,126.68 97.83,126.68 98.02,126.49 98.02,123.01 99.57,121.47 99.57,117.85 99.41,117.69 98.77,117.69 v2(98.39,117.31)
VMA_DQ15: length 37.8
  TOP w0.102: UG1.V51 72.4,116.5 73.06,116.5 v2(73.69,117.13)
  TOP w0.168: VRAM6.A12 99.1,118.11 v2(99.14,118.11)
  IN4 w0.102: v2(73.69,117.13) 73.8,117.24 75.56,117.24
  IN4 w0.127: v2(99.14,118.11) 99.1,118.11 98.78,118.42 98.78,119.02 98.61,119.19 98.2,119.19 98.02,119.37 98.02,121.2 96.52,122.7 96.52,125.05 96.38,125.18 91.12,125.18 90.37,125.93 85.09,125.93 76.41,117.24 75.56,117.24
VMA_DQ16: length 27.9
  TOP w0.168: UG1.AJ44 67.05,109.25 66.71,108.96 v2(66.7,108.91) ; v2(89.39,117.31) VRAM6.P13
  IN2 w0.14: v2(89.39,117.31) 89.02,116.93 89.02,116.12 88.46,115.57 84.5,115.57 77.97,109.03 71.46,109.03 70.42,109.36 69.23,109.36 69.16,109.29 68.51,109.29 68.45,109.35 67.66,109.35 67.59,109.29 67.03,109.29 66.7,108.96 v2(66.7,108.91)
VMA_DQ17: length 20.2
  TOP w0.168: v2(70.21,110.96) 70.16,110.96 UG1.AG48 ; v2(86.39,117.31) VRAM6.U13
  IN4 w0.127: v2(70.21,110.96) 72.09,110.96 72.36,111.23 79.55,111.23 83.99,115.66 85.41,115.66 86.02,116.27 86.02,116.76 86.39,117.14 v2(86.39,117.31)
VMA_DQ18: length 29.1
  TOP w0.168: UG1.AJ45 67.75,109.25 67.36,109.64 67.36,109.7 v2(67.3,109.75) ; VRAM6.M13 v2(90.89,117.31)
  IN4 w0.102: 75.56,109.43 75.48,109.52 70.09,109.52 69.89,109.31 68.37,109.31 68.37,109.32 67.68,109.32 67.36,109.64 67.36,109.7 v2(67.3,109.75)
  IN4 w0.127: 75.56,109.43 80.5,109.43 83.5,112.43 87.28,112.43 90.52,115.67 90.52,116.93 v2(90.89,117.31)
VMA_DQ19: length 24.6
  TOP w0.168: v2(90.14,118.06) VRAM6.N13
  TOP w0.254: UG1.AG49 v2(70.9,110.3)
  IN4 w0.102: v2(70.9,110.3) 71.68,110.3 71.95,110.03 75.56,110.03
  IN4 w0.127: 75.56,110.03 80.18,110.03 83.67,113.52 86.58,113.52 89.01,115.96 89.01,117.47 89.23,117.69 89.77,117.69 v2(90.14,118.06)
VMA_DQ20: length 22.9
  TOP w0.168: v2(86.4,118.76) 86.44,118.76 VRAM6.U12 ; v2(68.07,111.7) 68.07,111.68 68.4,111.35 UG1.AF46
  IN4 w0.127: v2(86.4,118.76) 86.35,118.76 86.02,118.43 85.49,118.43 85.21,118.16 85.21,117.93 79.04,111.76 72.1,111.76 71.59,111.26 70.7,111.26 70.44,111.51 68.82,111.51 68.75,111.44 68.31,111.44 68.07,111.68 v2(68.07,111.7)
VMA_DQ21: length 25
  TOP w0.168: v2(68.81,110.97) 68.83,110.99 68.83,111.02 UG1.AF47 ; v2(88.64,118.06) VRAM6.P12
  IN4 w0.127: v2(88.64,118.06) 88.27,117.68 88.27,116.28 86.76,114.77 84.03,114.77 79.89,110.63 71.87,110.63 71.79,110.71 70.63,110.71 70.5,110.58 69.27,110.58 68.89,110.97 v2(68.81,110.97)
VMA_DQ22: length 20.6
  TOP w0.168: v2(85.64,118.06) VRAM6.V12 ; UG1.AF48 69.95,111.45 v2(69.95,111.92)
  IN2 w0.14: v2(85.64,118.06) 85.43,118.27 84.59,118.27 77.27,110.95 72.18,110.95 71.01,112.12 70.66,112.12 70.4,111.87 70.15,111.87 70.14,111.87 70.04,111.87 70.01,111.91 69.96,111.91 v2(69.95,111.92)
VMA_DQ23: length 23.5
  TOP w0.168: v2(87.11,119.53) VRAM6.U11 ; UG1.AD47 69.13,112.75 68.85,112.47 68.84,112.47 v2(68.81,112.44)
  IN2 w0.14: v2(68.81,112.44) 68.84,112.47 68.87,112.47 69.1,112.7 69.71,112.7 69.85,112.84 70.41,112.84 70.62,112.63 71.76,112.63 72,112.39 72,112.04 72.43,111.61 77.05,111.61 84.63,119.19 85.79,119.19 85.85,119.14 86.73,119.14 v2(87.11,119.53)
VMA_DQ24: length 28.3
  TOP w0.135: v2(71.43,112.24) 71.31,112.24 70.8,112.75 UG1.AD49
  TOP w0.168: v2(89.41,126.31) 89.41,126.29 VRAM6.N2
  IN1 w0.127: v2(89.41,126.31) 89.76,125.96 89.76,123.82 89.61,123.67 89.3,123.67 89.18,123.55 89.18,123.01 88.02,121.86 85.95,121.86 83.33,119.24 83.33,118.57 76.72,111.96 71.71,111.96 v2(71.43,112.24)
VMA_DQ25: length 27.3
  TOP w0.168: v2(69.52,113.1) 69.52,113.08 UG1.AD48 ; VRAM6.P3 89.38,124.82 v2(89.38,124.8)
  IN1 w0.127: v2(69.52,113.1) 70.56,113.1 71.03,112.63 71.97,112.63 72.11,112.49 76.5,112.49 82.8,118.79 82.8,119.46 85.73,122.39 87.59,122.39 88.28,123.08 88.28,124.29 88.41,124.43 88.99,124.43 89.37,124.8 v2(89.38,124.8)
VMA_DQ26: length 32
  TOP w0.168: v2(90.13,125.54) 90.52,125.93 VRAM6.M2 ; UG1.AC46 68.42,113.45 v2(68.1,113.13)
  IN1 w0.127: v2(68.1,113.13) 68.14,113.17 68.75,113.17 69.27,112.65 69.78,112.65 69.95,112.82 70.52,112.82 70.71,112.62 70.71,112.4 71.68,111.43 76.94,111.43 83.87,118.35 83.87,119.02 86.17,121.33 88.36,121.33 90.14,123.12 90.14,124.22 90.5,124.58 90.5,125.17 v2(90.13,125.54)
VMA_DQ27: length 27.9
  TOP w0.168: UG1.AC47 68.87,113.73 68.86,113.73 68.86,113.75 68.81,113.8 v2(68.81,113.81) ; VRAM6.P2 89.02,125.93 88.65,125.56 v2(88.65,125.56)
  IN1 w0.127: v2(68.81,113.81) 68.81,113.78 69.09,113.5 70.56,113.5 70.78,113.28 71.94,113.28 72.19,113.03 76.28,113.03 82.27,119.02 82.27,119.68 85.51,122.93 87.3,122.93 87.51,123.14 87.51,124.97 87.72,125.18 88.27,125.18 88.64,125.56 v2(88.65,125.56)
VMA_DQ28: length 24
  TOP w0.168: UG1.AA47 69.49,114.48 69.99,114.23 70.05,114.04 v2(70.08,114.02) ; VRAM6.U3 v2(86.39,124.81)
  IN1 w0.127: v2(86.39,124.81) 86.02,124.43 85.47,124.43 84.32,123.28 84.32,122.49 81.73,119.9 81.73,119.24 76.06,113.56 71.41,113.56 71.36,113.51 70.87,113.51 70.65,113.73 70.65,113.88 70.52,114.02 70.08,114.02 v2(70.08,114.02)
VMA_DQ29: length 25.1
  TOP w0.168: VRAM6.V3 85.64,125.56 v2(85.64,125.56) ; v2(68.11,114.45) 68.45,114.85 UG1.AA46
  IN1 w0.127: v2(85.64,125.56) 83.78,123.7 83.78,122.71 81.2,120.12 81.2,119.46 75.84,114.09 72.19,114.09 71.47,114.82 70.75,114.82 70.34,114.41 69.22,114.41 68.83,114.8 68.47,114.8 68.11,114.45 v2(68.11,114.45)
VMA_DQ30: length 27.9
  TOP w0.102: UG1.AA45 67.75,114.85 67.19,114.52 v2(66.73,114.49)
  TOP w0.168: v2(87.14,124.06) VRAM6.U4
  IN2 w0.14: v2(87.14,124.06) 86.77,123.68 86.77,123.12 85.93,122.28 85.56,122.28 76.46,113.18 72.8,113.18 72.53,113.45 70.85,113.45 70.5,113.81 70.5,114.29 70.36,114.43 69.26,114.43 68.86,114.83 67.79,114.83 66.73,114.49 v2(66.73,114.49)
VMA_DQ31: length 26.9
  TOP w0.168: VRAM6.U2 86.77,125.93 v2(86.39,126.31) ; v2(66.68,115.88) 66.72,115.88 67.05,115.55 UG1.Y44
  IN2 w0.14: v2(86.39,126.31) 86.02,125.93 84.74,125.93 84,125.19 84,123.33 75.64,114.97 73.63,114.97 73.57,115.04 72.31,115.04 72.12,115.23 70.84,115.23 70.49,115.58 69.25,115.58 69.19,115.63 67.18,115.63 v2(66.68,115.88)
VMA_DQ32: length 17.9
  TOP w0.168: UG1.AW51 72,102.25 v2(72.32,101.93)
  TOP w0.216: v2(87.14,102.81) VRAM8.B3
  IN4 w0.102: 74.46,101.19 75.06,100.59
  IN4 w0.127: 75.06,100.59 75.4,100.26 82.93,100.26 85.11,102.43 86.77,102.43 v2(87.14,102.81) ; 74.46,101.19 72.52,101.19 72.32,101.4 v2(72.32,101.93)
VMA_DQ33: length 19.9
  TOP w0.102: v2(74.16,100.58) 74.15,100.6 73.7,100.73 73.03,100.85 UG1.BA52
  TOP w0.216: VRAM8.E2 v2(89.39,102.06)
  IN2 w0.14: v2(74.16,100.58) 74.17,100.57 74.17,100.19 74.34,100.01 76.53,100.01 77.3,100.78 82.2,100.78 84.6,103.19 88.83,103.19 89.01,103 89.03,102.99 89.03,102.43 v2(89.39,102.06)
VMA_DQ34: length 21.2
  TOP w0.168: v2(70.9,101.95) 70.9,101.97 71.19,102.25 UG1.AW50
  TOP w0.216: v2(88.64,102.81) VRAM8.E3
  IN4 w0.102: v2(70.9,101.95) 70.9,101.97 71.3,102.36 72.62,102.36 72.76,102.21 74.23,102.21 75.03,101.41 75.56,101.41
  IN4 w0.127: 75.56,101.41 76.18,100.79 82.26,100.79 84.66,103.18 87.3,103.18 87.52,102.96 87.52,102.63 87.72,102.44 88.27,102.44 v2(88.64,102.81)
VMA_DQ35: length 17.1
  TOP w0.168: v2(71.5,101.41) 71.5,101.38 71.95,100.9 UG1.BA51
  TOP w0.216: v2(85.64,102.06) VRAM8.A3
  IN4 w0.102: 75.56,99.72 74.37,99.72 73.28,100.81 72.45,100.81 71.93,101.32
  IN4 w0.127: 71.93,101.32 71.63,101.32 71.55,101.41 v2(71.5,101.41) ; 75.56,99.72 83.31,99.72 v2(85.64,102.06)
VMA_DQ36: length 26.7
  TOP w0.168: UG1.BA50 70.9,100.48 v2(70.9,100.46)
  TOP w0.216: v2(90.89,102.06) VRAM8.G2
  IN2 w0.14: v2(90.89,102.06) 90.89,101.85 90.52,101.47 90.52,100.31 89.53,99.33 85.09,99.33 82.99,97.22 79.41,97.22 79.02,96.83 73.89,96.83 72,98.72 71.22,98.72 70.47,99.47 70.47,100.02 70.59,100.19 70.65,100.25 70.88,100.46 v2(70.9,100.46)
VMA_DQ37: length 22.6
  TOP w0.168: v2(71.25,99.43) UG1.BB50
  TOP w0.216: v2(90.14,101.31) VRAM8.F2
  IN2 w0.14: v2(71.25,99.43) 71.46,99.28 71.6,99.3 71.94,99.35 71.97,99.35 72.15,99.53 72.46,99.53 72.79,99.2 73.33,99.2 74.41,98.12 82.83,98.12 84.8,100.1 89.61,100.1 89.77,100.26 89.77,100.93 v2(90.14,101.31)
VMA_DQ38: length 20.7
  TOP w0.168: v2(70.17,101.23) 70.55,100.88 UG1.BA49
  TOP w0.216: v2(87.14,101.31) VRAM8.B2
  IN4 w0.102: v2(70.17,101.23) 70.42,100.97 71.81,100.97 72.42,100.37 72.42,99.56 73.32,98.66 75.11,98.66
  IN4 w0.127: 75.11,98.66 83.12,98.66 85.39,100.93 86.55,100.93 86.93,101.31 v2(87.14,101.31)
VMA_DQ39: length 18.6
  TOP w0.168: v2(70.2,102.57) 70.21,102.56 70.24,102.56 UG1.AW49
  TOP w0.216: v2(86.39,103.56) 86.77,103.18 VRAM8.B4
  IN4 w0.102: v2(70.2,102.57) 70.27,102.57 70.6,102.9 72.62,102.9 72.97,102.55 74.7,102.55 75.11,102.14 75.56,102.14
  IN4 w0.127: 75.56,102.14 82.79,102.14 84.67,104.02 85.93,104.02 v2(86.39,103.56)
VMA_DQ40: length 26.4
  TOP w0.168: UG1.AV48 69.85,103 69.57,103.27 v2(69.57,103.34)
  TOP w0.216: VRAM8.E13 v2(89.39,109.56)
  IN1 w0.127: v2(69.57,103.34) 69.94,102.97 70.73,102.97 71.24,102.46 74.51,102.46 74.91,102.07 76.44,102.07 76.77,102.39 81.72,102.39 85.7,106.37 88.46,106.37 89.02,106.93 89.02,108.29 89.16,108.43 89.57,108.43 89.77,108.63 89.77,109.19 v2(89.39,109.56)
VMA_DQ41: length 23.5
  TOP w0.168: UG1.AT49 70.92,103.98 v2(70.92,103.95)
  TOP w0.216: VRAM8.F13 v2(90.16,110.32)
  IN2 w0.14: v2(70.92,103.95) 70.96,103.95 71.25,104.24 72.37,104.24 72.81,104.67 79.19,104.67 85.41,110.9 85.94,110.9 86.11,110.73 89.52,110.73 89.93,110.32 v2(90.16,110.32)
VMA_DQ42: length 22.7
  TOP w0.168: v2(68.66,103.84) 68.65,103.84 68.65,103.84 68.64,103.84 UG1.AT47
  TOP w0.216: VRAM8.B13 v2(86.39,109.56)
  IN1 w0.127: v2(86.39,109.56) 86.06,109.89 86.06,109.89 85.93,110.02 85.33,110.02 84.29,108.98 84.29,108.16 80.58,104.45 75.28,104.45 75.08,104.65 72.94,104.65 72.34,104.05 71.81,104.05 71.5,104.36 69.29,104.36 68.78,103.84 v2(68.66,103.84)
VMA_DQ43: length 21.3
  TOP w0.168: v2(70.06,103.91) 70.07,103.93 UG1.AT48
  TOP w0.216: VRAM8.B11 86.39,108.06 v2(86.38,108.06)
  IN2 w0.14: v2(70.06,103.91) 70.12,103.96 70.32,103.96 70.65,103.63 70.65,103.25 71.09,102.81 71.79,102.81 71.94,102.96 72.63,102.96 73.04,102.55 73.25,102.55 73.44,102.36 74.86,102.36 75.02,102.2 75.71,102.2 76.3,102.8 80.75,102.8 84.79,106.84 85.82,106.84 86,107.03 86,107.67 86.38,108.04 v2(86.38,108.06)
VMA_DQ44: length 25.9
  TOP w0.168: v2(68.11,104.69) 68.11,104.66 68.45,104.35 UG1.AT46
  TOP w0.216: VRAM8.B12 86.77,109.18 v2(87.14,108.81)
  IN2 w0.14: v2(87.14,108.81) 86.79,108.45 86.79,106.69 86.01,105.92 84.91,105.92 81.25,102.26 76.53,102.26 75.84,101.57 74.95,101.57 74.43,102.08 73.38,102.08 73.15,102.31 72.94,102.31 72.68,102.57 70.97,102.57 70.58,102.97 69.36,102.97 69.17,103.15 69.17,103.64 69.07,103.74 69.07,104.23 68.89,104.41 68.39,104.41 v2(68.11,104.69)
VMA_DQ45: length 20.8
  TOP w0.102: UG1.AV51 72.37,103.37 74.08,103.37 v2(74.48,102.97)
  TOP w0.216: VRAM8.E12 v2(88.64,108.81)
  IN1 w0.102: 75.58,103.1 74.6,103.1 v2(74.48,102.97)
  IN1 w0.127: v2(88.64,108.81) 88.27,108.43 88.27,107.09 88.08,106.91 85.23,106.91 81.43,103.1 75.58,103.1
VMA_DQ46: length 16.2
  TOP w0.102: UG1.AV52 73.24,102.95 v2(73.25,102.94)
  TOP w0.216: VRAM8.A12 86.02,109.18 v2(85.64,108.81)
  IN1 w0.127: v2(85.64,108.81) 85.64,108.63 85.16,108.15 85.16,107.93 80.87,103.64 73.95,103.64 v2(73.25,102.94)
VMA_DQ47: length 26.3
  TOP w0.102: UG1.AV49 70.92,102.58 72.8,102.58 72.92,102.47 v2(73.6,101.68)
  TOP w0.216: VRAM8.G13 v2(90.89,109.56)
  IN1 w0.127: v2(73.6,101.68) 74.24,101.03 81.29,101.03 86.09,105.84 89,105.84 89.71,106.55 89.71,107.02 89.89,107.2 89.89,107.59 89.97,107.67 89.97,107.95 90.54,108.52 90.54,109.2 v2(90.89,109.56)
