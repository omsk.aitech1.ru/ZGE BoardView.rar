# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TXP13: length 80
  TOP w0.105: UG1.BK41 64.62,93.99 64.61,93.79 64.6,93.72 64.59,93.61 64.41,93.42 64.41,92.83 65.22,92.01 65.9,92.01 66.28,91.63 66.78,91.63 67.11,91.31 67.82,91.31 68.06,91.07 68.06,89.84 68.28,89.61 68.48,89.61 v1(68.75,89.34)
  TOP w0.14: v1(112.36,124.5) 112.5,124.64 112.63,124.64 113.15,124.13 113.79,124.13 C64.1
  IN1 w0.086: v1(112.36,124.5) 112.13,124.72 111.98,124.72 111.79,124.92 109.53,124.92 106.93,122.31 106.93,118.1 103.22,114.39 103.22,110.68 102,109.47 102,100.64 98.96,97.6 98.96,96.8 98.46,96.3 94.31,96.3 93.78,96.82 81.21,96.82 73.56,89.18 70.18,89.18 69.75,89.62 69.02,89.62 v1(68.75,89.34)
PEG_TXP14: length 75.7
  TOP w0.105: UG1.BM41 65.15,93.15 65.33,92.97 65.33,92.82 65.57,92.58 66.08,92.58 66.53,92.12 67.02,92.12 67.34,91.8 68.06,91.8 68.54,91.31 69.22,91.31 69.76,90.77 69.76,90.45 69.98,90.22 70.19,90.22 v1(70.47,89.94)
  TOP w0.14: v1(111.97,126.42) 111.85,126.3 111.85,126.07 112.01,125.92 C59.1
  IN1 w0.086: v1(111.97,126.42) 111.75,126.2 111.75,125.92 111.33,125.51 109.33,125.51 106.29,122.46 106.29,118.25 102.64,114.6 102.64,110.89 101.44,109.69 101.44,100.91 97.97,97.43 80.9,97.43 73.21,89.74 71.81,89.74 71.33,90.22 70.74,90.22 v1(70.47,89.94)
PEG_TXP15: length 75.8
  TOP w0.105: v1(71.95,90.4) 71.95,90.56 71.84,90.66 71.06,90.66 70.7,91.02 70.7,91.55 70.47,91.78 68.74,91.78 68.29,92.23 67.56,92.23 67.16,92.62 66.7,92.62 65.8,93.52 65.8,93.7 UG1.BL42
  TOP w0.14: C58.1 114.04,126.61 113.92,126.74 113.58,126.74 v1(113.33,126.48)
  IN1 w0.086: v1(71.95,90.4) 71.95,90.51 72.17,90.74 72.56,90.74 73.4,91.58 74.27,91.58 80.68,98 97.7,98 100.87,101.16 100.87,109.91 102.07,111.11 102.07,115.02 105.54,118.49 105.54,122.53 109.95,126.94 112.72,126.94 112.95,126.71 113.1,126.71 v1(113.33,126.48)
PEGX_RST#: length 77
  TOP w0.102: 52.6,89.94 52.6,90.49 53.18,91.08 53.18,92.35 53.77,92.93 53.77,93.36 54.1,93.7 54.1,93.97 UG1.BK26
  TOP w0.14: RG43.2 23.41,87.27 QG9.2 22.27,87.69 22.56,87.98 23.11,87.98 v1(23.14,87.95) ; v1(53.44,86.07) 53.44,86.54 53.05,86.93 53.05,88.21 52.6,88.66 52.6,89.94
  IN1 w0.086: v1(53.44,86.07) 53.44,86.71 52.45,87.7 50.29,87.7 v1(49.8,87.21) 49.22,87.21 48.41,88.02 42.12,88.02 40.97,89.17 37.53,89.17 34.85,86.49 34.85,84.02 34.03,83.2 32.84,83.2 32.37,82.73 30.75,82.73 30.12,82.1 27.49,82.1 26.86,81.46 24.95,81.46 23.08,83.33 23.08,83.75 22.5,84.32 22.5,85.54 23.41,86.45 23.41,87.65 23.14,87.93 v1(23.14,87.95) 23.11,87.98 22.63,87.98 21.92,87.27 21.24,87.27 20.66,87.84 20.66,88.33 20.31,88.68 20.09,88.68 18.35,90.42 18.35,94.74 17.37,95.72 v1(17.37,95.73)
  BOTTOM w0.14: RG155.2 17.15,95.95 17.37,95.73 v1(17.37,95.73) ; v1(49.8,87.21) 48.79,86.2 48.79,83.1 48.53,82.85 48.02,82.85 47.77,82.59 47.77,82.44 47.44,82.11 RG185.1 46.36,82.89 RG182.1
PEX_CLKREQ: length 24.4
  TOP w0.102: UG1.BL26 54.45,93.68 54.07,93.3 54.07,92.88 53.43,92.24 53.43,90.64 53.03,90.24 53.03,90
  TOP w0.14: RG70.1 42.84,80.44 42.92,80.36 43.79,80.36 44.4,80.97 QG13.1 44.4,82.17 45.51,83.28 47.96,83.28 48.57,83.89 50.78,83.89 51.24,83.44 51.87,83.44 52.58,84.15 52.58,84.46 53.32,85.2 53.75,85.2 54.12,85.57 v1(54.12,85.92) 54.12,86.35 53.4,87.07 53.4,88.35 53.03,88.71 53.03,90
PEX_PLL_HVDD: length 0.7
  TOP w0.2: UG1.BB30 57.39,100.15 v2(57.78,100.53)
PEX_TERMP: length 10.8
  TOP w0.105: UG1.BL44 67.38,93.52 67.38,93.07
  TOP w0.135: 67.38,93.07 67.69,92.76 68.42,92.76 68.91,92.27 71.44,92.27 72.18,91.52
  TOP w0.14: RG36.2 73.43,90.57 73.16,90.84 73.05,90.96 72.75,90.96 72.18,91.52
PEXVDD_EN_U: length 10
  TOP w0.14: DG3.2 24.81,80.08 24.81,79.42 25.29,78.93 27.24,78.93 RG80.2 RG74.2 CG82.1 28.29,80.5 v1(28.57,80.21) 28.59,80.2 28.59,80 28.37,79.78 28.37,79.11 28.57,78.91 UG3.2
PGDMON: length 1.9
  TOP w0.14: v1(209.94,37.2) 209.84,37.09 U14.Y14
  BOTTOM w0.14: v1(209.94,37.2) 209.94,36.99 209.38,36.43 R867.2
PIRQ#: length 23.3
  TOP w0.102: v1(217.76,22.97) 217.62,23.1 217.62,23.77 217.3,24.09 U14.BE29
  IN4 w0.086: v1(217.76,22.97) 217.76,22.99 218.6,23.83 220.11,23.83 220.51,23.43 222.79,23.43 224.87,21.35 235.25,21.35 v1(235.88,21.99)
  BOTTOM w0.14: R1018.1 236.1,21.77 v1(235.88,21.99)
PIRQ#_C: length 4.1
  BOTTOM w0.14: R1018.2 237.83,20.93 237.83,19.67 R1064.2 237.89,19.52 238.37,19.04 238.37,18.41 238.93,17.85 U44.18
PLT_ID0: length 16.2
  TOP w0.102: v1(229.41,30.85) 229.41,30.19 228.62,29.4 227.54,29.4 226.82,28.68 226.35,28.68 226.18,28.52 225.94,28.52 U14.AU46
  BOTTOM w0.14: R861.2 236.2,36.76 R871.1 234.92,35.99 v1(234.59,35.66) 234.59,35.39 234.87,35.11 234.87,34.23 234.26,33.62 234.08,33.62 233.39,32.94 231.34,32.94 230.96,32.56 230.96,32.06 230.2,31.3 229.66,31.3 229.41,31.05 v1(229.41,30.85)
PLT_ID1: length 13.7
  TOP w0.102: v1(230.12,30.83) 230.12,30.55 228.77,29.2 227.63,29.2 226.91,28.48 226.49,28.48 U14.AU47
  BOTTOM w0.14: v1(230.12,30.83) 230.32,31.03 231.24,31.95 231.24,32.38 231.51,32.66 233.51,32.66 234.19,33.34 235.44,33.34 R889.1 236.29,34.2 R878.2
PLTRST#: length 569.5
  TOP w0.14: R555.2 239.55,16.66 238.67,16.66 238.32,17.01 236.96,17.01 236.75,17.23 236.75,17.92 237.15,18.33 U27.2 239.29,18.33 239.41,18.46 239.41,18.84 239.27,18.98 U27.1 237.82,18.98 237.23,19.57 v1(237.23,19.68) ; R412.1 65.29,25.36 v1(65.14,25.21) ; U31.4 206.99,11.03 206.85,11.17 206.85,11.37 207.16,11.68 R609.2 207.59,12.36 R605.2 209.03,12.84 209.49,12.84 v1(209.7,13.05) ; v1(207.1,51.47) 207.1,52.37 207.57,52.84 R1151.2 208.61,52.84 R162.2 ; v1(195.48,42.65) 195.48,42.98 194.97,43.49 R201.2 ; v1(51.07,43.03) 50.75,43.03 50.19,43.58 R200.2
  IN1 w0.086: v1(65.14,25.21) 65.47,25.21 66.24,24.45 66.24,23.46 66.06,23.28 66.06,22.4 67.22,21.24 71.04,21.24 74.54,17.74 74.54,14.67 74.85,14.37 83.38,14.37 83.64,14.62 83.64,15.41 84.17,15.94 84.17,16.73 83.08,17.82 v1(83.08,18.2)
  IN2 w0.089: v1(237.23,19.68) 236.78,19.22 236.36,19.22 235.57,20.01 234.21,20.01 233.65,20.57 225.06,20.57 224.43,19.94 221.5,19.94 220.34,18.77 217.38,18.77 215.68,17.08 215.68,13.83 215.05,13.2 214.48,13.2 213.71,13.97 211.41,13.97 210.87,13.43 210.08,13.43 v1(209.7,13.05) ; v1(254.6,27.7) 254.88,27.98 254.88,31.16 253.13,32.91 253.13,34.89 253.82,35.58 253.82,37.02 254.96,38.17 254.96,45.58 v1(254.43,46.12) ; v1(26.72,47.89) 27.03,48.2 27.03,51.5 25.37,53.15 24.83,53.15 24.59,52.91 22.54,52.91 21.92,53.54 21.48,53.54 20.97,54.04 20.97,54.8 19.39,56.39 18.82,56.39 18.81,56.4 18.27,56.4 17.07,57.6 17.07,58.84 16.13,59.78 16.13,59.8 15.98,59.95 15.98,60.44 14.96,61.45 14.96,70.17 14.71,70.42 14.71,76.65 13.77,77.58 13.77,78.35 14.23,78.81 14.23,83.33 14.45,83.55 14.45,83.82 16.67,86.05 20.38,86.05 23.13,83.3 23.13,82.28 24.29,81.12 30.51,81.12 30.78,80.85 32.09,80.85 32.84,80.1 34.03,80.1 34.88,80.95 37.07,80.95 37.7,80.32 39.85,80.32 41.19,81.65 44.04,81.65 45.33,82.95 49.24,82.95 50.37,81.82 v1(51.1,81.82)
  IN3 w0.089: v1(47.16,33.21) 48.42,33.21 50.36,31.27 51.03,31.27 51.65,30.65 52.58,30.65 53.82,29.41 54.39,29.41 55.9,27.9 55.9,27.3 56.79,26.4 58.78,26.4 60.42,24.76 61.21,24.76 61.37,24.6 62.5,24.6 63.66,25.77 64.05,25.77 64.21,25.61 64.75,25.61 v1(65.14,25.21) ; v1(254.43,46.12) 254.35,46.19 249.58,46.19 249.17,46.6 247.41,46.6 246.47,45.66 244.84,45.66 243.49,44.31 243.49,43.7 242.56,42.76 239.53,42.76 238.61,41.84 237.78,41.84 237.32,42.31 235.04,42.31 234.71,42.65 233.05,42.65 232.67,43.02 231.41,43.02 231.11,42.71 225.04,42.71 223.37,41.04 222.8,41.04 222.28,41.56 221.76,41.56 221.21,41.01 217.95,41.01 217.54,41.42 214.9,41.42 212.25,44.07 212.25,47.53 210.13,49.65 209.79,49.65 207.98,51.47 v1(207.1,51.47) 203.94,51.47 203.12,50.65 203.12,45.11 201.76,43.76 199.21,43.76 198.14,42.69 195.52,42.69 v1(195.48,42.65) ; v1(237.23,19.68) 237.23,19.88 238.4,21.05 239.25,21.05 239.8,21.6 239.8,22.29 240.87,23.36 242.9,23.36 244.2,24.66 244.2,27.69 245.45,28.93 252.15,28.93 253.38,27.7 v1(254.6,27.7)
  IN4 w0.086: v1(12.82,29.73) 12.63,29.93 12.63,34.65 13.39,35.41 13.39,38.53 14.56,39.69 16.8,39.69 17.95,38.55 19.22,38.55 20.77,37 25.18,37 26.47,38.29 v1(27.06,38.29) 27.43,38.29 29.34,36.38 29.34,35.41 29.93,34.82 31.56,34.82 32.18,34.19 35.11,34.19 36.01,35.1 37.46,35.1 38.52,34.03 39.36,34.03 40,33.39 41.27,33.39 43.19,35.31 45.68,35.31 46.32,34.66 46.32,34.05 v1(47.16,33.21) 47.8,33.85 48.03,33.85 48.46,34.27 48.46,34.56 50,36.1 51.8,36.1 52.12,35.78 53.48,35.78 55.83,38.14 56.41,38.14 56.89,38.62 56.89,38.93 56.64,39.18 56.64,45.61 56.11,46.14 54.83,46.14 51.72,43.03 v1(51.07,43.03) ; v1(83.08,18.2) 81.48,19.8 81.48,20.67 81.86,21.05 84.11,21.05 86.08,23.01 90.34,23.01 90.82,23.5 92.17,23.5 92.35,23.68 94.85,23.68 96.29,25.12 99.28,25.12 99.78,25.62 115.98,25.62 116.48,25.13 118.83,25.13 119.24,25.54 122.42,25.54 124.14,27.26 132.19,27.26 134.06,25.39 138.48,25.39 139.87,24 148.43,24 150.04,25.62 152.12,25.62 153.17,26.66 163.34,26.66 164.81,28.14 173.16,28.14 173.39,28.37 179.14,28.37 180.93,26.57 183.65,26.57 191.94,18.28 193.74,18.28 194.55,17.46 194.55,16.44 198.72,12.27 207.34,12.27 207.63,12.55 209.2,12.55 v1(209.7,13.05)
  BOTTOM w0.14: CN17.35 12.24,31 12.72,30.52 12.72,29.84 v1(12.82,29.73) ; v1(51.1,81.82) 50.88,81.82 49.93,82.77 49.14,82.77 48.91,82.54 UG7.2 ; U44.17 238.43,17.9 238.25,18.08 237.13,18.08 236.74,18.46 236.74,19.19 v1(237.23,19.68) ; v1(26.72,47.89) 25.92,47.89 24.78,46.75 21.77,46.75 21.65,46.63 20.93,46.63 20.68,46.38 20.68,45.86 20.18,45.37 20.18,45.1 19.96,44.88 19.96,43.38 19.79,43.21 19.79,40.83 20.1,40.51 20.1,40.03 22.13,38.01 25.84,38.01 26.11,38.29 v1(27.06,38.29)
PLTRST#_EC: length 2.9
  TOP w0.14: U18.22 68.48,25.02 v1(68.08,24.62) 67.85,24.62 67.12,25.36 R412.2
PM_SYNC: length 112.5
  TOP w0.114: v1(157.94,128.27) 157.61,128.59 U3.BM34
  TOP w0.14: v1(191.71,46.78) 192.08,46.78 192.96,45.91 192.96,45.04 193.59,44.41 193.59,43.63 194.25,42.97 194.25,42.47 194.53,42.18 195.7,42.18 R219.1
  IN2 w0.089: v1(191.71,46.78) 191.71,47.9 188.76,50.85 188.76,53.9 188.36,54.3 186.51,54.3 184.88,55.92 183.99,55.92 181.97,57.95 181.97,58.87 180.71,60.13 180.71,60.45 179.64,61.52 179.64,62.21 179.03,62.82 178.18,62.82 175.4,65.61 175.4,72.88 174.58,73.7 174.58,80.53 175.4,81.35 175.4,84.4 176.67,85.67 176.67,90.13 177.23,90.69 177.23,94.43 176.93,94.73 176.93,107.03 172.39,111.56 172.39,114.3 170.33,116.36 170.33,122.06 167.32,125.07 166.46,125.07 165.39,126.15 164.77,126.15 163.35,127.56 161.9,127.56 161.38,127.04 159.16,127.04 v1(157.94,128.27)
PM_SYNC_R: length 13.8
  TOP w0.102: U14.AF3 204.49,33.54 204.19,33.54 203.96,33.76 202.65,33.76 202.47,33.58 202.06,33.58 201.14,34.5 201.14,37.77
  TOP w0.14: R219.2 v1(197.17,40.67) 197.37,40.46 198.61,40.46 198.85,40.23 199.23,40.23 199.66,39.8 199.66,39.26 201.14,37.77
PM_THRMTRIP#: length 363.6
  TOP w0.14: R348.1 140.73,33.43 R333.1 140.91,33.39 140.91,31.73 140.92,31.72 v1(140.92,31.61) ; R51.1 113.66,130.46 111.94,130.46 111.07,129.59 109.72,129.59 109.46,129.86 108.2,129.86 108,129.66 108,128.5 107.56,128.06 v1(107.56,127.52)
  IN1 w0.086: v1(90.6,48.94) 91.21,49.55 92.62,49.55 93.28,50.21 95.27,50.21 96.59,48.89 96.59,48.59 96.73,48.44 96.73,48.11 96.59,47.97 96.59,47.08 97.77,45.9 97.77,42.35 97.6,42.17 97.6,41.56 96.43,40.39 96.43,39.04 96.68,38.78 97.56,38.78 97.79,39.01 v1(97.79,39.01)
  IN2 w0.089: v1(22.8,160.52) 22.8,160.2 24.23,158.78 24.95,158.78 26.1,159.93 26.99,159.93 28.31,158.61 30.67,158.61 32.09,160.03 37.78,160.03 38.47,160.73 41.64,160.73 41.9,160.47 43.92,160.47 45.31,161.86 46.37,161.86 47.41,160.82 56.78,160.82 57.31,161.35 60.88,161.35 60.93,161.31 62.82,161.31 64.62,159.51 64.91,159.51 65.5,158.92 67.8,158.92 69.6,160.72 70.37,160.72 71.57,161.93 71.98,161.93 72.73,162.67 75.04,162.67 75.29,162.43 75.29,162.17 75.86,161.6 75.94,161.6 76.36,161.17 77.62,161.17 79.36,162.92 81.89,162.92 84.55,160.26 97.13,160.26 97.5,159.89 103.67,159.89 103.83,160.05 105.15,160.05 105.5,159.7 105.5,158.87 103.78,157.14 103.78,151.55 105.5,149.83 105.5,146.24 106.71,145.04 106.71,129.64 107.56,128.79 v1(107.56,127.52) 107.56,127.14 106.96,126.54 106.96,111.66 106.03,110.73 106.03,98.61 104.92,97.5 104.92,93.12 104.81,93 104.81,89.83 105.6,89.03 105.6,87.67 107.18,86.09 107.18,84.06 106.57,83.45 106.57,80.84 103.95,78.22 102.84,78.22 101.88,77.26 101.88,76.06 101.35,75.54 101.35,73.72 96.12,68.48 v1(96.12,67.93) 96.16,67.89 96.16,61.79 96.58,61.37 96.58,56.6 95.9,55.92 95.9,52.95 95.52,52.57 94.98,52.57 94.38,51.97 94.38,51.97 94.01,51.6 94.01,50.99 93.64,50.62 92.92,50.62 91.23,48.93 90.61,48.93 v1(90.6,48.94)
  IN4 w0.086: v1(115.26,31.61) 115.78,31.09 140.4,31.09 v1(140.92,31.61) 141.45,31.09 149.09,31.09 149.64,30.53 151.07,30.53 151.49,30.95 151.49,31.11 151.77,31.39 152.16,31.39 152.64,30.91 165.36,30.91 165.74,31.29 174.88,31.29 180.43,36.84 188.24,36.84 188.77,36.31 193.85,36.31 193.91,36.25 v1(194.15,36.25)
  BOTTOM w0.14: R721.1 95.66,66.58 R718.1 96.12,67.48 v1(96.12,67.93) ; R845.2 199.4,38.37 198.16,37.13 195.85,37.13 195.42,36.69 194.81,36.69 194.37,36.25 v1(194.15,36.25) ; D88.2 21.71,159.43 v1(22.8,160.52) ; v1(115.26,31.61) 115.26,32.1 111.92,35.44 101.92,35.44 100.09,37.26 100.09,37.72 99.13,38.69 98.11,38.69 97.79,39.01 v1(97.79,39.01)
PM_THRMTRIP#_L: length 9.1
  TOP w0.102: v1(201.59,37.1) 201.34,36.85 201.34,34.89 201.64,34.59 202.46,34.59 202.63,34.41 203.3,34.41 203.49,34.22 204.16,34.22 204.21,34.27 204.37,34.27 U14.AD3
  BOTTOM w0.14: v1(201.59,37.1) 201.59,37.78 C800.1 200.77,37.97 R855.1 200.18,37.84 R845.1
PMON: length 224.3
  TOP w0.14: v1(103.55,56.68) 102.97,56.68 101.64,58 101.64,59.33 99.93,61.05 99.22,61.05 98.88,60.7 98.88,59.85 99.15,59.57 PR193.1 99.42,59.57 100.07,58.92 100.07,55.75 99.54,55.22 PC169.2 99.42,54.88 98.91,54.37 PR252.1
  TOP w0.203: v1(178.23,160.45) 178.23,161.09 178.43,161.29 PR71.1
  IN3 w0.089: v1(178.23,160.45) 178.79,159.89 178.79,158.58 177.79,157.58 177.79,153.19 174.35,149.75 174.35,146.7 173.1,145.45 173.1,137.74 170.87,135.52 170.87,131 170.14,130.26 170.14,127.67 169.52,127.05 169.52,125.14 170.14,124.53 170.14,113.9 169.31,113.07 169.31,112.23 169.6,111.94 170.21,111.94 172.79,109.36 172.79,94.33 171.82,93.36 171.82,92.83 173.35,91.3 173.35,88.94 172.45,88.04 172.45,85.94 171.44,84.93 171.44,81.14 171.82,80.77 171.82,67.16 175.16,63.81 175.16,63.13 175.76,62.53 175.76,61.27 176.51,60.52 176.51,60.21 176.32,60.01 176.32,58.43 v1(179,55.75)
  IN4 w0.086: v1(179,55.75) 179,55.72 178.64,55.36 175.6,55.36 172.98,57.98 171.74,57.98 162.13,67.6 117.85,67.6 115.47,65.22 111.15,65.22 110.93,65 103.53,65 102.16,63.63 102.16,57.54 103.02,56.68 v1(103.55,56.68)
PP: length 1.5
  BOTTOM w0.14: U44.4 240.43,10.71 T16.1
PPC_CC1_6:
  vias: v1(247.47,19.44)
PPC_CC2_4:
  vias: v1(247.37,21.69)
PPC_DVDD_IO:
  vias: v1(253,26.86) v1(253.66,26.86)
PPC_DVDD_IO_13: length 3.4
  TOP w0.14: C444.2 v1(253.82,19.22) 253.38,19.22 252.82,19.79 U23.13
  BOTTOM w0.14: v1(253.82,19.22) 253.87,19.16 R1061.1
PPC_DVDD_IO_C:
  vias: v1(251.17,24.88)
PPC_FW_ID: length 3
  TOP w0.14: R525.1 250.05,17.74 v1(250.05,18.61) 249.97,18.69 U23.8
  BOTTOM w0.14: v1(250.05,18.61) 250.09,18.56 250.09,17.82 R1076.2
PPC_HPD_11: length 3.4
  TOP w0.14: U23.11 251.47,19.09 251.81,18.75 251.81,18.16 R526.2 R527.2
PPC_I2C_ADR_1: length 5
  TOP w0.14: R406.2 246.79,26.28 247.45,26.28 247.8,25.94 TP46.1 248.02,25.09 248.02,23.23 248.37,22.88 U23.1
PPC_I2CM_SCL_C: length 2.9
  TOP w0.14: U23.17 v1(253.74,22.38) 253.97,22.38 R435.1
  BOTTOM w0.14: R1001.1 254.51,22.38 v1(253.74,22.38)
PPC_I2CM_SDA_C: length 6.4
  TOP w0.14: R448.1 254.45,21.44 v1(253.88,21.44) 253.43,21.88 U23.16
  BOTTOM w0.14: v1(253.88,21.44) 253.88,21.44 253.13,20.69 253.13,18.66 R1074.1
PPC_I2CS_SCL_18: length 2.5
  TOP w0.14: U23.18 253.48,22.88 253.71,23.11 v1(253.71,23.71) 253.93,23.92 R425.1
PPC_I2CS_SCL_C: length 8
  TOP w0.14: v1(251.34,18.56) 251.34,18.66 250.97,19.03 U23.10
  BOTTOM w0.14: R1077.2 251.21,18.43 v1(251.34,18.56) 251.86,19.07 251.86,19.22 C912.2 252.49,20.14 252.62,20.26 252.62,21.01 253.51,21.91 254.54,21.91 R1013.2
PPC_I2CS_SDA_C: length 3.3
  TOP w0.14: v1(250.69,18.58) 250.47,18.8 U23.9
  BOTTOM w0.14: R1060.2 251.08,19.53 R1046.2 251.24,19.12 v1(250.69,18.58)
PPC_P36: length 2.3
  TOP w0.14: R408.1 249.33,25.17 249.33,24.82 249.97,24.19 U23.23
PPC_VBUS_MON_C: length 4.4
  TOP w0.14: R418.1 R424.1 246.66,23.92 v1(247.49,23.92) 247.72,23.69 247.72,23.11 247.87,22.95 247.87,22.53 248.02,22.38 U23.2
PPC_VBUS_MON_XRES: length 5.7
  TOP w0.14: U23.7 249.47,18.94 249.58,18.83 249.58,17.97 R524.2 R523.2 R522.2 248.04,18.46 TP50.1
PPC_VBUS_MONITOR: length 16.1
  TOP w0.14: R523.1 248.18,16.63 v1(248.65,16.16) ; v1(245.03,24.92) 245.18,25.06 R418.2
  IN4 w0.086: v1(245.03,24.92) 245.92,24.03 247.63,24.03 248.36,23.3 248.36,17.74 248.65,17.45 v1(248.65,16.16)
  BOTTOM w0.14: v1(248.65,16.16) 248.67,16.14 R1116.1 C928.2 248.68,14.33 248.68,13.24 R1136.2
PPC_VCCD_C:
  vias: v1(250.26,24.88) v1(251.73,26.48)
PPC_VCON_5V:
  vias: v1(246.37,20.57) v1(247.21,20.87)
PPC_VDDD_A: length 3.9
  TOP w0.14: U23.12 251.97,18.98 252.14,18.81 252.75,18.81 v1(253.18,18.38) 253.26,18.3 C456.2 R528.1
PPC_VDDD_C:
  vias: v1(252.24,24.88)
PRE_SEL: length 2.7
  BOTTOM w0.14: R648.1 55.23,159.55 53.76,159.55 53.62,159.69 U34.27
PROC_SEL#: length 12.3
  TOP w0.102: 160.4,103.54 160.24,103.7 159.33,103.7 158.2,104.83 U3.BN1
  TOP w0.508: 160.4,103.54 164.12,103.54 v1(165,104.41) 166.46,105.88 R97.2 166.02,107.3 165.98,107.27 R98.1
PROCHOT_EC: length 16.6
  TOP w0.14: U18.17 67.65,27.02 v1(67.56,26.93) ; v1(65.7,35.8) 65.52,35.98 65.52,36.44 64.91,37.05 64.91,37.28 64.47,37.73 Q29.2 63.93,37.73 63.65,38.01 C246.1 62.86,38.37 R268.2
  BOTTOM w0.14: v1(67.56,26.93) 67.56,28.47 66.68,29.35 66.68,30.54 67,30.86 67,32.19 66.16,33.03 66.16,35.34 v1(65.7,35.8)
PROCPWRGD: length 130.4
  TOP w0.114: v1(162.76,128.61) 162.76,128.38 C56.1 163.21,127.43 161.38,127.43 161,127.06 U3.BT31
  TOP w0.14: U14.AE3 205.2,33.44 v1(205.2,33.24)
  IN2 w0.089: v1(205.2,33.24) 204.88,33.24 204.13,33.99 204.13,34.31 202.94,35.5 201.62,35.5 201.26,35.86 201.26,36.17 197.76,39.67 197.76,40.93 195.9,42.79 195.9,42.92 195.34,43.48 195.34,47.34 194.79,47.9 194.79,48.84 194.43,49.2 194.43,51.66 193.71,52.38 193.71,55.78 191.57,57.92 191.26,57.92 190.72,58.46 189.72,58.46 189.05,59.12 187.78,59.12 182.87,64.02 182.87,64.91 181.28,66.5 179.77,66.5 178.54,67.73 178.54,79.78 177.82,80.51 177.82,83.59 181.53,87.31 181.53,88.52 180.19,89.86 180.19,93.14 179.18,94.15 179.18,102.78 178.31,103.65 178.31,109.07 177.38,110 176.93,110 174.2,112.73 174.2,123.87 172.97,125.1 172.97,127.38 171.95,128.4 166.32,128.4 166.01,128.71 162.85,128.71 v1(162.76,128.61)
PS8811_MBCLK: length 216.8
  TOP w0.14: Q33.3 95.94,34.93 96.08,35.07 96.72,35.07 97.1,34.69 97.1,34.17 97.95,33.31 98.55,33.31 98.93,32.93 98.93,29.02 100.04,27.91 v1(100.04,27.42) ; U30.33 276.07,14.85 276.12,14.9 276.12,15.44 v1(276.29,15.61)
  IN2 w0.089: v1(276.29,15.61) 276.09,15.41 276.09,14.88 275.32,14.11 272.46,14.11 271.33,12.98 270.64,12.98 270.34,12.68 266.43,12.68 264.79,11.04 260.3,11.04 260,11.34 258.3,11.34 257.81,10.85 257.25,10.85 257.04,11.06 256.08,11.06 255.47,10.46 253.75,10.46 252.86,11.34 251.16,11.34 250.49,12.01 249.08,12.01 248.42,11.34 244.49,11.34 243.65,10.5 242.05,10.5 240.15,12.4 231.29,12.4 230.66,11.77 226.37,11.77 225.71,11.12 221.94,11.12 221.35,10.53 219.57,10.53 218.24,11.87 212.13,11.87 211.67,11.4 210.29,11.4 209.59,10.7 208.1,10.7 207.37,11.43 202.43,11.43 201.49,10.5 198.27,10.5 195.71,13.06 195.71,15.58 192.94,18.34 191.27,18.34 190.35,19.26 190.35,19.87 189.31,20.9 183.69,20.9 183.2,21.4 179.5,21.4 177.11,23.79 177.11,26.61 177.2,26.7 177.2,27.35 176.67,27.88 168.88,27.88 168.48,27.48 168.07,27.48 166.72,26.13 165.67,26.13 165.16,26.64 152.56,26.64 152.12,26.2 151.87,26.2 151.43,26.64 149.47,26.64 148.48,25.65 141.29,25.65 140.84,25.19 133.83,25.19 130.59,21.95 125.34,21.95 123.24,19.84 116.55,19.84 115.16,21.23 115.16,23.5 113.92,24.74 112.26,24.74 111.31,25.68 101.78,25.68 v1(100.04,27.42)
  BOTTOM w0.14: v1(276.29,15.61) 276.99,15.61 R1128.2
PS8811_MBDATA: length 215.1
  TOP w0.14: v1(276.59,15.03) 276.59,14.77 276.47,14.65 U30.32 ; Q33.6 94.93,33.4 95.62,32.71 96.39,32.71 96.96,33.28 97.26,33.28 v1(97.42,33.12) 97.71,32.83 98.35,32.83 98.65,32.52 98.65,28.9 99.49,28.07 v1(99.49,27.09)
  IN2 w0.089: v1(99.49,27.09) 101.11,25.47 111.26,25.47 112.18,24.55 113.84,24.55 114.97,23.42 114.97,21.15 116.47,19.65 123.32,19.65 125.42,21.76 130.67,21.76 133.7,24.79 140.71,24.79 141.37,25.46 148.65,25.46 148.97,25.78 151.97,25.78 152.63,26.45 165.09,26.45 165.59,25.94 166.8,25.94 168.15,27.29 168.56,27.29 168.96,27.69 175.64,27.69 176.92,26.4 176.92,23.71 179.42,21.21 183.12,21.21 183.62,20.71 189.23,20.71 190.16,19.79 190.16,19.18 191.19,18.15 192.86,18.15 195.52,15.5 195.52,12.98 198.19,10.31 201.57,10.31 202.5,11.24 207.29,11.24 208.02,10.51 209.67,10.51 210.37,11.21 211.74,11.21 212.21,11.68 218.16,11.68 219.58,10.26 225.12,10.26 226.44,11.58 230.74,11.58 231.33,12.16 240.11,12.16 241.97,10.31 243.73,10.31 244.57,11.15 248.49,11.15 249.16,11.82 250.41,11.82 251.08,11.15 252.78,11.15 253.67,10.27 255.55,10.27 256.16,10.87 256.96,10.87 257.17,10.66 257.89,10.66 258.38,11.15 259.92,11.15 260.22,10.85 264.88,10.85 266.52,12.49 270.56,12.49 270.85,12.79 271.48,12.79 272.61,13.92 275.48,13.92 v1(276.59,15.03)
  BOTTOM w0.14: v1(276.59,15.03) 276.69,14.93 R1127.2
PS8817_A1_EQ: length 3.4
  TOP w0.14: U21.43 54.64,23.42 v1(54.51,23.29)
  BOTTOM w0.14: v1(54.51,23.29) 54.25,23.03 R994.1 R1009.2
PS8817_A2_EQ: length 3.5
  TOP w0.14: v1(54.6,27.23) 54.81,27.02 U21.34
  BOTTOM w0.14: R923.2 R938.1 54.25,27.23 v1(54.6,27.23)
PS8817_ADDR: length 3.2
  TOP w0.14: R516.1 58.82,19.84 R469.2 58.73,20.14 59.2,20.62 59.2,21.1 59.06,21.24 U21.53
PS8817_B1_DE: length 5.6
  TOP w0.14: U21.6 60.52,24.22 60.81,23.93 61.45,23.93 v1(61.66,24.15)
  BOTTOM w0.14: v1(61.66,24.15) 61.66,23.94 62.39,23.22 R995.2 62.39,22.73 62.99,22.13 v1(63.23,22.14) 63.92,22.14 R1010.1
PS8817_B1_EQ: length 3.5
  TOP w0.14: v1(61.04,24.36) 60.78,24.62 U21.7
  BOTTOM w0.14: v1(61.04,24.36) 61.46,24.78 61.81,24.78 R962.1 62.33,25.09 R979.2
PS8817_B2_DE: length 5.3
  TOP w0.14: U21.25 57.46,30.17 56.91,30.72 56.91,32.32 R354.1 57.93,33.34 v1(57.93,33.65) 57.93,34.32 R308.2
PS8817_B2_EQ: length 5.3
  TOP w0.14: U21.23 58.26,30.19 58.49,30.42 58.91,30.42 59.2,30.7 59.2,31.93 R353.1 58.43,32.7 58.43,33.23 58.78,33.58 R309.2
PS8817_DCI_CLK: length 5.5
  TOP w0.14: U21.15 60.53,27.82 60.77,28.06 61.87,28.06 62.03,27.9 63.38,27.9 63.54,28.06 64.99,28.06 TP39.1
PS8817_DCI_DATA: length 4.1
  TOP w0.14: TP38.1 64.05,28.51 62.03,28.51 61.82,28.3 60.59,28.3 60.52,28.22 U21.16
PS8817_DCI_EN: length 5.2
  TOP w0.14: R310.2 59.75,33.71 59.51,33.47 59.51,32.51 R350.1 60.24,31.17 59.53,30.46 59.34,30.46 59.06,30.17 U21.21
PS8817_EN: length 1.5
  TOP w0.14: R363.2 60.43,30.79 U21.20
PS8817_MBCLK: length 85.4
  TOP w0.14: U21.51 58.26,21.39 57.98,21.12 v1(57.98,20.86) ; Q46.4 61.73,14.63 R567.2 61.74,14.34 61.64,14.24 v1(58.57,14.24) 56.94,14.24 56.46,14.72 v1(56.46,14.89)
  IN1 w0.086: v1(56.46,14.89) 56.86,15.29 56.86,16.02 57.63,16.79 57.63,19.26 56.13,20.77 56.13,21.13 56.4,21.4 57.44,21.4 v1(57.98,20.86)
  IN4 w0.086: v1(56.46,14.89) 55.99,14.42 54.81,14.42 54.14,15.09 49.44,15.09 47.18,17.35 35.94,17.35 35.23,16.64 35.23,15.71 34.35,14.83 32.42,14.83 32.03,15.23 29.04,15.23 28.77,14.96 27.31,14.96 25.11,17.16 19.96,17.16 19.32,16.53 16.55,16.53 14.59,14.57 14.31,14.57 11.77,12.03 9.11,12.03 8.07,13.07 8.07,15.13 7.62,15.58 7.62,18.32 8.61,19.31 10.19,19.31 10.3,19.2 11.24,19.2 12.46,20.43 v1(12.46,20.64)
  BOTTOM w0.14: v1(12.46,20.64) 12.46,20.32 12.14,20 CN17.13
PS8817_MBDATA: length 78
  TOP w0.14: v1(57.12,14.88) 57.12,14.91 57.5,15.28 57.63,15.28 58.24,15.9 R562.2 58.8,15.9 59.07,15.63 Q46.1 ; U21.50 57.86,21.47 57.32,20.93 v1(57.32,20.87)
  IN1 w0.086: v1(57.12,14.88) 57.12,16.01 57.92,16.8 57.92,19.54 57.32,20.13 v1(57.32,20.87)
  IN4 w0.086: v1(10.53,19.65) 10.43,19.75 8.43,19.75 7.18,18.51 7.18,15.39 7.63,14.95 7.63,12.89 8.93,11.59 11.95,11.59 14.49,14.13 14.78,14.13 16.74,16.08 19.51,16.08 20.14,16.72 24.93,16.72 27.13,14.52 28.95,14.52 29.22,14.79 31.84,14.79 32.24,14.39 34.54,14.39 35.67,15.53 35.67,16.46 36.12,16.91 47,16.91 49.26,14.65 53.92,14.65 54.59,13.98 56.22,13.98 v1(57.12,14.88)
  BOTTOM w0.14: CN17.12 10.69,19.5 v1(10.53,19.65)
PS8817_MODE: length 3.5
  TOP w0.14: U21.48 57.06,21.44 56.92,21.3 56.36,21.3 55.99,20.94 R467.2 R499.1
PS8817_RESETB: length 5.3
  TOP w0.14: U21.26 57.06,30.18 56.18,31.06 v1(56.18,31.51) 56.18,32.28 C327.2 56.39,32.77 56.84,33.21 R306.1
PS8817_REXT: length 2.5
  TOP w0.14: R463.2 54.76,20.88 55.19,21.31 55.96,21.31 56.47,21.82 U21.47
PS_FBVDD_PGOOD: length 224.9
  TOP w0.14: v1(48.93,78.03) 48.52,77.62 43.65,77.62 43.39,77.88 DG4.2 ; PR35.2 14.98,165.32 15.15,165.15 16.02,165.15 v1(16.2,164.98) ; Q3.2 79.28,160.48 78.99,160.77 78.99,162.14 v1(78.12,163.01)
  IN1 w0.086: v1(40.86,88.56) 40.61,88.31 39.62,88.31 39.46,88.15 37.22,88.15 36.6,87.54 36.6,86.12 36.33,85.85 36.33,84.84 37.04,84.13 43.18,84.13 44.4,82.92 45.73,82.92 46.2,82.45 47.71,82.45 48.89,81.27 48.89,78.07 v1(48.93,78.03)
  IN2 w0.089: v1(78.12,163.01) 78.12,162.91 76.98,161.76 76.6,161.76 76.18,162.18 76.1,162.18 75.87,162.41 75.87,162.67 75.28,163.26 71.47,163.26 70.88,162.68 70.88,162.07 70.33,161.51 69.67,161.51 69.27,161.9 68.52,161.9 66.72,160.1 64.86,160.1 63.07,161.89 61.17,161.89 61.13,161.93 57.07,161.93 56.54,161.4 49.58,161.4 48.53,162.44 45.07,162.44 43.68,161.05 42.14,161.05 41.88,161.31 38.23,161.31 37.57,160.66 31.38,160.66 30.21,159.48 27.86,159.48 27.11,160.23 25.98,160.23 24.83,159.07 24.38,159.07 23.41,160.04 23.41,160.52 18.9,165.03 17.32,165.03 16.96,165.4 16.53,165.4 16.2,165.07 v1(16.2,164.98) 16.2,164.97 16.2,164.96 16.15,164.91 16.15,164.68 16.74,164.09 18.98,164.09 21.91,161.15 21.91,159.11 22.4,158.62 22.4,154.22 20.16,151.98 20.16,148.84 19.78,148.46 19.78,148.17 17.41,145.79 14.61,145.79 9.51,140.7 7.76,140.7 7.33,140.26 7.33,131.42 6.82,130.91 6.82,105.1 9.96,101.96 11.64,101.96 15,98.6 15.07,98.6 17.82,95.85 18.66,95.85 20.07,94.44 22.48,94.44 22.89,94.04 23.71,94.04 26.78,90.97 26.78,90.33 27.87,89.24 32.78,89.24 33.06,88.96 38.51,88.96 39.26,88.21 40.51,88.21 v1(40.86,88.56)
  BOTTOM w0.14: v1(48.93,78.03) 49.12,78.03 49.88,78.79 UG10.1
PS_USB_VBUS_DSH_QR:
  vias: v1(109.9,139.51)
PS_USB_VDDP_IN: length 33
  TOP w0.254: v2(45.18,97.45) 45.18,97.52 UG1.BE12
  IN1 w0.508: v1(18.75,100.04) 18.75,99.62 17.87,98.75 17.87,96.77 19.86,94.78 22.97,94.78 23.43,94.32 24.75,94.32 25.22,94.78 26.96,94.78 27.43,94.32 29.8,94.32 30.01,94.53 31.34,94.53 32.59,95.79 32.59,100 33.67,101.08 39.12,101.08 39.56,100.65
PS_USBC_PD_BST1: length 2.1
  TOP w0.203: PU7.16 102.51,154.33 102.81,154.63 102.81,155.01 103.19,155.4 PR88.2
PS_USBC_PD_BST1_R: length 1
  TOP w0.203: PR88.1 104.46,155.39 PC79.1
PS_USBC_PD_BST2: length 1.9
  TOP w0.203: PU7.13 102.79,152.83 103.69,151.94 PR104.2
PS_USBC_PD_BST2_R: length 1
  TOP w0.203: PR104.1 104.47,152.33 104.48,152.34 PC81.2
PS_USBC_PD_EN: length 2.9
  TOP w0.203: PR87.2 98.36,156.11 PC76.1 99.88,156.11 100.58,155.41 PU7.3
PS_USBC_PD_OC: length 2.3
  TOP w0.203: PR102.1 98.18,153.1 PC80.1 98.51,153.11 98.73,153.33 PU7.7
PS_USBC_PD_SW1: length 4.2
  TOP w0.203: PC79.2 103.68,154.4 ; 103.68,154.4 103.68,154 103.82,153.86 104.92,153.86 105.35,154.3 ; 103.68,154.4 103.11,153.83 PU7.15
PS_USBC_PD_SW2: length 4.2
  TOP w0.203: PU7.14 103.2,153.33 103.7,152.84 ; 103.7,152.84 103.7,153.29 103.89,153.48 105.15,153.48 105.4,153.23 ; 103.7,152.84 PC81.1
PS_USBC_PD_VCC: length 2.5
  TOP w0.203: PR107.1 98.64,150.91 PC83.1 99.76,150.91 100.08,151.23 PU7.9
PS_USBC_PD_VOUT_1:
  vias: v1(105.02,147.8) v3(103.73,150.13) v3(103.73,149.37) v3(104.49,150.13) v3(104.49,149.37)
PS_VBUS_ALT: length 259.3
  TOP w0.14: v1(244.82,26.81) 245.58,26.81 R394.1 R406.1 ; PR105.2 97.64,150.12 98.35,149.41 98.69,149.41 99.46,148.63 100.64,148.63 100.8,148.79 v1(100.98,148.79)
  IN2 w0.089: v1(244.82,26.81) 244.28,27.36 244.28,31.24 243.94,31.58 243.94,32.91 242.84,34 240.15,34 239.85,34.31 239.85,35.35 240.27,35.77 v1(240.35,35.77)
  IN3 w0.089: v1(189.4,56.23) 192.58,59.41 193.14,59.41 193.55,59 193.55,58.19 197.11,54.63 197.11,48.01 193.94,44.84 193.94,41.38 196.05,39.27 196.05,38.34 199.86,34.53 203.72,34.53 204.67,35.48 204.67,35.72 204.94,36 206.22,36 206.53,35.69 207.52,35.69 208.11,36.28 212.26,36.28 214.84,33.7 220.41,33.7 220.78,34.06 222.07,34.06 222.17,34.15 225.89,34.15 227.29,35.55 231.01,35.55 231.49,35.07 232.76,35.07 233.15,35.46 234.83,35.46 236.07,36.7 237.31,36.7 238.2,35.81 240.31,35.81 v1(240.35,35.77)
  IN4 w0.086: v1(100.98,148.79) 101.91,148.79 102.61,148.1 104.14,148.1 108.99,143.25 108.99,125.83 108.63,125.48 108.63,110.97 109.19,110.41 109.19,105.09 108.68,104.57 108.68,93.86 113.08,89.45 113.08,87.27 117.85,82.5 122.22,82.5 124.97,79.75 165.14,79.75 180.24,64.65 180.24,64.02 181.26,63 181.27,63 181.28,62.99 181.39,62.99 182.67,61.71 182.9,61.71 184.79,59.82 184.79,59.08 187,56.87 188.99,56.87 189.4,56.46 v1(189.4,56.23)
PTP_PWR_EN#: length 0.8
  BOTTOM w0.14: 93.19,16.15 R1162.1
PW_VCC3_ANA_PCIE: length 1.2
  TOP w0.203: v2(263.37,49.48) 263.37,49.46 U7.L16
  BOTTOM w0.254: C742.2 263.83,49.73 263.58,49.48 v2(263.37,49.48)
PW_VCC3_ANA_USB: length 1.1
  TOP w0.203: U7.J16 264.34,49.09 v2(264.63,48.8)
  BOTTOM w0.203: v2(264.63,48.8) 264.54,48.71 C750.2
PWM1_1PH: length 81.1
  TOP w0.203: v1(177.92,171.03) 177.92,170.74 177.63,170.44 PU2.44 ; PR90.1 v1(113.15,155.54)
  IN1 w0.203: v1(177.92,171.03) 177.83,171.12 177.83,171.61 177.06,172.38 172.55,172.38 172.35,172.18 169.84,172.18 169.26,172.76 165.47,172.76 161.59,168.88 158.82,168.88 157.79,167.85 153.3,167.85 151.38,165.93 146.16,165.93 145.3,165.07 143.04,165.07 141.16,166.95 138.74,166.95 138.01,166.22 138.01,166.22 137.27,165.49 128.36,165.49 125.85,162.98 125.85,159.27 124.38,157.8 114.6,157.8 113.26,156.46 113.26,155.65 v1(113.15,155.54)
  BOTTOM w0.203: PR439.1 177.92,169.82 v1(177.92,171.03)
PWM1_4PH_A: length 13
  TOP w0.203: PR60.1 168.26,163.74 v1(168.42,163.9) ; PU2.18 176.03,162.58 175.98,162.53 175.98,162.12 v1(176.18,161.92)
  IN1 w0.203: v1(168.42,163.9) 168.49,163.82 170.81,163.82 172.28,162.34 175.75,162.34 v1(176.18,161.92)
  BOTTOM w0.203: v1(176.18,161.92) 175.71,162.39 PR456.2
PWM2_4PH_A: length 30.1
  TOP w0.203: v1(157.94,163.9) 157.94,163.84 PR59.1 ; PR74.2 177.6,161.06 176.95,161.72 v1(176.79,161.72) 176.79,162.01 176.43,162.38 PU2.19
  IN1 w0.203: v1(176.79,161.72) 176.79,162.12 176.47,162.44 176.47,162.73 175.98,163.22 174,163.22 170.12,167.1 170.12,167.54 168.81,168.85 164.36,168.85 163.54,168.04 159.18,168.04 157.94,166.81 v1(157.94,163.9)
PWM3_4PH_A: length 44.7
  TOP w0.203: v1(177.81,161.88) 177.41,161.88 176.83,162.46 PU2.20 ; v1(146.86,164.33) 147.18,164.33 147.56,163.95 PR58.1
  IN1 w0.203: v1(146.86,164.33) 147.59,165.07 147.59,165.43 147.79,165.62 151.51,165.62 153.43,167.54 157.92,167.54 158.72,168.34 162.2,168.34 163.77,169.92 169.34,169.92 171.6,167.66 172.66,167.66 173.12,167.2 173.12,166.03 175.08,164.08 176.04,164.08 176.96,163.16 176.96,162.39 177.47,161.88 v1(177.81,161.88)
  BOTTOM w0.203: v1(177.81,161.88) 177.41,161.88 176.62,162.67 PR453.2
PWM4_4PH_A: length 54
  TOP w0.203: v1(136.54,164.73) 136.75,164.53 136.75,164.13 136.77,164.1 PR57.1 ; v1(177.5,162.49) 177.43,162.49 177.23,162.7 PU2.21
  IN4 w0.203: v1(177.5,162.49) 177.26,162.49 172.23,167.53 171.82,167.53 169.18,170.17 169.18,172.25 168.42,173.02 147.8,173.02 144.93,170.15 142.51,170.15 138.4,166.03 137.85,166.03 v1(136.54,164.73)
  BOTTOM w0.203: PR455.2 v1(177.44,163.48) 177.44,162.81 177.5,162.75 v1(177.5,162.49)
PWR_LEVEL: length 31.8
  TOP w0.102: UG1.BE6 40.45,97.99 v2(40.16,97.7)
  TOP w0.14: v1(21.5,101.06) DG2.2 22.33,101.72 22.29,101.76 RG16.1 22.29,102.51 21.47,103.33 21.47,104.02 22.06,104.61 QG3.1 22.69,104.61 RG13.2
  IN2 w0.089: v2(40.16,97.7) 39.86,97.7 39.56,98 39.27,98 39.25,97.98 38.9,97.64 38.68,97.64 36.76,95.71 35.55,95.71 35.09,95.25 31.74,95.25 29.62,97.37 26.29,97.37 25.57,98.09 25.57,98.52 26.49,99.43 26.49,99.82 26.21,100.1 22.86,100.1 21.9,101.06 v1(21.5,101.06)
PWRLED#: length 248.3
  TOP w0.14: R420.2 65.98,24.4 v1(65.83,24.25)
  IN2 w0.089: v1(36.21,159.17) 36.54,159.5 41.81,159.5 41.9,159.58 45.09,159.58 45.83,158.84 54.04,158.84 54.77,159.56 57.13,159.56 57.58,159.1 58.62,159.1 58.63,159.1 60.67,159.1 60.99,158.78 63.57,158.78 64.1,158.25 64.39,158.25 64.97,157.67 68.32,157.67 70.03,159.37 71.41,159.37 72.15,160.11 73.84,160.11 74.57,159.37 77.2,159.37 77.91,158.66 79.85,158.66 80.58,157.93 84.28,157.93 86.92,155.29 86.92,149.6 87.06,149.46 87.06,145.5 88.33,144.23 94.47,144.23 96.63,142.07 96.63,135.71 103.24,129.09 103.24,100.99 102.23,99.97 102.23,98.11 100.48,96.36 100.48,89.52 102.96,87.03 103.23,87.03 104.58,85.67 104.58,84.14 105.15,83.57 v1(105.15,83.2)
  IN3 w0.089: v1(86.58,53.56) 86.99,53.97 86.99,54.06 87.77,54.84 87.77,55.74 88.74,56.71 88.74,58.39 89.33,58.98 89.33,58.98 90.14,59.78 90.75,59.78 91.9,60.93 91.9,66.52 95.65,70.27 95.65,72.59 96.71,73.65 98.02,73.65 101.29,76.91 101.29,78.12 104.67,81.5 104.67,82.3 105.15,82.78 v1(105.15,83.2)
  IN4 w0.086: v1(86.58,53.56) 86.58,53.84 86.16,54.27 84.73,54.27 84.44,53.98 84.18,53.98 83.06,52.85 80.19,52.85 79.76,52.43 78.68,52.43 77.45,53.65 76.58,53.65 75.19,52.26 74.43,52.26 74.02,51.85 70.25,51.85 70.01,51.61 68.3,51.61 68.04,51.34 65.06,51.34 64.5,51.89 61.26,51.89 60.91,51.55 60.91,49.93 61.72,49.13 61.72,48.84 60.92,48.04 60.92,45.28 64.23,41.97 64.23,38.94 63.12,37.83 63.12,35.66 64.94,33.84 64.94,31.56 63.26,29.89 63.26,29.07 62.82,28.63 62.2,28.01 62.2,25.76 62.53,25.43 62.53,24.64 63.48,23.69 63.92,23.69 64.15,23.92 64.71,23.92 64.86,24.07 65.65,24.07 v1(65.83,24.25)
  BOTTOM w0.14: v1(36.21,159.17) 36.5,158.89 D85.1 36.98,159.15 36.47,159.66 36.06,159.66 35.35,160.37 CN8.14
R_SPKL+: length 28.5
  IN2 w0.762: v1(7.67,26.23) 7.44,26.46 7.44,34.87 12.36,39.8 12.36,47.49 11.6,48.25 11.6,50.66 12.62,51.68 12.62,51.88
  vias: v1(12.95,53.18) v1(13.4,53.74)
R_SPKL-: length 29.9
  IN2 w0.762: v1(7.71,25.19) 7.91,25.19 8.7,25.98 8.7,26.82 8.38,27.14 8.38,34.52 13.28,39.42 13.28,47.87 12.54,48.61 12.54,50.29 13.73,51.48 13.73,51.6
  vias: v1(13.68,52.47) v1(14.12,52.98)
R_SPKR+: length 41
  IN4 w0.762: 17.31,54.32 14.7,51.71 12.87,51.71 11.55,50.38 11.55,48.23 12.31,47.46 12.31,40.32 9.9,37.91 9.9,37.36 7.56,35.02 7.56,27.44 8.5,26.5 8.5,23.89 6.95,22.34 6.95,21.23 7.5,20.69 v1(7.84,20.69)
  vias: v1(18.18,54.27) v1(18.84,54.27)
R_SPKR-: length 37.9
  IN4 w0.762: 17.55,52.8 17.22,52.8 15.22,50.79 13.25,50.79 12.46,50 12.46,48.6 13.23,47.84 13.23,40.01 10.81,37.6 10.81,37.01 8.45,34.65 8.45,27.81 9.39,26.87 9.39,23.18 v1(7.84,21.63)
  vias: v1(18.13,53.48) v1(18.79,53.48)
REGN6V: length 20.3
  TOP w0.14: v1(96.89,51.17) 96.89,50.87 96.48,50.45 PR276.1
  TOP w0.178: 92.75,55.18 93.39,55.18 PU23.24
  TOP w0.203: v1(89.67,55.57) 89.88,55.79 PC170.1 91.81,55.31 92.62,55.31 92.75,55.18
  IN1 w0.086: v1(96.89,51.17) 96.89,51.24 96.27,51.86 96.27,52.79 96.89,53.41 96.89,56.7 96.53,57.06 93.36,57.06 92.48,57.94 92.03,57.94 91.18,57.1 91.18,56.55 90.22,55.58 89.68,55.58 v1(89.67,55.57)
RESETB: length 9.3
  TOP w0.14: R631.2 282.36,7.97 282.94,7.39 C495.1 282.03,7.03 v1(280.27,8.79) 280.07,8.79 279.76,9.1 277.23,9.1 276.87,9.46 U30.16
REXT: length 1.5
  TOP w0.14: R561.1 277.67,15.07 U30.29
RF_EN: length 81.3
  TOP w0.14: R184.1 51.61,46.52 51.76,46.37 51.76,46 v1(51.7,45.94) ; R450.1 90.04,21.38 90.11,21.3 90.98,21.3 91.76,20.52 91.76,19.68 92.02,19.42 v1(92.22,19.42)
  IN2 w0.089: v1(51.7,45.94) 51.7,45.91 51.38,45.58 49.87,45.58 49.15,44.87 47.53,44.87 46.47,43.81 46.47,40.58 47.44,39.61 47.44,38.7 47.14,38.41 47.14,37.44 v1(47.06,37.35)
  IN3 w0.089: v1(92.22,19.42) 91.1,18.3 89.53,18.3 88.61,17.39 87.39,17.39 86.58,16.58 85.67,16.58 85.06,17.19 84.02,17.19 83.42,17.79 81.47,17.79 80.45,16.77 77.57,16.77 72.04,22.3 72.04,22.77 70.03,24.78 70.03,27.81 67.86,29.98 67.86,30.07 67.43,30.5 66.9,30.5 66.8,30.4 65.39,30.4 65.27,30.52 63.89,30.52 63.17,29.8 60.84,29.8 60.62,29.58 59.68,29.58 59.27,29.99 56.81,29.99 54.61,32.19 54.61,32.87 53.13,34.35 49.85,34.35 49.07,35.14 48.17,35.14 47.54,35.76 47.54,36.97 47.16,37.35 v1(47.06,37.35)
  BOTTOM w0.14: CN16.56 51.22,46.5 51.7,46.02 v1(51.7,45.94)
ROM_CS: length 34.8
  TOP w0.135: v2(38.69,94.91) 39.02,95.25 UG1.BJ4
  TOP w0.14: RG71.2 58.55,80.86 v1(58.33,81.08)
  IN1 w0.086: v1(58.33,81.08) 57.77,81.64 57.77,83.04 48.31,92.5 47.14,92.5 46.07,93.56 46.07,96.51 45.92,96.66 45.46,96.66 45.19,96.93 44.2,96.93 43.78,97.35 42.54,97.35 41.8,98.09 41.32,98.09 40.68,98.72 39.21,98.72 39.03,98.54 39.03,95.75 39.04,95.74 39.04,95.27 v2(38.69,94.91)
ROM_CS_R: length 3.8
  TOP w0.14: RG71.1 57.77,78.92 RG76.2 57.76,78.91 TPG10.1 56.52,79.05 UG2.1
ROM_SCLK: length 48.6
  TOP w0.135: UG1.BK3 38.35,94.55 38.03,94.23 37.98,94.23 v2(37.97,94.22)
  TOP w0.14: v1(46.48,81.22) 46.47,81.22 46.47,81.47 RG62.2
  IN2 w0.089: v2(37.97,94.22) 37.83,94.08 31.25,94.08 29.13,96.2 25.76,96.2 25.44,96.51 24.36,96.51 23.7,97.17 23.7,97.63 23.58,97.75 23.25,97.75 22.28,98.72 21.36,98.72 20.98,99.1 16.77,99.1 16.36,99.51 v1(16.36,99.94)
  IN4 w0.086: v2(37.97,94.22) 37.95,94.22 37.94,94.23 37.06,94.23 36.22,93.39 36.22,93.02 36.91,92.34 36.91,90.65 39.64,87.92 39.64,84.57 39.96,84.26 41.43,84.26 42.74,82.95 42.74,82.75 43.45,82.04 44.35,82.04 44.38,82.01 45.69,82.01 v1(46.48,81.22)
  BOTTOM w0.14: v1(16.36,99.94) 15.91,99.5 RG143.1 15.91,98.81 16.27,98.46 RG147.2
ROM_SCLK_R: length 2.9
  TOP w0.14: UG2.6 48.01,81.59 TPG9.1 47.77,81.83 RG62.1
ROM_SI: length 39.3
  TOP w0.135: 34.84,93.01 35.35,93.51 v1(35.78,93.51) 36.09,93.51 36.79,94.22 37.32,94.22 UG1.BK2
  TOP w0.14: RG47.1 54.29,84.67 53.54,84.67 53.1,84.24 53.1,83.93 52.09,82.92 51.02,82.92 50.56,83.37 48.79,83.37 48.18,82.76 45.73,82.76 45.23,82.26 45.23,80.9 v1(45.26,80.87) ; 34.84,93.01 34.59,92.75 RG31.2 31.89,92.1 30.68,92.1 30.38,92.4 RG35.1
  IN4 w0.086: v1(35.78,93.51) 35.78,91.3 38.92,88.16 38.92,87.52 39.3,87.14 39.3,84.41 39.84,83.87 40.18,83.87 42.35,81.7 44.21,81.7 45.03,80.87 v1(45.26,80.87)
ROM_SI_R: length 5.7
  TOP w0.14: UG2.5 50.5,82.86 50.76,82.6 52.22,82.6 TPG7.1 53.86,84.23 RG47.2
ROM_SO: length 45.5
  TOP w0.135: v2(38.74,94.2) 38.74,94.22 38.76,94.23 38.76,94.26 UG1.BK4
  TOP w0.14: RG49.2 RG50.1 TPG8.1 57.93,81.83 56.42,80.32 UG2.2 54.11,80.32 52.15,82.28 50.55,82.28 50.53,82.26 48.22,82.26 48.04,82.44 45.86,82.44 45.66,82.24 45.66,81.22 45.92,80.97 v1(45.92,80.81)
  IN4 w0.086: v2(38.74,94.2) 38.73,94.22 38.7,94.22 38.06,94.86 36.32,94.86 35.38,93.92 35.38,91.32 37.27,89.44 37.27,86.42 36.23,85.38 36.23,84.84 36.79,84.28 37.85,84.28 38.53,83.61 40.07,83.61 42.24,81.44 44.1,81.44 44.36,81.18 44.36,81.17 45.06,80.47 45.77,80.47 45.91,80.61 45.91,80.81 v1(45.92,80.81)
RS232_DET#: length 10.8
  TOP w0.102: v1(228.76,30.83) 228.9,30.69 228.9,30.04 228.46,29.61 227.46,29.61 226.76,28.91 U14.AR48
  BOTTOM w0.14: R881.1 233.11,34.1 233.11,33.49 232.94,33.32 231.33,33.32 230.68,32.67 230.68,32.18 230.08,31.58 229.25,31.58 228.76,31.09 v1(228.76,30.83)
RSMRST#: length 228.5
  TOP w0.14: v1(77.17,32.87) 77.17,33.92 77.43,34.18 U18.112
  IN2 w0.089: v1(233.19,45) 233.75,45 234.07,44.68 235.34,44.68 236.63,43.39 236.63,41.6 237.18,41.05 237.18,39.64 235.82,38.28 235.82,36.37 234.35,34.9 234.35,33.85 233.62,33.13 233.62,28.08 233.98,27.73 234.79,27.73 235.12,27.4 235.12,25.31 v1(235.38,25.06)
  IN3 w0.089: v1(201.8,52.37) 201.83,52.33 208.1,52.33 209.66,50.77 213.96,50.77 215.77,52.57 217.41,52.57 220.64,49.34 221.96,49.34 223.77,47.53 228.62,47.53 230.76,45.39 232.8,45.39 v1(233.19,45)
  IN4 w0.086: v1(86.1,45.38) 86.1,45.42 86.43,45.76 87.45,45.76 88.03,46.34 89.18,46.34 91.55,48.7 95.1,48.7 95.78,48.02 96.02,48.02 97.43,46.62 98.47,46.62 99.3,47.44 99.3,49.66 101.11,51.47 101.11,63.52 103.25,65.67 110.65,65.67 110.96,65.97 115.26,65.97 117.55,68.26 162.43,68.26 172.04,58.65 173.25,58.65 175.41,56.49 180.36,56.49 180.9,55.96 180.9,53.62 181.31,53.21 181.31,52.68 181.64,52.35 182.91,52.35 184.19,51.08 186.71,51.08 187.18,50.61 188.76,50.61 188.93,50.78 196.3,50.78 197.1,51.58 199.69,51.58 201.06,52.95 201.41,52.95 201.77,52.59 201.77,52.39 v1(201.8,52.37)
  BOTTOM w0.14: v1(86.1,45.38) 85.52,45.38 85.32,45.18 82.98,45.18 81.87,44.07 81.87,41.63 81.01,40.77 81.01,38.86 80.61,38.46 80.61,37.52 80.05,36.97 80.05,35.43 77.49,32.87 v1(77.17,32.87) ; v1(235.38,25.06) 235.99,24.44 R981.1
RST_BUF_PWR: length 8.4
  TOP w0.14: U32.5 250.88,10.85 250.62,11.12 250.62,13 250.88,13.26 U29.5 252.2,13.26 252.44,13.02 252.44,12.89 v1(252.57,12.77)
  BOTTOM w0.14: R1141.2 C931.1 251.74,12.81 251.64,12.91 R1132.2 251.94,13.4 v1(252.57,12.77)
RTC_RST#: length 123.6
  TOP w0.14: v1(226.42,24.74) 226.26,24.59 U14.BE47 ; Q49.3 203.78,13.88 203.88,13.88 204.45,13.31 204.45,13.02 v1(204.45,13.02) 203.88,12.45 R619.2 C489.1 ; v1(228.14,15.7) 228.14,15.46 228.11,15.44 CN5.9
  IN1 w0.086: v1(228.14,15.7) 228.91,15.7 229.3,15.31 230.71,15.31 230.98,15.59 230.98,16.07 232.15,17.24 233.68,17.24 234.66,18.22 234.66,19.5 233.35,20.81 229.9,20.81 228.44,22.27 228.44,23.09 226.79,24.74 v1(226.42,24.74)
  IN2 w0.089: v1(228.14,15.7) 228.1,15.74 228.03,15.74 226.49,17.28 217.77,17.28 217.08,16.6 217.08,14.98 216.27,14.18 216.27,13.24 215.81,12.77 214.49,12.77 213.59,13.68 211.53,13.68 210.99,13.14 210.48,13.14 209.98,12.64 207.89,12.64 207.59,12.34 204.86,12.34 204.45,12.74 v1(204.45,13.02)
  IN4 w0.086: v1(226.42,24.74) 225.9,24.22 225.09,24.22 224.78,23.92 220.57,23.92 219.2,25.29 217.34,25.29 216.12,24.07 209.9,24.07 207.17,21.34 204.24,21.34 203.32,22.25 203.32,24.94 204.64,26.25 206.05,26.25 206.59,26.8 206.91,26.8 207.23,27.12 207.67,27.12 207.93,27.38 207.93,28.88 207.36,29.46 206.39,29.46 205.81,30.04 204.84,30.04 202.71,32.17 200.25,32.17 198.62,33.8 197.43,33.8 194.4,36.82 188.92,36.82 188.44,37.3 183.8,37.3 182.47,38.64 v1(182.47,38.66)
  BOTTOM w0.14: v1(182.47,38.66) 182.47,38.15 v1(182.77,37.85) J1.1
RTC_X1: length 7.1
  TOP w0.14: U14.BA49 227.39,26 229.75,26 230.17,26.42 230.32,26.42 230.45,26.3 230.45,25.98 R411.1 231.03,25.77 231.26,26.01 C365.2 232.34,26.01 Y4.1
RTC_X2: length 7.1
  TOP w0.14: Y4.2 232.5,25.01 C391.2 231.18,25.01 231.16,24.99 R411.2 229.96,24.99 229.19,25.76 226.93,25.76 U14.BA48
RTD3_CIO_PWR_EN: length 50.6
  IN2 w0.089: v1(238.65,39.06) 239.98,39.06 241.44,40.51 242.77,40.51 243.63,41.38 243.63,41.94 243.94,42.25 244.34,42.25 246.84,44.74 246.84,47.68 247.76,48.6 247.76,52.11 250.88,55.23 251.33,55.23 252.73,56.63 252.73,57.36 254.37,59 254.37,60.09 254.46,60.18 258.95,60.18 260.33,58.8 265.8,58.8 v1(266.2,59.2)
  BOTTOM w0.14: v1(266.2,59.2) 266.2,59.19 266.69,58.71 267.41,58.71 267.59,58.53 R739.1 ; R863.2 234.28,37.48 236.09,37.48 v1(237.06,38.46) 237.33,38.73 238.32,38.73 v1(238.65,39.06)
S5_ON: length 334.7
  TOP w0.14: PR406.1 98.83,23.73 v1(99.19,23.73) ; PR417.2 173.91,20.24 174.11,20.44 v1(174.24,20.44) ; R380.2 254.26,28.3 v1(254.25,28.29) ; v1(80.87,22.22) 80.87,23.79 79.95,24.7 79.95,26.53 79.24,27.25 79.24,28.92 79.6,29.28 79.6,30.65 81.29,32.35 81.54,32.35 82.23,33.05 U18.100 82.23,36.26 82.5,36.53 R273.1 ; v1(163.19,25.44) 162.72,25.91 PR385.1
  IN2 w0.089: v1(163.19,25.44) 162.61,24.86 161.56,24.86 160.96,25.46 159.43,25.46 158.86,24.88 158.03,24.88 157.49,25.42 154.82,25.42 154.31,24.91 149.33,24.91 148.34,23.93 134.06,23.93 131.03,20.89 125.78,20.89 123.68,18.79 116.11,18.79 114.11,20.8 114.11,23.06 113.49,23.68 111.82,23.68 111.38,24.12 99.81,24.12 99.45,23.77 99.23,23.77 v1(99.19,23.73) 98.1,23.73 97.96,23.87 96.26,23.87 95.27,22.88 95.27,22.27 94.95,21.95 92.96,21.95 92.29,21.28 89.98,21.28 88.88,20.18 87.47,20.18 86.63,19.35 82.64,19.35 80.77,21.23 80.77,22.11 v1(80.87,22.22)
  IN3 w0.089: v1(239.37,21.95) 239.37,22.27 240.76,23.66 242.79,23.66 243.91,24.78 243.91,27.93 245.2,29.23 253.31,29.23 v1(254.25,28.29)
  IN4 w0.086: v1(99.19,23.73) 99.31,23.73 100.77,25.18 115.73,25.18 116.22,24.69 119.01,24.69 119.43,25.1 122.93,25.1 125.44,22.59 130.32,22.59 132.68,24.95 138.3,24.95 139.69,23.56 148.4,23.56 150.16,25.33 152.24,25.33 153.29,26.37 163.46,26.37 164.93,27.85 173.28,27.85 173.51,28.08 179.02,28.08 179.77,27.32 179.77,24.48 177.77,22.47 176.62,22.47 175.08,20.92 174.72,20.92 v1(174.24,20.44) 174.84,19.84 176.64,19.84 177.58,20.78 177.58,21.47 180.03,23.92 184.98,23.92 187.27,21.63 187.27,19.88 188.46,18.68 191.13,18.68 191.82,17.99 193.62,17.99 194.26,17.34 194.26,16.31 198.6,11.98 207.56,11.98 207.82,12.23 209.49,12.23 210.62,13.36 211.43,13.36 211.55,13.48 212.36,13.48 214.34,11.5 217.85,11.5 219.38,9.97 223.5,9.97 225.74,12.21 228.69,12.21 229.61,13.13 234.47,13.13 236.75,15.41 236.75,15.92 238.02,17.19 238.02,19.8 237.9,19.92 237.9,20.88 238.97,21.95 v1(239.37,21.95)
  BOTTOM w0.14: v1(174.24,20.44) 174.82,20.44 175.69,21.3 175.69,24.38 176.66,25.35 176.66,26.55 176.32,26.89 176.32,27.37 177.21,28.26 177.21,33.21 178.49,34.5 PQ58.2 ; v1(80.87,22.22) 81.17,22.52 PR569.1 ; PR570.1 239.03,22.28 v1(239.37,21.95)
S5_ON_R: length 4.5
  TOP w0.14: v1(240.1,24.44) v1(241.12,24.44)
  BOTTOM w0.14: PU32.5 240.21,24.55 v1(240.1,24.44) 240.1,24.43 239.92,24.25 PC440.1 239.45,23.8 PR570.2 ; v1(241.12,24.44) 241.01,24.55 PU32.3
S_GPIO: length 3
  BOTTOM w0.14: R1105.2 R1104.1 213.33,17.8 213.45,17.92 213.45,18.94 R1056.1
S_SPKR+:
  vias: v1(17.76,16.54)
S_SPKR-:
  vias: v1(17.49,15.26) v1(17.49,14.57)
SATA_LED#: length 353.8
  TOP w0.102: U14.AK48 226.65,31.92 228.97,31.92 v1(229.66,32.6) 229.94,32.6 230.37,32.17 D49.2 230.66,32.3 230.96,32.59
  TOP w0.14: R343.1 232.7,32.71 231.07,32.71 230.96,32.59
  IN1 w0.086: v1(104.84,71.82) 104.84,72.38 103.15,74.08 103.15,74.67 103.71,75.23 103.71,75.9 105.77,77.97 105.77,83.86 v1(105.14,84.48)
  IN2 w0.089: v1(229.66,32.6) 228.9,33.37 226.93,33.37 226.19,34.1 226.19,38.9 225.07,40.03 219.26,40.03 218.46,40.83 217.29,40.83 216.32,41.79 216.32,43.45 213.73,46.04 v1(213.73,46.42) ; v1(105.14,84.48) 104.77,84.86 104.77,85.93 103.48,87.22 103.04,87.22 100.67,89.6 100.67,96.28 102.42,98.03 102.42,99.89 103.43,100.91 103.43,129.17 96.82,135.78 96.82,142.15 94.55,144.42 88.41,144.42 87.25,145.58 87.25,149.54 87.11,149.68 87.11,155.37 84.36,158.12 80.66,158.12 79.93,158.85 77.99,158.85 77.28,159.56 74.65,159.56 73.92,160.3 72.07,160.3 71.33,159.56 69.95,159.56 68.24,157.86 65.05,157.86 64.47,158.44 64.18,158.44 63.65,158.97 61.06,158.97 60.74,159.3 57.66,159.3 57.21,159.75 54.69,159.75 53.96,159.03 45.91,159.03 45.17,159.77 41.82,159.77 41.74,159.69 39.68,159.69 v1(39.17,160.2)
  IN3 w0.089: v1(198.81,25.7) 200.52,25.7 200.75,25.47 203.43,25.47 203.92,25.95 203.92,26.29 204.97,27.34 206.03,27.34 206.44,27.75 207.1,27.75 207.34,27.99 209.11,27.99 209.55,28.43 210.43,28.43 210.76,28.1 211.64,28.1 212.11,27.63 213.02,27.63 213.38,27.98 213.38,28.47 213.85,28.95 214.4,28.95 214.86,29.41 214.86,29.91 215.1,30.14 220.11,30.14 220.42,30.45 225.98,30.45 227.01,31.49 228.54,31.49 v1(229.66,32.6)
  IN4 w0.086: v1(104.84,71.82) 105.17,71.49 112.72,71.49 115.43,74.19 164.55,74.19 175.12,63.63 175.12,62.66 176.28,61.5 176.38,61.5 177.79,60.1 178.3,60.1 179.36,59.04 179.93,59.04 180.24,58.74 180.24,58.06 182.97,55.33 184.87,55.33 186.1,54.11 186.1,52.27 186.72,51.64 188.46,51.64 189.03,51.07 195.49,51.07 v1(195.9,51.48)
  BOTTOM w0.14: CN8.15 35.85,160.26 36.18,159.93 36.58,159.93 37.09,159.43 37.68,159.43 D84.1 38.14,158.97 EC7.2 39.06,159.42 39.17,159.54 v1(39.17,160.2) ; v1(195.9,51.48) 195.9,51.12 196.27,50.75 CN15.10 197.94,50.75 198.24,50.45 198.24,49.21 198.88,48.58 202.88,48.58 204.5,46.96 205.77,46.96 207.83,44.9 211.29,44.9 212.81,46.42 v1(213.73,46.42) ; v1(198.81,25.7) CN18.10
SATA_RXN0: length 203.1
  TOP w0.14: v1(224.81,44.48) 224.81,44.63 224.95,44.77 225.31,44.77 U14.C45
  IN1 w0.086: v1(51.06,21.3) 51.38,20.98 51.38,20.79 51.66,20.5 52.72,20.5 54.1,21.88 54.1,28.59 54.41,28.9 55.71,28.9 56.03,28.58 58.71,28.58 59.6,29.47 60.95,29.47 61.22,29.74 63.06,29.74 63.73,30.41 67.24,30.41 67.95,29.7 73.98,29.7 74.45,30.17 76.02,30.17 76.8,30.95 83.62,30.95 85.4,29.17 86.81,29.17 86.91,29.27 90.92,29.27 91.23,29.58 95.35,29.58 95.82,29.11 96.9,29.11 97.55,28.47 98.01,28.47 98.3,28.18 100.54,28.18 101.71,27.02 111.03,27.02 113.32,29.3 147.75,29.3 148.98,28.07 163.75,28.07 164.41,28.73 167.56,28.73 167.86,28.44 172.77,28.44 173.52,29.19 176.07,29.19 181.92,35.04 188.68,35.04 189.21,35.58 198.16,35.58 200.45,37.86 204.82,37.86 205.33,38.37 206.21,38.37 206.38,38.21 210.09,38.21 211.14,39.25 212.58,39.25 212.85,39.51 214.69,39.51 215.58,38.62 218.54,38.62 218.73,38.82 221.85,38.82 222.33,39.29 223.07,39.29 223.74,39.96 225.24,39.96 225.76,40.48 225.76,41.38 225.38,41.75 224.82,41.75 224.3,42.27 224.3,43.04 223.95,43.39 223.95,44.56 224.36,44.98 224.85,44.98 224.95,44.87 224.95,44.63 v1(224.81,44.48)
  BOTTOM w0.14: C903.2 50.61,20.81 51.19,20.81 51.32,20.94 51.32,21.05 v1(51.06,21.3)
SATA_RXN0_CN: length 14.2
  BOTTOM w0.14: CN20.16 28.15,18.17 28.27,18.28 28.27,18.58 28.56,18.88 37.22,18.88 38.5,20.15 40.44,20.15 C908.1
SATA_RXN_IN: length 2.5
  BOTTOM w0.14: C903.1 49.39,20.79 48.74,20.79 48.39,21.14 48.06,21.14 47.94,21.26 U43.4
SATA_RXN_OUT: length 3.1
  BOTTOM w0.14: U43.12 43.08,21.26 42.92,21.1 42.64,21.1 42.35,20.81 42.35,20.26 42.12,20.03 41.76,20.03 C908.2
SATA_RXP0: length 203
  TOP w0.14: U14.C46 v1(225.32,45.27)
  IN1 w0.086: v1(51.76,21.33) 51.55,21.11 51.55,20.85 51.73,20.67 52.65,20.67 53.93,21.95 53.93,28.66 54.34,29.07 55.78,29.07 56.1,28.75 58.64,28.75 59.53,29.64 60.88,29.64 61.15,29.9 62.99,29.9 63.66,30.57 67.3,30.57 68.01,29.86 73.91,29.86 74.38,30.33 75.95,30.33 76.73,31.12 83.69,31.12 85.47,29.34 86.75,29.34 86.85,29.44 90.85,29.44 91.16,29.75 95.41,29.75 95.89,29.27 96.97,29.27 97.62,28.63 98.08,28.63 98.37,28.35 100.61,28.35 101.78,27.18 110.97,27.18 113.25,29.47 147.81,29.47 149.05,28.24 163.68,28.24 164.34,28.9 167.63,28.9 167.93,28.6 172.7,28.6 173.45,29.35 176,29.35 181.85,35.21 188.61,35.21 189.14,35.74 198.09,35.74 200.38,38.03 204.76,38.03 205.26,38.54 206.28,38.54 206.44,38.37 210.03,38.37 211.07,39.41 212.51,39.41 212.78,39.68 214.76,39.68 215.65,38.79 218.47,38.79 218.66,38.98 221.79,38.98 222.26,39.45 223,39.45 223.67,40.13 225.17,40.13 225.59,40.55 225.59,41.31 225.31,41.58 224.75,41.58 224.14,42.2 224.14,42.97 223.78,43.33 223.78,44.63 224.29,45.14 225.19,45.14 v1(225.32,45.27)
  BOTTOM w0.14: v1(51.76,21.33) 51.58,21.15 51.58,20.83 51.3,20.55 50.88,20.55 C910.2
