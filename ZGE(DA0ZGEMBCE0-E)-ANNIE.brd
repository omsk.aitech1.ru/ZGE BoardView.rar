# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Nets (continued)
M_B_CB4: JDIM1.88 JDIM3.91 U3.AY10
M_B_CB5: JDIM1.101 JDIM3.104 U3.AW10
M_B_CB6: JDIM1.91 JDIM3.88 U3.AY7
M_B_CB7: JDIM1.104 JDIM3.101 U3.AW7
M_B_CKE0: JDIM1.109 U3.AT8
M_B_CKE1: JDIM1.110 U3.AT10
M_B_CKE2: JDIM3.109 U3.AT7
M_B_CKE3: JDIM3.110 U3.AT11
M_B_CS#0: JDIM1.149 U3.AF11
M_B_CS#1: JDIM1.157 U3.AE7
M_B_CS#2: JDIM3.149 U3.AF10
M_B_CS#3: JDIM3.157 U3.AE10
M_B_DIM0_CLKN0: JDIM1.139 U3.AN9
M_B_DIM0_CLKN1: JDIM1.140 U3.AM8
M_B_DIM0_CLKP0: JDIM1.137 U3.AM9
M_B_DIM0_CLKP1: JDIM1.138 U3.AM7
M_B_DIM1_CLKN0: JDIM3.139 U3.AM10
M_B_DIM1_CLKN1: JDIM3.140 U3.AJ11
M_B_DIM1_CLKP0: JDIM3.137 U3.AM11
M_B_DIM1_CLKP1: JDIM3.138 U3.AJ10
M_B_DQ0: JDIM1.4 JDIM3.7 U3.BT11
M_B_DQ1: JDIM1.8 JDIM3.3 U3.BR11
M_B_DQ2: JDIM1.20 JDIM3.17 U3.BT9
M_B_DQ3: JDIM1.16 JDIM3.21 U3.BR8
M_B_DQ4: JDIM1.7 JDIM3.4 U3.BP11
M_B_DQ5: JDIM1.3 JDIM3.8 U3.BN11
M_B_DQ6: JDIM1.17 JDIM3.20 U3.BP8
M_B_DQ7: JDIM1.21 JDIM3.16 U3.BN8
M_B_DQ8: JDIM1.28 JDIM3.25 U3.BL12
M_B_DQ9: JDIM1.24 JDIM3.29 U3.BL11
M_B_DQ10: JDIM1.25 JDIM3.28 U3.BL8
M_B_DQ11: JDIM1.37 JDIM3.42 U3.BJ8
M_B_DQ12: JDIM1.42 JDIM3.37 U3.BJ11
M_B_DQ13: JDIM1.38 JDIM3.41 U3.BJ10
M_B_DQ14: JDIM1.29 JDIM3.24 U3.BL7
M_B_DQ15: JDIM1.41 JDIM3.38 U3.BJ7
M_B_DQ16: JDIM1.50 JDIM3.45 U3.BG11
M_B_DQ17: JDIM1.46 JDIM3.49 U3.BG10
M_B_DQ18: JDIM1.45 JDIM3.50 U3.BG8
M_B_DQ19: JDIM1.58 JDIM3.63 U3.BF8
M_B_DQ20: JDIM1.63 JDIM3.58 U3.BF11
M_B_DQ21: JDIM1.59 JDIM3.62 U3.BF10
M_B_DQ22: JDIM1.49 JDIM3.46 U3.BG7
M_B_DQ23: JDIM1.62 JDIM3.59 U3.BF7
M_B_DQ24: JDIM1.83 JDIM3.80 U3.BB11
M_B_DQ25: JDIM1.70 JDIM3.67 U3.BC11
M_B_DQ26: JDIM1.80 JDIM3.83 U3.BB8
M_B_DQ27: JDIM1.67 JDIM3.70 U3.BC8
M_B_DQ28: JDIM1.66 JDIM3.71 U3.BC10
M_B_DQ29: JDIM1.79 JDIM3.84 U3.BB10
M_B_DQ30: JDIM1.71 JDIM3.66 U3.BC7
M_B_DQ31: JDIM1.84 JDIM3.79 U3.BB7
M_B_DQ32: JDIM1.186 JDIM3.183 U3.AA11
M_B_DQ33: JDIM1.183 JDIM3.186 U3.AA10
M_B_DQ34: JDIM1.170 JDIM3.173 U3.AC11
M_B_DQ35: JDIM1.169 JDIM3.174 U3.AC10
M_B_DQ36: JDIM1.182 JDIM3.187 U3.AA7
M_B_DQ37: JDIM1.187 JDIM3.182 U3.AA8
M_B_DQ38: JDIM1.173 JDIM3.170 U3.AC8
M_B_DQ39: JDIM1.174 JDIM3.169 U3.AC7
M_B_DQ40: JDIM1.190 JDIM3.195 U3.W8
M_B_DQ41: JDIM1.194 JDIM3.191 U3.W7
M_B_DQ42: JDIM1.204 JDIM3.207 U3.V10
M_B_DQ43: JDIM1.208 JDIM3.203 U3.V11
M_B_DQ44: JDIM1.195 JDIM3.190 U3.W11
M_B_DQ45: JDIM1.191 JDIM3.194 U3.W10
M_B_DQ46: JDIM1.207 JDIM3.204 U3.V7
M_B_DQ47: JDIM1.203 JDIM3.208 U3.V8
M_B_DQ48: JDIM1.215 JDIM3.212 U3.R11
M_B_DQ49: JDIM1.224 JDIM3.229 U3.P11
M_B_DQ50: JDIM1.228 JDIM3.225 U3.P7
M_B_DQ51: JDIM1.212 JDIM3.215 U3.R8
M_B_DQ52: JDIM1.211 JDIM3.216 U3.R10
M_B_DQ53: JDIM1.225 JDIM3.228 U3.P10
M_B_DQ54: JDIM1.216 JDIM3.211 U3.R7
M_B_DQ55: JDIM1.229 JDIM3.224 U3.P8
M_B_DQ56: JDIM1.250 JDIM3.245 U3.L11
M_B_DQ57: JDIM1.237 JDIM3.232 U3.M11
M_B_DQ58: JDIM1.249 JDIM3.246 U3.L7
M_B_DQ59: JDIM1.236 JDIM3.233 U3.M8
M_B_DQ60: JDIM1.246 JDIM3.249 U3.L10
M_B_DQ61: JDIM1.233 JDIM3.236 U3.M10
M_B_DQ62: JDIM1.232 JDIM3.237 U3.M7
M_B_DQ63: JDIM1.245 JDIM3.250 U3.L8
M_B_DQSN0: JDIM1.11 JDIM3.11 U3.BN9
M_B_DQSN1: JDIM1.32 JDIM3.32 U3.BL9
M_B_DQSN2: JDIM1.53 JDIM3.53 U3.BG9
M_B_DQSN3: JDIM1.74 JDIM3.74 U3.BC9
M_B_DQSN4: JDIM1.177 JDIM3.177 U3.AC9
M_B_DQSN5: JDIM1.198 JDIM3.198 U3.W9
M_B_DQSN6: JDIM1.219 JDIM3.219 U3.R9
M_B_DQSN7: JDIM1.240 JDIM3.240 U3.M9
M_B_DQSN8: JDIM1.95 JDIM3.95 U3.AY9
M_B_DQSP0: JDIM1.13 JDIM3.13 U3.BP9
M_B_DQSP1: JDIM1.34 JDIM3.34 U3.BJ9
M_B_DQSP2: JDIM1.55 JDIM3.55 U3.BF9
M_B_DQSP3: JDIM1.76 JDIM3.76 U3.BB9
M_B_DQSP4: JDIM1.179 JDIM3.179 U3.AA9
M_B_DQSP5: JDIM1.200 JDIM3.200 U3.V9
M_B_DQSP6: JDIM1.221 JDIM3.221 U3.P9
M_B_DQSP7: JDIM1.242 JDIM3.242 U3.L9
M_B_DQSP8: JDIM1.97 JDIM3.97 U3.AW9
M_B_ODT0: JDIM1.155 U3.AF7
M_B_ODT1: JDIM1.161 U3.AE8
M_B_ODT2: JDIM3.155 U3.AE9
M_B_ODT3: JDIM3.161 U3.AE11
MACRO_BTN_1: CN19.43 D92.1 U4.11
MACRO_BTN_2: CN19.42 D91.1 U4.12
MACRO_BTN_3: CN19.41 D90.1 U4.13
MACRO_BTN_P: CN19.44 D93.1 U4.10
MACRO_BTN_T: CN19.40 D89.1 U4.14
MAIND: PC319.1 PQ10.2 PQ41.3 PQ46.2 PR285.1 PR466.2
MAINON: PQ49.2 PR371.2 PR374.1 PR486.1 PR494.1 PR512.2 PR567.2 R17.1 R139.1 R464.1 U18.30
MAINON_ON_G: PQ8.2 PQ9.2 PQ11.2 PQ41.2 PQ42.2 PQ49.3 PQ51.2 PR85.1 PR467.2
MB_THRMTRIP#: D88.1(CATHODE) R666.2 U38.4
MBCLK: PC410.1 PD4.1 PR498.1 PR502.1 R238.1 R274.1 U18.110
MBCLK1_GPU: PR304.1 PR305.2 QG10.3
MBCLK_CONN: PJ22.5 PR502.2
MBDATA: PC409.1 PD5.1 PR497.1 PR501.1 R237.1 R275.1 U18.111
MBDATA1_GPU: PR293.1 PR297.2 QG10.6
MBDATA_CONN: PJ22.4 PR501.2
MCR_LED_CTL_B: Q43.2 R560.2 U4.21
MCR_LED_CTL_G: Q51.2 R590.2 U4.20
MCR_LED_CTL_R: Q51.5 R589.2 U4.19
MCR_LED_EN_B: CN19.32 D67.1 Q43.3
MCR_LED_EN_G: CN19.33 D66.1 Q51.6
MCR_LED_EN_R: CN19.34 D65.1 Q51.3
MCR_LED_PWR_1: CN19.38 D61.1 Q45.3
MCR_LED_PWR_2: CN19.37 D62.1 Q50.6
MCR_LED_PWR_3: CN19.36 D63.1 Q50.3
MCR_LED_PWR_CTL_1: Q45.5 R519.2 U4.16
MCR_LED_PWR_CTL_2: Q50.2 R588.2 U4.17
MCR_LED_PWR_CTL_3: Q50.5 R582.2 U4.18
MCR_LED_PWR_CTL_P: Q45.2 R596.2 U4.15
MCR_LED_PWR_CTL_T: Q36.2 R462.2 U4.22
MCR_LED_PWR_P: CN19.39 D60.1 Q45.6
MCR_LED_PWR_T: CN19.35 D64.1 Q36.3 R472.1
MCR_LED_T_CTL_B: Q44.2 R506.2 U4.25
MCR_LED_T_CTL_G: Q52.2 R592.2 U4.24
MCR_LED_T_CTL_R: Q52.5 R591.2 U4.23
MCR_LED_T_EN_B: CN19.29 D70.1 Q44.3
MCR_LED_T_EN_G: CN19.30 D69.1 Q52.6
MCR_LED_T_EN_R: CN19.31 D68.1 Q52.3
MCU_INT#: R118.2 U4.3 U18.113
ME_WR#: R493.2 R1053.1 R1088.2 U18.109
MEM_VDD_CTRL: PR12.2 RG163.2 UG1.BH4
MEM_VREF_CTL: QG1.2 QG2.2 QG17.2 QG19.2 RG20.2 UG1.BD3
MEM_VREF_CTL_QA: QG2.3 RG3.1
MEM_VREF_CTL_QB: QG1.3 RG4.1
MEM_VREF_CTL_QC: QG17.3 RG96.1
MEM_VREF_CTL_QD: QG19.3 RG126.1
MIC1-L: CN17.5 U17.31
MIC1-R: CN17.6 U17.30
MIC1-VREFO-L: CN17.7 U17.18
MIC1-VREFO-R: CN17.8 U17.19
MIC-JD: CN17.9 R373.2
MIC_VCC: C51.2 C52.2 CN10.35 R40.2
MKB_INT#: Q39.1(S) R510.1 U18.76
MKB_INT#_R: CN19.15 D57.1 Q39.3 R509.1
MKB_PWR_EN: Q77.2 R367.1 R1158.2
MODE: R559.2 U30.30
MODEM_CLKREQ: CN16.14 Q35.6 R468.1
MODEM_CLKREQ_C: Q35.5 R447.1 U14.BA17
MPHY_EXT_PWR_GATE: R1097.1 TP111.1 U14.AP29
NB_FGC6: RG151.2 UG1.BE5 UG11.2
NBSWON#: C254.2 C514.1 CN5.11 D87.1 R240.1 R261.1 R645.1 SW1.1 SW1.2 U18.107
NGFF1_DET1: Q72.3 R860.1 R875.1 R877.2 U14.AJ43
NGFF1_PEDET1: CN15.69 Q72.2 R848.2 R859.2 R860.2
NGFF1_RST#: CN15.50 R201.1
NGFF2_DET2: R256.1 R334.2 U14.AM46
NGFF2_RST#: CN18.50 R609.1
NV_USB2_D_N: U14.H3 U16.11
NV_USB2_D_P: U14.H2 U16.12
NVVDD: CG411.2 CG412.2 CG413.2 CG419.2 CG420.2 CG424.2 CG435.2 CG436.2 CG437.2 CG438.2 CG439.2 CG440.2 CG441.2 CG442.2 CG443.2 CG444.2 CG445.2 CG446.2 CG447.2 CG448.2 CG449.2 CG450.2 CG451.2 CG452.2 CG453.2 CG454.2 CG456.2 CG457.2 CG464.2 CG465.2 CG466.2 CG467.2 CG468.2 CG469.2 CG470.2 CG471.2 CG472.2 CG473.2 CG474.2 CG475.2 CG476.2 CG477.2 CG479.2 CG482.1 CG486.1 CG489.2 CG491.2 CG492.2 CG493.2 CG494.2 CG495.2 CG496.2 CG497.1 CG498.2 CG499.2 CG500.2 CG501.2 CG502.2 CG518.2 CG524.2 CG525.2 CG526.2 CG527.1 CG528.2 CG529.2 CG530.2 CG531.2 CG532.2 CG533.2 CG536.2 CG545.2 CG546.2 CG550.2 CG551.2 CG552.2 CG554.1 CG556.2 CG557.2 CG558.2 CG559.2 CG560.2 CG561.1 CG562.1 CG569.2 CG570.2 CG571.2 CG572.2 CG573.2 CG576.2 CG578.1 CG580.2 CG590.2 CG591.2 CG592.2 CG594.2 CG595.2 CG596.2 CG597.2 CG598.2 CG599.2 CG600.2 CG601.2 CG602.2 CG603.2 CG604.2 CG605.2 CG606.2 CG607.2 CG608.2 CG609.2 CG610.2 CG613.2 CG614.2 CG615.2 CG616.2 CG625.2 CG626.2 CG627.2 CG628.2 CG629.2 CG630.1 CG631.2 CG632.2 CG633.1 CG634.2 CG635.2 CG636.1 CG637.2 CG638.2 CG639.1 CG650.2 CG651.2 CG652.2 CG653.2 CG654.2 CG655.2 CG656.2 CG657.2 CG658.2 CG659.2 CG660.2 CG661.2 CG662.2 CG663.2 CG664.2 CG665.2 CG666.2 CG667.2 CG668.2 CG669.2 CG670.2 CG671.2 CG672.2 CG673.2 CG674.2 CG675.2 CG689.1 CG692.1 CG693.2 CG694.2 CG695.1 CG696.2 CG697.2 CG698.2 CG699.2 CG700.2 CG705.1 CG706.1 CG708.1 CG709.1 CG710.2 CG714.2 CG715.2 CG716.2 CG717.2 CG718.2 CG719.2 CG720.2 CG721.2 CG722.1 CG725.1 CG728.2 CG732.2 CG733.2 CG736.1 CG741.2 CG742.2 CG743.2 CG746.2 CG749.1 CG750.1 CG751.1 CG752.1 CG754.2 CG755.2 CG758.1 CG759.2 CG760.2 CG761.2 CG762.2 CG763.2 CG764.2 CG765.2 CG766.2 CG767.2 CG768.2 CG769.2 CG770.2 CG772.2 CG776.1 CG808.1 CG812.1 CG842.1 CG843.1 CG845.2 CG852.1 CG853.2 CG854.1 CG857.1 CG859.1 CG860.2 CG861.1 CG864.1 CG901.1 CG902.1 CG903.1 PC125.1 PC126.1 PC127.1 PC128.1 PC341.1 PC342.1 PC343.1 PC344.1 PC345.1 PC346.1 PC347.1 PC348.1 PC349.1 PC350.1 PC351.1 PC352.1 PL11.2 PL12.2 PL13.2 PL14.2 PL15.2 PL16.2 PL17.2 PL18.2 PR153.2 PR154.2 PR155.2 PR156.2 PR157.2 PR158.2 PR159.2 PR160.2 PR506.2 PR521.1 UG1.AA13 UG1.AA14 UG1.AA15 UG1.AA16 UG1.AA17 UG1.AA18 UG1.AA19 UG1.AA20 UG1.AA21 UG1.AA22 UG1.AA23 UG1.AA24 UG1.AA25 UG1.AA26 UG1.AA27 UG1.AA28 UG1.AA29 UG1.AA30 UG1.AA31 UG1.AA32 UG1.AA33 UG1.AA34 UG1.AA35 UG1.AA36 UG1.AA37 UG1.AA38 UG1.AA39 UG1.AA40 UG1.AB13 UG1.AB40 UG1.AC13 UG1.AC14 UG1.AC15 UG1.AC16 UG1.AC17 UG1.AC18 UG1.AC19 UG1.AC20 UG1.AC21 UG1.AC22 UG1.AC23 UG1.AC24 UG1.AC25 UG1.AC26 UG1.AC27 UG1.AC28 UG1.AC29 UG1.AC30 UG1.AC31 UG1.AC32 UG1.AC33 UG1.AC34 UG1.AC35 UG1.AC36 UG1.AC37 UG1.AC38 UG1.AC39 UG1.AC40 UG1.AD13 UG1.AD40 UG1.AE13 UG1.AE14 UG1.AE15 UG1.AE16 UG1.AE17 UG1.AE18 UG1.AE19 UG1.AE20 UG1.AE21 UG1.AE22 UG1.AE23 UG1.AE24 UG1.AE25 UG1.AE26 UG1.AE27 UG1.AE28 UG1.AE29 UG1.AE30 UG1.AE31 UG1.AE32 UG1.AE33 UG1.AE34 UG1.AE35 UG1.AE36 UG1.AE37 UG1.AE38 UG1.AE39 UG1.AE40 UG1.AF13 UG1.AF14 UG1.AF15 UG1.AF16 UG1.AF17 UG1.AF18 UG1.AF24 UG1.AF25 UG1.AF26 UG1.AF30 UG1.AF31 UG1.AF32 UG1.AF33 UG1.AF34 UG1.AF40 UG1.AG13 UG1.AG19 UG1.AG20 UG1.AG21 UG1.AG22 UG1.AG23 UG1.AG27 UG1.AG28 UG1.AG29 UG1.AG35 UG1.AG36 UG1.AG37 UG1.AG38 UG1.AG39 UG1.AG40 UG1.AH13 UG1.AH14 UG1.AH15 UG1.AH16 UG1.AH17 UG1.AH18 UG1.AH19 UG1.AH20 UG1.AH21 UG1.AH22 UG1.AH23 UG1.AH24 UG1.AH25 UG1.AH26 UG1.AH27 UG1.AH28 UG1.AH29 UG1.AH30 UG1.AH31 UG1.AH32 UG1.AH33 UG1.AH34 UG1.AH35 UG1.AH36 UG1.AH37 UG1.AH38 UG1.AH39 UG1.AH40 UG1.AJ13 UG1.AJ40 UG1.AK13 UG1.AK14 UG1.AK15 UG1.AK16 UG1.AK17 UG1.AK18 UG1.AK19 UG1.AK20 UG1.AK21 UG1.AK22 UG1.AK23 UG1.AK24 UG1.AK25 UG1.AK26 UG1.AK27 UG1.AK28 UG1.AK29 UG1.AK30 UG1.AK31 UG1.AK32 UG1.AK33 UG1.AK34 UG1.AK35 UG1.AK36 UG1.AK37 UG1.AK38 UG1.AK39 UG1.AK40 UG1.AL13 UG1.AL40 UG1.AM13 UG1.AM14 UG1.AM15 UG1.AM16 UG1.AM17 UG1.AM18 UG1.AM19 UG1.AM20 UG1.AM21 UG1.AM22 UG1.AM23 UG1.AM24 UG1.AM25 UG1.AM26 UG1.AM27 UG1.AM28 UG1.AM29 UG1.AM30 UG1.AM31 UG1.AM32 UG1.AM33 UG1.AM34 UG1.AM35 UG1.AM36 UG1.AM37 UG1.AM38 UG1.AM39 UG1.AM40 UG1.AN13 UG1.AN40 UG1.AP13 UG1.AP14 UG1.AP15 UG1.AP16 UG1.AP17 UG1.AP18 UG1.AP19 UG1.AP20 UG1.AP21 UG1.AP22 UG1.AP23 UG1.AP24 UG1.AP25 UG1.AP26 UG1.AP27 UG1.AP28 UG1.AP29 UG1.AP30 UG1.AP31 UG1.AP32 UG1.AP33 UG1.AP34 UG1.AP35 UG1.AP36 UG1.AP37 UG1.AP38 UG1.AP39 UG1.AP40 UG1.AR13 UG1.AR40 UG1.AT13 UG1.AT14 UG1.AT15 UG1.AT16 UG1.AT17 UG1.AT18 UG1.AT19 UG1.AT20 UG1.AT21 UG1.AT22 UG1.AT23 UG1.AT24 UG1.AT25 UG1.AT26 UG1.AT27 UG1.AT28 UG1.AT29 UG1.AT30 UG1.AT31 UG1.AT32 UG1.AT33 UG1.AT34 UG1.AT35 UG1.AT36 UG1.AT37 UG1.AT38 UG1.AT39 UG1.AT40 UG1.AT42 UG1.AU13 UG1.AU40 UG1.AU43 UG1.AV13 UG1.AV14 UG1.AV15 UG1.AV16 UG1.AV17 UG1.AV18 UG1.AV19 UG1.AV20 UG1.AV21 UG1.AV22 UG1.AV23 UG1.AV24 UG1.AV25 UG1.AV26 UG1.AV27 UG1.AV28 UG1.AV29 UG1.AV30 UG1.AV31 UG1.AV32 UG1.AV33 UG1.AV34 UG1.AV35 UG1.AV36 UG1.AV37 UG1.AV38 UG1.AV39 UG1.AV40 UG1.AV42 UG1.AV43 UG1.AV44 UG1.AW13 UG1.AW40 UG1.AW42 UG1.AW43 UG1.AW44 UG1.AW45 UG1.AY13 UG1.AY14 UG1.AY15 UG1.AY16 UG1.AY17 UG1.AY18 UG1.AY19 UG1.AY20 UG1.AY21 UG1.AY22 UG1.AY23 UG1.AY24 UG1.AY25 UG1.AY26 UG1.AY27 UG1.AY28 UG1.AY29 UG1.AY30 UG1.AY31 UG1.AY32 UG1.AY33 UG1.AY34 UG1.AY35 UG1.AY36 UG1.AY37 UG1.AY38 UG1.AY39 UG1.AY40 UG1.AY43 UG1.AY45 UG1.BA43 UG1.BA44 UG1.BA45 UG1.BA46 UG1.BA47 UG1.BB38 UG1.BB39 UG1.BB45 UG1.BB46 UG1.BB47 UG1.BB48 UG1.BC38 UG1.BC39 UG1.BC40 UG1.BC41 UG1.BC45 UG1.BC47 UG1.BC49 UG1.BD39 UG1.BD41 UG1.BD46 UG1.BD47 UG1.BD48 UG1.BD49 UG1.BD50 UG1.BD51 UG1.BE41 UG1.BE42 UG1.BE43 UG1.BE46 UG1.BE47 UG1.BE48 UG1.BE49 UG1.BE50 UG1.BE51 UG1.BE52 UG1.BF42 UG1.BF44 UG1.BF45 UG1.BF47 UG1.BF49 UG1.BF51 UG1.BG43 UG1.BG44 UG1.BG45 UG1.BG46 UG1.BG47 UG1.BG48 UG1.BG49 UG1.BG50 UG1.BG51 UG1.BG52 UG1.BH44 UG1.BH45 UG1.BH47 UG1.BH48 UG1.BH49 UG1.BH50 UG1.BH51 UG1.BH52 UG1.BJ44 UG1.BJ45 UG1.BJ46 UG1.BJ47 UG1.BJ48 UG1.BJ49 UG1.BJ50 UG1.BJ51 UG1.BJ52 UG1.BK47 UG1.BK48 UG1.BK49 UG1.BK50 UG1.BK51 UG1.BK52 UG1.BL46 UG1.BL47 UG1.BL48 UG1.BL49 UG1.BL50 UG1.BL51 UG1.BL52 UG1.BM47 UG1.BM48 UG1.BM49 UG1.BM50 UG1.BM51 UG1.N13 UG1.N14 UG1.N15 UG1.N16 UG1.N17 UG1.N18 UG1.N19 UG1.N20 UG1.N21 UG1.N22 UG1.N23 UG1.N24 UG1.N25 UG1.N26 UG1.N27 UG1.N28 UG1.N29 UG1.N30 UG1.N31 UG1.N32 UG1.N33 UG1.N34 UG1.N35 UG1.N36 UG1.N37 UG1.N38 UG1.N39 UG1.N40 UG1.P13 UG1.P40 UG1.R13 UG1.R14 UG1.R15 UG1.R16 UG1.R17 UG1.R18 UG1.R19 UG1.R20 UG1.R21 UG1.R22 UG1.R23 UG1.R24 UG1.R25 UG1.R26 UG1.R27 UG1.R28 UG1.R29 UG1.R30 UG1.R31 UG1.R32 UG1.R33 UG1.R34 UG1.R35 UG1.R36 UG1.R37 UG1.R38 UG1.R39 UG1.R40 UG1.T13 UG1.T40 UG1.U13 UG1.U14 UG1.U15 UG1.U16 UG1.U17 UG1.U18 UG1.U19 UG1.U20 UG1.U21 UG1.U22 UG1.U23 UG1.U24 UG1.U25 UG1.U26 UG1.U27 UG1.U28 UG1.U29 UG1.U30 UG1.U31 UG1.U32 UG1.U33 UG1.U34 UG1.U35 UG1.U36 UG1.U37 UG1.U38 UG1.U39 UG1.U40 UG1.V13 UG1.V40 UG1.W13 UG1.W14 UG1.W15 UG1.W16 UG1.W17 UG1.W18 UG1.W19 UG1.W20 UG1.W21 UG1.W22 UG1.W23 UG1.W24 UG1.W25 UG1.W26 UG1.W27 UG1.W28 UG1.W29 UG1.W30 UG1.W31 UG1.W32 UG1.W33 UG1.W34 UG1.W35 UG1.W36 UG1.W37 UG1.W38 UG1.W39 UG1.W40 UG1.Y13 UG1.Y40
NVVDD_CORE1: DG3.1(CATHODE) DG6.2 DG7.2 RG80.1 RG180.2 RG189.1 UG8.4
NVVDD_CORE1_EN: CG899.1 DG7.1(CATHODE) PD7.1(CATHODE) PR320.2 RG184.1 RG189.2
NVVDD_PG_LOOP_OVT: QG21.2 QG23.3 QG23.6 RG185.2
NVVDD_PSI: PR532.1 RG18.2 UG1.BD2
NVVDD_PWM_GPU: PR314.1 UG1.BD6
NVVDD_SENSE_I: PR298.1 PR361.1
NVVDD_SENSE_V: PR299.1 PR358.1 PR362.2
NVVDDPG: DG4.1 PR527.1 QG23.5 RG78.2
OUT_DP_TXN0: C31.2 U39.39
OUT_DP_TXN1: C25.2 U39.36
OUT_DP_TXN2: C27.2 U39.34
OUT_DP_TXN3: C29.2 U39.31
OUT_DP_TXP0: C30.2 U39.40
OUT_DP_TXP1: C24.2 U39.37
OUT_DP_TXP2: C26.2 U39.33
OUT_DP_TXP3: C28.2 U39.30
OVERT#: QG9.1(S) RG45.2 RG51.1 UG1.BG5
OVRM_VCC: PR342.2 PR343.2 PR344.2 PR346.1 PR348.1 PR349.1 PR353.1
PA_DP_MODE: U5.16 U13.21
PA_POL: U5.11 U5.15 U13.22
PA_TBT_MODE: U5.10 U13.23
PA_USB2_RBIAS: R812.2 U7.H19
PB_USB2_RBIAS: R811.1 U7.F19
PBLED: C353.1 Q1.2 R12.2 R388.1
PBLED#: CN8.5 D9.1 Q1.3
PBLED_R: R388.2 U18.81
PCBEEP_EC: D36.2 U18.34
PCH_2_CPU_TRIG: R232.2 U3.H23
PCH_2_CPU_TRIG_R: R232.1 U14.AK3
PCH_AZ_CODEC_BITCLK: C277.1 R488.1 U17.11
PCH_AZ_CODEC_RST#: R496.1 U17.10
PCH_AZ_CODEC_SDIN0: R294.2 R491.1
PCH_AZ_CODEC_SDOUT: R492.1 U17.14
PCH_AZ_CODEC_SYNC: R494.1 U17.12
PCH_BLON_EC: R89.1 U18.88
PCH_BRIGHT: CN10.34 Q15.3 R44.2 R45.2 R100.2
PCH_DISP_ON: R698.1 U14.AV44
PCH_DMICCLK: R691.2 U14.BD16
PCH_DMICDAT: R692.2 U14.BF15
PCH_DPST_PWM: R45.1 R909.1 U14.AU48
PCH_GPD7: R532.1 R533.2 U14.BE41
PCH_GPP_H15: R836.1 R850.2 U14.AC47
PCH_JTAGX: R248.1 U14.AH4
PCH_LVDS_BLON: R91.1 U14.AV46
PCH_PECI: R52.1 R193.2 U14.AF2
PCH_PWROK: R1108.2 U18.78
PCH_RSMRST#: R951.1 R965.1 R981.2 U14.BA47
PCH_SLP_S0IX#: CN5.15 R552.2 R1072.1
PCH_SLP_S0IX#_L: R495.1 R552.1 U14.BC28
PCH_SLP_SUS#: TP105.1 U14.BD39
PCH_SMBCLK: JDIM1.253 JDIM2.253 JDIM3.253 JDIM4.253 Q66.1(S) R726.2
PCH_SMBDATA: JDIM1.254 JDIM2.254 JDIM3.254 JDIM4.254 Q66.4 R723.2
PCH_SPI1_CLK: EC5.2 R321.1 R360.1 U19.6
PCH_SPI1_CLK_L: R360.2 R1067.1 U14.AW47
PCH_SPI1_SI: R335.1 R341.1 R936.1 U19.5
PCH_SPI1_SI_L: R919.1 R936.2 R940.2 R1066.1 U14.AU41
PCH_SPI1_SO: R454.1 R945.1 U19.2
PCH_SPI1_SO_L: R931.1 R944.2 R945.2 R1044.1 U14.BA45
PCH_SPI_CLK_EC: R321.2 U18.105
PCH_SPI_CS0#: R369.1 R452.2 R453.2 U19.1
PCH_SPI_CS0#_L: R369.2 U14.AY47
PCH_SPI_IO2: R455.1 U19.3(W\P\(IO2))
PCH_SPI_IO3: R320.1 R340.2 U19.7
PCH_SPI_SI_EC: R276.1 R341.2 U18.102
PCH_SPI_SO_EC: R272.1 R454.2 U18.103
PCH_TBT_PLTRST#: R1150.2 U6.2 U14.AM48
PCH_TBT_WAKE#: Q27.1(S) R222.2 R223.1 U14.T47
PCH_TCK: R283.2 U14.AJ3
PCH_TDI: R244.1 U14.AH2
PCH_TDO: R188.1 R189.2 U14.AH3
PCH_TMS: R264.1 U14.AJ4
PCH_WAKE#: Q27.3 R223.2 R1153.1
PCH_WAKE#_L: R436.1 R449.1 U14.BB47
PCI_PLTRST#: R1152.2 U14.AV29 U31.1 U31.2
PCIE_CLKREQ2#: R1120.1 U14.AR32
PCIE_CLKREQ7#: R279.1 U14.AC48
PCIE_CLKREQ8#: R864.1 U14.AE41
PCIE_CLKREQ9#: R338.1 U14.AF48
PCIE_CLKREQ10#: R832.1 U14.AC41
PCIE_CLKREQ11#: R831.1 U14.AC39
PCIE_CLKREQ12#: R825.1 U14.AE39
PCIE_CLKREQ13#: R281.1 U14.AB48
PCIE_CLKREQ14#: R846.1 U14.AC44
PCIE_CLKREQ15#: R835.1 U14.AC43
PCIE_CLKREQ_LAN#: CN17.33 R1119.1 U14.BB30
PCIE_CLKREQ_NGFF1#: CN15.52 R576.1 U14.BF31
PCIE_CLKREQ_NGFF2#: CN18.52 R1098.1 U14.AN29
PCIE_CLKREQ_TBT#: Q69.1(S) R305.1 R791.2 U14.AE47
PCIE_CLKREQ_TBT#_C: Q69.3 R767.1 R791.1 U7.AC5
PCIE_CLKREQ_VGA#: QG13.3 R490.1 U14.BE31
PCIE_CLKREQ_WLAN#: Q28.3 R1129.1 U14.BA30
PCIE_RXN9_SSD: R782.1 U14.G36
PCIE_RXN9_SSD_R: CN15.5 R782.2
PCIE_RXN10_SSD: R796.1 U14.K37
PCIE_RXN10_SSD_R: CN15.17 R796.2
PCIE_RXN11_SSD: R810.1 U14.G38
PCIE_RXN11_SSD_R: CN15.29 R810.2
PCIE_RXN12_SSD: R827.1 U14.H42
PCIE_RXN12_SSD_R: CN15.43 R827.2
PCIE_RXN14_LAN: CN17.38 U14.D46
PCIE_RXN15_WLAN: CN16.43 U14.F44
PCIE_RXN17_TBT: C215.2 U14.K43
PCIE_RXN17_TBT_C: C215.1 U7.V22
PCIE_RXN18_TBT: C218.2 U14.P41
PCIE_RXN18_TBT_C: C218.1 U7.P22
PCIE_RXN19_TBT: C220.2 U14.M44
PCIE_RXN19_TBT_C: C220.1 U7.K22
PCIE_RXN20_TBT: C222.2 U14.R35
PCIE_RXN20_TBT_C: C222.1 U7.F22
PCIE_RXN21_SSD: R1028.1 U14.T43
PCIE_RXN21_SSD_R: CN18.43 R1028.2
PCIE_RXN22_SSD: R985.1 U14.U40
PCIE_RXN22_SSD_R: CN18.29 R985.2
PCIE_RXN23_SSD: R950.1 U14.W43
PCIE_RXN23_SSD_R: CN18.17 R950.2
PCIE_RXN24_SSD: R933.1 U14.Y40
PCIE_RXN24_SSD_R: CN18.5 R933.2
PCIE_RXP9_SSD: R787.1 U14.F36
PCIE_RXP9_SSD_R: CN15.7 R787.2
PCIE_RXP10_SSD: R801.1 U14.J37
PCIE_RXP10_SSD_R: CN15.19 R801.2
PCIE_RXP11_SSD: R816.1 U14.F39
PCIE_RXP11_SSD_R: CN15.31 R816.2
PCIE_RXP12_SSD: R819.1 U14.J41
PCIE_RXP12_SSD_R: CN15.41 R819.2
PCIE_RXP14_LAN: CN17.37 U14.C47
PCIE_RXP15_WLAN: CN16.41 U14.E45
PCIE_RXP17_TBT: C216.2 U14.K44
PCIE_RXP17_TBT_C: C216.1 U7.V23
PCIE_RXP18_TBT: C217.2 U14.R40
PCIE_RXP18_TBT_C: C217.1 U7.P23
PCIE_RXP19_TBT: C219.2 U14.N42
PCIE_RXP19_TBT_C: C219.1 U7.K23
PCIE_RXP20_TBT: C221.2 U14.R37
PCIE_RXP20_TBT_C: C221.1 U7.F23
PCIE_RXP21_SSD: R1027.1 U14.R44
PCIE_RXP21_SSD_R: CN18.41 R1027.2
PCIE_RXP22_SSD: R1000.1 U14.U41
PCIE_RXP22_SSD_R: CN18.31 R1000.2
PCIE_RXP23_SSD: R966.1 U14.W44
PCIE_RXP23_SSD_R: CN18.19 R966.2
PCIE_RXP24_SSD: R934.1 U14.Y41
PCIE_RXP24_SSD_R: CN18.7 R934.2
PCIE_TXN9_SSD: C734.2 U14.C34
PCIE_TXN9_SSD_R: C734.1 CN15.11
PCIE_TXN10_SSD: C760.2 U14.C35
PCIE_TXN10_SSD_R: C760.1 CN15.23
PCIE_TXN11_SSD: C779.2 U14.B36
PCIE_TXN11_SSD_R: C779.1 CN15.35
PCIE_TXN12_SSD: C783.2 U14.D38
PCIE_TXN12_SSD_R: C783.1 CN15.47
PCIE_TXN14_LAN: CN17.43 R170.2
PCIE_TXN14_LAN_C: R170.1 U14.C39
PCIE_TXN15_WLAN: C232.2 CN16.37
PCIE_TXN15_WLAN_C: C232.1 U14.B40
PCIE_TXN17_TBT: C178.2 U7.Y22
PCIE_TXN17_TBT_C: C178.1 U14.A42
PCIE_TXN18_TBT: C177.2 U7.T22
PCIE_TXN18_TBT_C: C177.1 U14.C42
PCIE_TXN19_TBT: C181.2 U7.M22
PCIE_TXN19_TBT_C: C181.1 U14.C44
PCIE_TXN20_TBT: C174.2 U7.H22
PCIE_TXN20_TBT_C: C174.1 U14.A44
PCIE_TXN21_SSD: C913.2 U14.G47
PCIE_TXN21_SSD_R: C913.1 CN18.47
PCIE_TXN22_SSD: C899.2 U14.H47
PCIE_TXN22_SSD_R: C899.1 CN18.35
PCIE_TXN23_SSD: C876.2 U14.G49
PCIE_TXN23_SSD_R: C876.1 CN18.23
PCIE_TXN24_SSD: C862.2 U14.G46
PCIE_TXN24_SSD_R: C862.1 CN18.11
PCIE_TXP9_SSD: C741.2 U14.D34
PCIE_TXP9_SSD_R: C741.1 CN15.13
PCIE_TXP10_SSD: C769.2 U14.B35
PCIE_TXP10_SSD_R: C769.1 CN15.25
PCIE_TXP11_SSD: C780.2 U14.C36
PCIE_TXP11_SSD_R: C780.1 CN15.37
PCIE_TXP12_SSD: C784.2 U14.E37
PCIE_TXP12_SSD_R: C784.1 CN15.49
PCIE_TXP14_LAN: CN17.44 R169.2
PCIE_TXP14_LAN_C: R169.1 U14.D39
PCIE_TXP15_WLAN: C231.2 CN16.35
PCIE_TXP15_WLAN_C: C231.1 U14.C40
PCIE_TXP17_TBT: C179.2 U7.Y23
PCIE_TXP17_TBT_C: C179.1 U14.B42
PCIE_TXP18_TBT: C176.2 U7.T23
PCIE_TXP18_TBT_C: C176.1 U14.D42
PCIE_TXP19_TBT: C171.2 U7.M23
PCIE_TXP19_TBT_C: C171.1 U14.D43
PCIE_TXP20_TBT: C184.2 U7.H23
PCIE_TXP20_TBT_C: C184.1 U14.B44
PCIE_TXP21_SSD: C920.2 U14.F46
PCIE_TXP21_SSD_R: C920.1 CN18.49
PCIE_TXP22_SSD: C904.2 U14.H48
PCIE_TXP22_SSD_R: C904.1 CN18.37
PCIE_TXP23_SSD: C885.2 U14.G48
PCIE_TXP23_SSD_R: C885.1 CN18.25
PCIE_TXP24_SSD: C869.2 U14.G45
PCIE_TXP24_SSD_R: C869.1 CN18.13
PCIE_WAKE#: CN17.34 Q22.3 Q26.3 R130.1 R449.2
PCIE_WAKE#_TBT: Q22.1(S) R130.2 R140.2 R737.2 R1153.2 U7.W1
PCIECOMP_N: R171.1 U14.B12
PCIECOMP_P: R171.2 U14.A13
PCM_CLK: CN16.8 R1118.1
PCM_IN: CN16.12 R1117.1
PD1#: D52.2 D59.2 R475.2 R503.2 R511.1 R1021.2 U20.7 U22.7 U25.7
PD_GPIO1: R337.2 U13.17
PD_GPIO2: R311.2 U13.18
PD_GPIO16: R870.2 U13.48
PD_GPIO17: R884.2 U13.49
PD_LDO_1V8: C228.1 U13.35
PECI: R47.1 R52.2 U3.BT34
PEG_COMP: R102.2 U3.G2
PEG_RXN0: CG890.1 U3.E10
PEG_RXN0_C: CG890.2 UG1.BH26
PEG_RXN1: CG898.1 U3.E11
PEG_RXN1_C: CG898.2 UG1.BE26
PEG_RXN2: CG888.1 U3.E12
PEG_RXN2_C: CG888.2 UG1.BG27
PEG_RXN3: CG895.1 U3.E13
PEG_RXN3_C: CG895.2 UG1.BH29
PEG_RXN4: CG886.1 U3.E14
PEG_RXN4_C: CG886.2 UG1.BE29
PEG_RXN5: CG884.1 U3.E15
PEG_RXN5_C: CG884.2 UG1.BG30
PEG_RXN6: CG892.1 U3.E16
PEG_RXN6_C: CG892.2 UG1.BH32
PEG_RXN7: CG894.1 U3.E17
PEG_RXN7_C: CG894.2 UG1.BE32
PEG_RXN8: CG880.1 U3.F18
PEG_RXN8_C: CG880.2 UG1.BG33
PEG_RXN9: CG878.1 U3.D19
PEG_RXN9_C: CG878.2 UG1.BH35
PEG_RXN10: CG867.1 U3.F20
PEG_RXN10_C: CG867.2 UG1.BE35
PEG_RXN11: CG875.1 U3.D21
PEG_RXN11_C: CG875.2 UG1.BG36
PEG_RXN12: CG873.1 U3.F22
PEG_RXN12_C: CG873.2 UG1.BH38
PEG_RXN13: CG871.1 U3.D23
PEG_RXN13_C: CG871.2 UG1.BE38
PEG_RXN14: CG868.1 U3.F24
PEG_RXN14_C: CG868.2 UG1.BG39
PEG_RXN15: CG863.1 U3.D25
PEG_RXN15_C: CG863.2 UG1.BG41
PEG_RXP0: CG891.1 U3.F10
PEG_RXP0_C: CG891.2 UG1.BG26
PEG_RXP1: CG897.1 U3.D11
PEG_RXP1_C: CG897.2 UG1.BF26
PEG_RXP2: CG889.1 U3.F12
PEG_RXP2_C: CG889.2 UG1.BF27
PEG_RXP3: CG896.1 U3.D13
PEG_RXP3_C: CG896.2 UG1.BG29
PEG_RXP4: CG887.1 U3.F14
PEG_RXP4_C: CG887.2 UG1.BF29
PEG_RXP5: CG885.1 U3.D15
PEG_RXP5_C: CG885.2 UG1.BF30
PEG_RXP6: CG883.1 U3.F16
PEG_RXP6_C: CG883.2 UG1.BG32
PEG_RXP7: CG882.1 U3.D17
PEG_RXP7_C: CG882.2 UG1.BF32
PEG_RXP8: CG881.1 U3.E18
PEG_RXP8_C: CG881.2 UG1.BF33
PEG_RXP9: CG879.1 U3.E19
PEG_RXP9_C: CG879.2 UG1.BG35
PEG_RXP10: CG870.1 U3.E20
PEG_RXP10_C: CG870.2 UG1.BF35
PEG_RXP11: CG876.1 U3.E21
PEG_RXP11_C: CG876.2 UG1.BF36
PEG_RXP12: CG874.1 U3.E22
PEG_RXP12_C: CG874.2 UG1.BG38
PEG_RXP13: CG872.1 U3.E23
PEG_RXP13_C: CG872.2 UG1.BF38
PEG_RXP14: CG877.1 U3.E24
PEG_RXP14_C: CG877.2 UG1.BF39
PEG_RXP15: CG866.1 U3.E25
PEG_RXP15_C: CG866.2 UG1.BH41
PEG_TXN0: C90.1 UG1.BK27
PEG_TXN1: C89.1 UG1.BL29
PEG_TXN2: C86.1 UG1.BM30
PEG_TXN3: C85.1 UG1.BK30
PEG_TXN4: C82.1 UG1.BL32
PEG_TXN5: C81.1 UG1.BM33
PEG_TXN6: C78.1 UG1.BK33
PEG_TXN7: C77.1 UG1.BL35
PEG_TXN8: C75.1 UG1.BM36
PEG_TXN9: C72.1 UG1.BK36
PEG_TXN10: C71.1 UG1.BL38
PEG_TXN11: C68.1 UG1.BM39
PEG_TXN12: C67.1 UG1.BK39
PEG_TXN13: C63.1 UG1.BL41
PEG_TXN14: C61.1 UG1.BM42
PEG_TXN15: C57.1 UG1.BK42
PEG_TXP0: C91.1 UG1.BL27
PEG_TXP1: C88.1 UG1.BK29
PEG_TXP2: C87.1 UG1.BM29
PEG_TXP3: C84.1 UG1.BL30
PEG_TXP4: C83.1 UG1.BK32
PEG_TXP5: C80.1 UG1.BM32
PEG_TXP6: C79.1 UG1.BL33
PEG_TXP7: C76.1 UG1.BK35
PEG_TXP8: C74.1 UG1.BM35
PEG_TXP9: C73.1 UG1.BL36
PEG_TXP10: C70.1 UG1.BK38
PEG_TXP11: C69.1 UG1.BM38
PEG_TXP12: C65.1 UG1.BL39
PEG_TXP13: C64.1 UG1.BK41
PEG_TXP14: C59.1 UG1.BM41
PEG_TXP15: C58.1 UG1.BL42
PEGX_RST#: QG9.2 RG43.2 RG155.2 RG182.1 RG185.1 UG1.BK26
PEX_CLKREQ: QG13.1(S) RG70.1 UG1.BL26
PEX_PLL_HVDD: CG781.2 CG783.2 CG837.2 RG141.1 UG1.BB30
PEX_TERMP: RG36.2 UG1.BL44
PEXVDD_EN_U: CG82.1 DG3.2 RG74.2 RG80.2 UG3.2
PGDMON: R867.2 U14.Y14
PIRQ#: R1018.1 U14.BE29
PIRQ#_C: R1018.2 R1064.2 U44.18
PLT_ID0: R861.2 R871.1 U14.AU46
PLT_ID1: R878.2 R889.1 U14.AU47
PLTRST#: CN17.35 R162.2 R200.2 R201.2 R412.1 R555.2 R605.2 R609.2 R1151.2 U27.1 U27.2 U31.4 U44.17 UG7.2
PLTRST#_EC: R412.2 U18.22
PM_SYNC: R219.1 U3.BM34
PM_SYNC_R: R219.2 U14.AF3
PM_THRMTRIP#: D88.2 R51.1 R333.1 R348.1 R718.1 R721.1 R845.2
PM_THRMTRIP#_L: C800.1 R845.1 R855.1 U14.AD3
PMON: PC169.2 PR71.1 PR193.1 PR252.1
PP: T16.1 U44.4
PPC_CC1_6: C437.2 R505.2 R521.2 U23.6
PPC_CC2_4: R434.2 R445.2 U23.4
PPC_DVDD_IO: C386.1 C854.2 R405.1 R937.2 U23.19
PPC_DVDD_IO_13: C444.2 R1061.1 U23.13
PPC_DVDD_IO_C: C368.1 R975.1 R984.1 TP109.1 U23.21
PPC_FW_ID: R525.1 R1076.2 U23.8
PPC_HPD_11: R526.2 R527.2 U23.11
PPC_I2C_ADR_1: R406.2 TP46.1 U23.1
PPC_I2CM_SCL_C: R435.1 R1001.1 U23.17
PPC_I2CM_SDA_C: R448.1 R1074.1 U23.16
PPC_I2CS_SCL_18: R425.1 U23.18
PPC_I2CS_SCL_C: C912.2 R1013.2 R1077.2 U23.10
PPC_I2CS_SDA_C: R1046.2 R1060.2 U23.9
PPC_P36: R408.1 U23.23
PPC_VBUS_MON_C: R418.1 R424.1 U23.2
PPC_VBUS_MON_XRES: R522.2 R523.2 R524.2 TP50.1 U23.7(XRES/RESET_INPUT)
PPC_VBUS_MONITOR: C928.2 R418.2 R523.1 R1116.1 R1136.2
PPC_VCCD_C: C367.2 R959.1 U23.22
PPC_VCON_5V: C428.2 R1043.1 U23.5
PPC_VDDD_A: C456.2 R528.1 U23.12
PPC_VDDD_C: C369.1 R957.1 U23.20
PRE_SEL: R648.1 U34.27
PROC_SEL#: R97.2 R98.1 U3.BN1
PROCHOT_EC: C246.1 Q29.2 R268.2 U18.17
PROCPWRGD: C56.1 U3.BT31 U14.AE3
PS8811_MBCLK: Q33.3 R1128.2 U30.33
PS8811_MBDATA: Q33.6 R1127.2 U30.32
PS8817_A1_EQ: R994.1 R1009.2 U21.43
PS8817_A2_EQ: R923.2 R938.1 U21.34
PS8817_ADDR: R469.2 R516.1 U21.53
PS8817_B1_DE: R995.2 R1010.1 U21.6
PS8817_B1_EQ: R962.1 R979.2 U21.7
PS8817_B2_DE: R308.2 R354.1 U21.25
PS8817_B2_EQ: R309.2 R353.1 U21.23
PS8817_DCI_CLK: TP39.1 U21.15
PS8817_DCI_DATA: TP38.1 U21.16
PS8817_DCI_EN: R310.2 R350.1 U21.21
PS8817_EN: R363.2 U21.20
PS8817_MBCLK: CN17.13 Q46.4 R567.2 U21.51
PS8817_MBDATA: CN17.12 Q46.1(S) R562.2 U21.50
PS8817_MODE: R467.2 R499.1 U21.48
PS8817_RESETB: C327.2 R306.1 U21.26
PS8817_REXT: R463.2 U21.47
PS_FBVDD_PGOOD: DG4.2 PR35.2 Q3.2 UG10.1
PS_USB_VBUS_DSH_QR: PQ13.3 PR125.2
PS_USB_VDDP_IN: CG773.2 CG777.1 CG811.1 CG840.2 RG139.2 RG195.2 UG1.BE12
PS_USBC_PD_BST1: PR88.2 PU7.16
PS_USBC_PD_BST1_R: PC79.1 PR88.1
PS_USBC_PD_BST2: PR104.2 PU7.13
PS_USBC_PD_BST2_R: PC81.2 PR104.1
PS_USBC_PD_EN: PC76.1 PR87.2 PU7.3
PS_USBC_PD_OC: PC80.1 PR102.1 PU7.7
PS_USBC_PD_SW1: PC79.2 PL2.1 PU7.15
PS_USBC_PD_SW2: PC81.1 PL2.2 PU7.14
PS_USBC_PD_VCC: PC83.1 PR107.1 PU7.9(VCC)
PS_USBC_PD_VOUT_1: PC84.1 PC86.1 PC87.1 PC324.1 PQ12.7 PU7.12
PS_VBUS_ALT: PR105.2 R394.1 R406.1
PTP_PWR_EN#: R1161.1 R1162.1
PW_VCC3_ANA_PCIE: C742.2 U7.L16
PW_VCC3_ANA_USB: C750.2 U7.J16
PWM1_1PH: PR90.1 PR439.1 PU2.44
PWM1_4PH_A: PR60.1 PR456.2 PU2.18
PWM2_4PH_A: PR59.1 PR74.2 PU2.19
PWM3_4PH_A: PR58.1 PR453.2 PU2.20
PWM4_4PH_A: PR57.1 PR455.2 PU2.21
PWR_LEVEL: DG2.2 QG3.1(S) RG13.2 RG16.1 UG1.BE6
PWRLED#: CN8.14 D85.1 R420.2
R_SPKL+: C359.1 CN13.4 L12.2
R_SPKL-: C387.1 CN13.3 L15.2
R_SPKR+: C434.1 CN13.2 L20.2
R_SPKR-: C416.1 CN13.1 L19.2
REGN6V: PC170.1 PR276.1 PU23.24
RESETB: C495.1 R631.2 U30.16
REXT: R561.1 U30.29
RF_EN: CN16.56 R184.1 R450.1
ROM_CS: RG71.2 UG1.BJ4
ROM_CS_R: RG71.1 RG76.2 TPG10.1 UG2.1
ROM_SCLK: RG62.2 RG143.1 RG147.2 UG1.BK3
ROM_SCLK_R: RG62.1 TPG9.1 UG2.6
ROM_SI: RG31.2 RG35.1 RG47.1 UG1.BK2
ROM_SI_R: RG47.2 TPG7.1 UG2.5
ROM_SO: RG49.2 RG50.1 TPG8.1 UG1.BK4 UG2.2
RS232_DET#: R881.1 U14.AR48
RSMRST#: R981.1 U18.112
RST_BUF_PWR: C931.1 R1132.2 R1141.2 U29.5(VCC) U32.5
RTC_RST#: C489.1 CN5.9 J1.1 Q49.3 R619.2 U14.BE47
RTC_X1: C365.2 R411.1 U14.BA49 Y4.1
RTC_X2: C391.2 R411.2 U14.BA48 Y4.2
RTD3_CIO_PWR_EN: R739.1 R863.2
S1: U13.8 U13.15 U13.19 U13.58 U13.63 U13.64 U13.65 U13.69 U13.70 U13.71
S2: U13.7 U13.52 U13.56 U13.57 U13.60 U13.61 U13.62 U13.66 U13.67 U13.68(NC#68)
S5_ON: PQ58.2 PR385.1 PR406.1 PR417.2 PR569.1 PR570.1 R273.1 R380.2 U18.100
S5_ON_R: PC440.1 PR570.2 PU32.3 PU32.5
S_GPIO: R1056.1 R1104.1 R1105.2
S_SPKR+: C461.1 L22.2 R504.1
S_SPKR-: C473.1 CN22.1 L24.2
SATA_LED#: CN8.15 CN15.10 CN18.10 D49.2 D84.1 EC7.2 R343.1 U14.AK48
SATA_RXN0: C903.2 U14.C45
SATA_RXN0_CN: C908.1 CN20.16
SATA_RXN_IN: C903.1 U43.4
SATA_RXN_OUT: C908.2 U43.12
SATA_RXP0: C910.2 U14.C46
SATA_RXP0_CN: C914.1 CN20.15
SATA_RXP_IN: C910.1 U43.5
SATA_RXP_OUT: C914.2 U43.11
SATA_TXN0: C891.2 U14.B38
SATA_TXN0_CN: C902.1 CN20.18
SATA_TXN_IN: C891.1 U43.2
SATA_TXN_OUT: C902.2 U43.14
SATA_TXP0: C883.2 U14.C38
SATA_TXP0_CN: C889.1 CN20.19
SATA_TXP_IN: C883.1 U43.1
SATA_TXP_OUT: C889.2 U43.15
SENSEA: R594.2 R911.1 U17.48
SENSEA_EC: Q54.3 R587.1
SENSEB: R373.1 U17.49
SERIRQ: R1047.2 U14.AW35 U18.5
SIO_EXT_SCI#: R907.2 U14.AL15 U18.23
SIO_RCIN#: R474.2 U14.BE39 U18.4
SKTOCC_N: R53.2 U3.BR33
SKTOCC_N_R: R53.1 R900.2 U14.AP41
SLP_A#: CN5.6 R540.2
SLP_A#_L: R540.1 U14.BE40
SLP_LAN#: TP112.1 U14.BF40
SLP_S3#_L: R480.1 U14.BF42
SLP_S4#_L: R541.1 U14.BE42
SLP_S5#: CN5.4 R479.2
SLP_S5#_L: R479.1 U14.BC42
SLP_WLAN_N: TP113.1 U14.BD42
SM_INTRUDER#: R967.2 U14.BB44
SM_RCOMP_0: R99.1 U3.G1
SM_RCOMP_1: R105.2 U3.H1
SM_RCOMP_2: R109.1 U3.J2
SMB1ALERT#: R1071.1 R1103.1 U14.BD33
SMB_ME0_CLK: R537.2 U14.BF25
SMB_ME0_DAT: R535.2 U14.BE24
SMB_ME1_CLK: Q55.1(S) R606.2 R1157.1 U14.BF27
SMB_ME1_DAT: Q55.4 R603.2 R1156.1 U14.BE27
SMB_ME2_CLK: R303.2 U14.AE48
SMB_ME2_DAT: R288.2 U14.AD47
SMB_ME3_CLK: R891.2 U14.AF47
SMB_ME3_DAT: R289.2 U14.AD48
SMB_ME4_CLK: R849.2 R863.1 U14.AE43
SMB_ME4_DAT: R879.2 U14.AJ46
SMB_PCH_CLK: Q66.6 R478.2 U14.BE26
SMB_PCH_DAT: Q66.3 R477.2 U14.BF26
SMBALERT#: R574.1 R575.2 U14.BE25
SMDDR_VREF_CA: C694.1 R730.1 U3.BN13
SMDDR_VREF_DQ0_M3: TP9.1 U3.BP13
SMDDR_VREF_DQ1_M3: C151.1 R164.1 U3.BR13
SML0ALERT#: R476.2 R577.2 U14.BF24
SML2ALERT#: R270.1 R271.1 U14.AB47
SNN_FBA_RFU_G5: TPG46.1 VRAM6.G5
SNN_FBA_RFU_G5_1: TPG64.1 VRAM8.G5
SNN_FBA_RFU_M5: TPG45.1 VRAM6.M5
SNN_FBA_RFU_M5_1: TPG62.1 VRAM8.M5
SNN_FBA_TCK0: TPG47.1 VRAM6.N5
SNN_FBA_TCK1: TPG65.1 VRAM8.N5
SNN_FBA_TDI0: TPG51.1 VRAM6.F10
SNN_FBA_TDI1: TPG60.1 VRAM8.F10
SNN_FBA_TDO0: TPG50.1 VRAM6.N10
SNN_FBA_TDO1: TPG61.1 VRAM8.N10
SNN_FBA_TMS0: TPG49.1 VRAM6.F5
SNN_FBA_TMS1: TPG63.1 VRAM8.F5
SNN_FBB_RFU_G5: TPG20.1 VRAM3.G5
SNN_FBB_RFU_G5_1: TPG23.1 VRAM4.G5
SNN_FBB_RFU_M5: TPG28.1 VRAM3.M5
SNN_FBB_RFU_M5_1: TPG22.1 VRAM4.M5
SNN_FBB_TCK1: TPG13.1 VRAM4.N5
SNN_FBB_TDI1: TPG26.1 VRAM4.F10
SNN_FBB_TDO1: TPG17.1 VRAM4.N10
SNN_FBB_TMS1: TPG29.1 VRAM4.F5
SNN_FBC_RFU_G5: TPG19.1 VRAM1.G5
SNN_FBC_RFU_G5_1: TPG24.1 VRAM2.G5
SNN_FBC_RFU_M5: TPG25.1 VRAM1.M5
SNN_FBC_RFU_M5_1: TPG18.1 VRAM2.M5
SNN_FBC_TCK0: TPG27.1 VRAM1.N5
SNN_FBC_TCK1: TPG15.1 VRAM2.N5
SNN_FBC_TDI0: TPG16.1 VRAM1.F10
SNN_FBC_TDI1: TPG30.1 VRAM2.F10
SNN_FBC_TDO0: TPG34.1 VRAM1.N10
SNN_FBC_TDO1: TPG14.1 VRAM2.N10
SNN_FBC_TMS0: TPG12.1 VRAM1.F5
SNN_FBC_TMS1: TPG32.1 VRAM2.F5
SNN_FBD_RFU_G5: TPG58.1 VRAM7.G5
SNN_FBD_RFU_G5_1: TPG40.1 VRAM5.G5
SNN_FBD_RFU_M5: TPG57.1 VRAM7.M5
SNN_FBD_RFU_M5_1: TPG35.1 VRAM5.M5
SNN_FBD_TCK0: TPG56.1 VRAM7.N5
SNN_FBD_TCK1: TPG41.1 VRAM5.N5
SNN_FBD_TDI0: TPG53.1 VRAM7.F10
SNN_FBD_TDI1: TPG43.1 VRAM5.F10
SNN_FBD_TDO0: TPG54.1 VRAM7.N10
SNN_FBD_TDO1: TPG44.1 VRAM5.N10
SNN_FBD_TMS0: TPG55.1 VRAM7.F5
SNN_FBD_TMS1: TPG38.1 VRAM5.F5
SPDIF_OUT: CN17.11 R344.2
SPI1_IO2: R377.1 R378.2 R455.2 R456.1 U14.AY48
SPI1_IO3: R320.2 R382.1 R385.1 U14.BA46
SPI_CS0#_UR_ME: R453.1 U18.101
SPI_TPM_CS#: R921.1 R1017.1
SPI_TPM_CS#_L: R921.2 U14.AT40
SRTC_RST#: C476.1 Q41.3 R618.2 U14.BD46
STRAP0: RG158.2 RG159.1 UG1.BL3
STRAP1: RG153.1 RG154.2 UG1.BL4
STRAP2: RG173.1 RG174.2 UG1.BM4
STRAP3: RG171.1 RG172.2 UG1.BM5
STRAP4: RG161.2 RG162.1 UG1.BK5
STRAP5: RG145.1 RG146.2 UG1.BJ5
STRP1: R119.1 U4.6
STRP2: R120.1 U4.7
SURR_L_SPK: C385.2 U17.25
SURR_R_SPK: C399.2 U17.24
SUSACK#: R486.1 R617.1 U14.BE35
SUSB#: CN5.2 R480.2 U18.119
SUSC#: CN5.5 R541.2 U18.18
SUSCLK: CN16.50 R983.2
SUSCLK32: R983.1 R1011.1 U14.BE45
SUSD: PC168.1 PQ20.2 PQ21.3 PQ56.2 PR178.2
SUSON: PQ23.2 PR163.1 PR365.1 PR495.1 R231.1 U18.120
SUSWARN#: R486.2 R615.1 U14.BC37
SW1_4PH_A: PR68.1 PR73.1 PR98.1
SW2_4PH_A: PR30.1 PR31.1 PR96.1
SW3_4PH_A: PR18.1 PR24.1 PR99.1
SW4_4PH_A: PR19.1 PR20.2 PR97.1
SW_1PH: PR9.2 PR94.1
SYS_HWPG: D37.1(CATHODE) PR397.2 U18.124
SYS_PWROK: R1019.1 R1023.1 R1037.2 R1068.1 U42.4
SYS_PWROK_R: R1024.1 R1032.2 R1037.1 U14.AU3
SYS_SHDN#: PR103.2 PR381.2 PR403.2 PU28.6 Q5.3 U18.85
SYSTEM_AGND: PR369.1 PR378.2 PR379.2 PR391.2 PR398.2
TBT1_PCIE_RBIAS: R804.1 U7.N16
TBT2_DP_HPD: R784.1 U7.Y6
TBT_BATLOW#: R736.1 R738.2 U7.F2
TBT_CIO_PLUG_EVENT#: D18.1(CATHODE) R129.2 R134.1 R135.1 U7.W2
TBT_DP_HPD: CG66.1 R147.1 R807.2 R1004.1 RG32.2 U7.AA2
TBT_DPSNK0_DDC_CLK: R762.1 R763.1 U7.Y5
TBT_DPSNK0_DDC_DATA: R741.1 R752.1 U7.R4
TBT_DPSNK1_DDC_CLK: R772.1 R777.1 U7.Y8
TBT_DPSNK1_DDC_DATA: R740.1 R751.1 U7.N4
TBT_DPSRC_HPD: R127.1 U7.G1
TBT_EE_CLK: R154.2 U7.AB4 U9.6
TBT_EE_CS_N: R768.2 R775.1 U7.AC3 U9.1
TBT_EE_DI: R153.2 U7.AB3 U9.5
TBT_EE_DO: R150.2 R786.1 U7.AC4 U9.2
TBT_EE_WP_N: R785.2 U7.V1 U9.3(W\P\(IO2))
TBT_FORCE_PWR: R744.1 R759.1 R941.2 U7.H4
TBT_FORCE_PWR_R: R941.1 U14.BA20
TBT_HPD: R211.2 R807.1 U10.32
TBT_HTPLG_NL5: D18.2 R129.1 R1055.1
TBT_I2C_SCL: R132.2 U7.U2 U13.32
TBT_I2C_SCL1: Q74.1(S) R964.1 U13.27
TBT_I2C_SDA: R133.2 U7.U1 U13.33
TBT_I2C_SDA1: Q74.4 R942.1 U13.28
TBT_JTAG_TCK: R753.2 U7.T4
TBT_JTAG_TDI: R756.2 U7.Y4
TBT_JTAG_TDO: R755.2 U7.W4
TBT_JTAG_TMS: R754.2 U7.V4
TBT_MAINON: R137.1 R138.1 R139.2 U7.D2
TBT_MRESET: R370.2 R375.2 R376.2 U18.125
TBT_PLTRST#: R160.2 R162.1 U6.4 U7.L4
TBT_RBIAS: R765.1 U7.J6
TBT_RESET_C: R352.1 R361.2
TBT_RESET_N: R361.1 R370.1 R380.1 R742.1 U7.F4
TBT_RSENSE: R765.2 U7.H6
TBT_SPI_HOLD#: R822.2 U9.7
TBT_SRC0_CFG1: R148.1 U7.AA1
TBT_SRC0_DDC_CLK: R144.1 R745.2 U7.Y2
TBT_SRC0_DDC_DATA: R143.1 R149.2 U7.Y1
TBT_TEST_EN: R757.2 U7.E1
TBT_TEST_PWRGD: R774.2 U7.AB5
TBT_WAKE#_EC: R500.1 R737.1
TBT_XTL25_IN: C224.2 U7.D22 Y1.1
TBT_XTL25_OUT: C223.2 U7.D23 Y1.3
TBTA_AUX_N: C758.1 U7.W15
TBTA_AUX_P: C751.1 U7.Y15
TBTA_CA2HD_0_N: CN3.B10 D97.2 U7.A21
TBTA_CA2HD_0_P: CN3.B11 D98.2 U7.B21
TBTA_CA2HD_1_N: CN3.A10 D25.2 U7.B15
TBTA_CA2HD_1_P: CN3.A11 D24.2 U7.A15
TBTA_CC1: C807.2 CN3.A5 D28.2 U13.24
TBTA_CC2: C803.2 CN3.B5 D23.2 U13.26
TBTA_DPSRC_AUX_N: C758.2 R803.2 U5.17 U5.20
TBTA_DPSRC_AUX_P: C751.2 R799.2 U5.18 U5.19
TBTA_HD2CA_0_N: C185.1 CN3.A3 D29.2
TBTA_HD2CA_0_P: C190.1 CN3.A2 D30.2
TBTA_HD2CA_1_N: C755.1 CN3.B3 D96.2
TBTA_HD2CA_1_P: C748.1 CN3.B2 D95.2
TBTA_HPD: R749.1 U7.M4 U13.30
TBTA_I2C_INT: R760.1 U7.J4 U13.34
TBTA_I2C_IRQ2Z_EC: R227.2 R843.1 U13.29
TBTA_LSRX: R158.1 U5.6 U5.9 U7.A4
TBTA_LSTX: R157.1 U5.7 U5.8 U7.A5
TBTA_SBU1: CN3.A8 D21.2 U5.1
TBTA_SBU2: CN3.B8 D22.2 U5.2
TBTA_TX0_N: C185.2 U7.B19
TBTA_TX0_P: C190.2 U7.A19
TBTA_TX1_N: C755.2 U7.B17
TBTA_TX1_P: C748.2 U7.A17
TBTA_USB2_D_N: R206.1 U14.M6
TBTA_USB2_D_N_T: CN3.A7 CN3.B7 D26.2 R206.2
TBTA_USB2_D_P: R217.1 U14.N8
TBTA_USB2_D_P_T: CN3.A6 CN3.B6 D27.2 R217.2
TBTA_VBUS_L: C744.1 C772.1 C773.1 C774.1 C775.1 CN3.A4 CN3.A9 CN3.B4 CN3.B9(VBUS#4) D94.1 U13.13
TBTB_HPD: R128.1 U7.G2
TBTB_I2C_INT: R136.1 TP22.1 U7.E2
TBTB_LSRX: R773.1 U7.B5
TBTB_LSTX: R769.1 U7.B4
TEMP_MBAT#: PR184.1 PR503.1 PR504.2 U18.73
TEMP_MBAT#_CONN: PJ22.6 PR504.1
THER_ALERT#: RG25.1 RG30.2 UG1.BJ3
THERMDN: TPG1.1 UG1.BJ1
THERMDP: TPG2.1 UG1.BJ2
THERMTRIP#: Q5.1(EMITTER) R46.1 R51.2 U3.J31
TI_TBT_EE_CLK: R154.1 U12.6 U13.38
TI_TBT_EE_CS_N: R768.1 R857.1 U12.1 U13.39
TI_TBT_EE_DI: R153.1 U12.5 U13.37
TI_TBT_EE_DO: R150.1 R847.1 U12.2 U13.36
TI_TBT_EE_WP_N: R866.2 U12.3(W\P\(IO2))
TI_TBT_SPI_HOLD#: R851.2 U12.7
TMU_CLK_OUT: R131.1 U7.V2
TP_LED_CTL_W: D75.1 Q40.2 R593.2 U4.1
TP_LED_EN_W: CN19.27 D71.1 Q40.3
TP_LED_PWR: C896.1 C901.1 CN19.28 D109.1 Q76.3
TP_LED_PWR_CTL: Q76.2 R989.2 U4.32
TPCLK: C443.2 CN19.6 D54.1 R482.2 U18.89
TPD_EN: CN19.11 D110.1 R421.1
TPD_INT#: R267.1 R284.1 R597.1
TPD_INT#_PCH: R598.1 R1110.2 U14.BA24
TPD_INT#_R: CN19.10 D55.1 Q42.1(S) R572.1 R584.2
TPDATA: C430.2 CN19.7 D53.1 R465.2 U18.90
TPEV_PEG_VIEW_2: R190.2 R197.2 U3.E3
TPM_MISO: R1016.2 R1044.2 U44.24
TPM_SCS#: R1017.2 R1063.2 U44.20
TPM_VDD: C915.1 C916.1 C939.1 C940.1 C941.1 R1140.2 R1145.2 U44.8 U44.22
TRI_EN#: PQ55.2 PR551.1 U18.99
TS_SPI1_CLK: R489.1 TP57.1
TS_SPI1_CLK_R: R489.2 U14.BE19
TS_SPI1_CS#: R551.1 TP53.1
TS_SPI1_CS#_R: R551.2 U14.BF19
TS_SPI1_MISO: R550.1 TP55.1
TS_SPI1_MISO_R: R553.2 U14.BE18
TS_SPI1_MOSI: R553.1 TP54.1
TS_SPI1_MOSI_R: R550.2 U14.BF18
TS_VREF: TPG67.1 UG1.BF12
TSENSE_4PH_A: PC66.2 PR72.1 PU2.14
TX0_HDMI+: CN1.7 R636.2 U33.1 U33.10(NC#4)
TX0_HDMI-: CN1.9 R635.2 U33.2 U33.9
TX1_HDMI+: CN1.4 R638.2 U37.4 U37.7
TX1_HDMI-: CN1.6 R637.2 U37.5 U37.6
TX2_HDMI+: CN1.1 R644.2 U37.1 U37.10(NC#4)
TX2_HDMI-: CN1.3 R639.2 U37.2 U37.9
TXC_HDMI+: C501.2 CN1.10 R634.2 U33.4 U33.7
TXC_HDMI-: C501.1 CN1.12 R632.2 U33.5 U33.6
UART2_CTS#: R1048.2 U14.AV21
UART2_RTS#: R1055.2 R1099.1 U14.AW21
UART2_RXD: R1008.2 R1056.2 U14.BD20
UART2_TXD: R484.2 U14.BE20
UART_WAKE_N: CN16.20 R620.2
ULT_EDP_HPD_Q: QG8.2 RG33.1 RG34.1
USB2_COMP: R214.1 U14.F4
USB3_RT_0V9: C809.1 C812.2 C839.2 C840.2 L5.2 L8.2 U15.5 U15.10 U15.28
USB3_RT_DCDC_GND: C247.1 C248.1 C249.1 C806.2 C809.2 C812.1 R853.2 U15.7
USB3_RT_DCI_CLK: TP35.1 U15.32
USB3_RT_DCI_DAT: TP34.1 U15.31
USB3_RT_I2C_ADR_SEL0: R291.1 R883.1 U15.23
USB3_RT_I2C_ADR_SEL1: R865.1 R876.1 U15.22
USB3_RT_POWER_EN: R347.1 R359.2 R625.1 U15.4
USB3_RT_PU_PWR: R359.1 R876.2 R883.2 R898.2 R915.2
USB3_RT_RX1N: C242.2 U15.11
USB3_RT_RX1P: C241.2 U15.12
USB3_RT_SCL: R304.1 U15.24
USB3_RT_SDA: R349.1 U15.26
USB3_RT_SSRXN: C834.1 U15.34
USB3_RT_SSRXP: C835.1 U15.35
USB3_RT_SSTXN: C857.1 U15.38
USB3_RT_SSTXP: C856.1 U15.39
USB3_RT_TEST_29: TP32.1 U15.29
USB3_RT_TEST_30: TP33.1 U15.30
USB3_RT_TEST_EN: TP31.1 U15.27
USB3_RT_TEST_R: TP29.1 U15.18
USB3_RT_TX1N: C239.2 U15.15
USB3_RT_TX1P: C240.2 U15.14
USB3_RT_VIN: C247.2 C248.2 C249.2 C806.1 L33.1 U15.9
USB3_RT_VX: L5.1 U15.8
USB3_RT_XTAL_I: C237.2 R247.1 U15.20 Y2.1
USB3_RT_XTAL_O: R277.2 U15.21(XTAL_O)
USB3_RT_XTAL_O_R: C260.2 R247.2 R277.1 Y2.3
USB3O2_MUX_AUXN: TP47.1 U16.17
USB3O2_MUX_AUXP: TP45.1 U16.16
USB3O2_MUX_AVDD33: C337.1 C342.2 C351.2 L11.1 U16.13 U16.24
USB3O2_MUX_CABLE_DET: R386.2 R387.1 U16.14
USB3O2_MUX_CC1: TP44.1 U16.21
USB3O2_MUX_CC2: TP43.1 U16.20
USB3O2_MUX_CC_CAP: TP42.1 U16.22
USB3O2_MUX_CFG_SCL: R269.1 U16.39
USB3O2_MUX_CFG_SDA: R278.1 U16.38
USB3O2_MUX_DP_LN_0N: TP86.1 U16.2
USB3O2_MUX_DP_LN_0P: TP82.1 U16.1
USB3O2_MUX_DP_LN_3N: TP92.1 U16.4
USB3O2_MUX_DP_LN_3P: TP85.1 U16.3
USB3O2_MUX_DRP_EN: R890.2 R897.1 U16.28
USB3O2_MUX_HPD: TP78.1 U16.37
USB3O2_MUX_I2C_ADR0: R249.2 R842.2 U16.48
USB3O2_MUX_I2C_ADR1: R250.2 R841.2 U16.47
USB3O2_MUX_INTP_OUT: R253.2 U16.41
USB3O2_MUX_NC_23: TP37.1 U16.23
USB3O2_MUX_PU_PWR: R285.1 R386.1 R839.2 R840.2 R841.1 R842.1 R897.2 R904.1
USB3O2_MUX_PWR_EN: C487.1 D77.1(CATHODE) R610.2 R903.1 R904.2 U16.27
USB3O2_MUX_RESET_N: C493.1 D79.2 R285.2 R299.1 R628.1 U16.33
USB3O2_MUX_SBU1: TP41.1 U16.19
USB3O2_MUX_SBU2: TP36.1 U16.18
USB3O2_MUX_SSRX1N: TP90.1 U16.32
USB3O2_MUX_SSRX1P: TP89.1 U16.31
USB3O2_MUX_SSRX2N: TP79.1 U16.35
USB3O2_MUX_SSRX2P: TP83.1 U16.36
USB3O2_MUX_SSRX_N: TP93.1 U16.5
USB3O2_MUX_SSRX_P: TP96.1 U16.6
USB3O2_MUX_SSRXN: C242.1 U16.8
USB3O2_MUX_SSRXP: C241.1 U16.7
USB3O2_MUX_SSTX1N: L6.1 R327.1 U16.26
USB3O2_MUX_SSTX1P: L6.4 R342.1 U16.25
USB3O2_MUX_SSTX2N: L34.1 R899.1 U16.29
USB3O2_MUX_SSTX2P: L34.4 R892.1 U16.30
USB3O2_MUX_SSTXN: C239.1 U16.10
USB3O2_MUX_SSTXP: C240.1 U16.9
USB3O2_MUX_TEST_EN: TP84.1 U16.34
USB3O2_MUX_USB_ID: R252.1 U16.42
USB3O2_MUX_VBUS_CTRL: R251.2 U16.43
USB3O2_MUX_VBUS_DIV6: TP40.1 U16.15
USB3O2_MUX_VCONN1_EN: TP80.1 U16.45
USB3O2_MUX_VCONN2_EN: TP81.1 U16.44(VCONN2_EN)
USB30_RX1+: C397.1 U14.C11
USB30_RX1+_C: C397.2 U21.8
USB30_RX1+_R: CN17.18 R422.2
USB30_RX1+_RT: R422.1 U21.39
USB30_RX1-: C382.1 U14.D11
USB30_RX1-_C: C382.2 U21.9
USB30_RX1-_R: CN17.19 R413.2
USB30_RX1-_RT: R413.1 U21.38
USB30_RX2+: C350.1 U14.C9
USB30_RX2+_C: C350.2 U21.17
USB30_RX2+_R: CN17.27 R381.2
USB30_RX2+_RT: R381.1 U21.30
USB30_RX2-: C339.1 U14.B9
USB30_RX2-_C: C339.2 U21.18
USB30_RX2-_R: CN17.28 R371.2
USB30_RX2-_RT: R371.1 U21.29
USB30_RX3+: C490.1 U14.C10
USB30_RX3+_R: CN7.6 D80.1 R621.2
USB30_RX3+_RTI: R621.1 U30.21
USB30_RX3+_RTO: C490.2 U30.8
USB30_RX3-: C494.1 U14.B10
USB30_RX3-_R: CN7.5 D81.1 R627.2
USB30_RX3-_RTI: R627.1 U30.20
USB30_RX3-_RTO: C494.2 U30.9
USB30_RX4+: C483.2 U14.J15
USB30_RX4-: C482.2 U14.K16
USB30_TX1+: C423.1 U14.F7
USB30_TX1+_C: C423.2 U21.2
USB30_TX1+_R: CN17.15 R444.2
USB30_TX1+_RT: R444.1 U21.45
USB30_TX1-: C406.1 U14.F9
USB30_TX1-_C: C406.2 U21.3
USB30_TX1-_R: CN17.16 R433.2
USB30_TX1-_RT: R433.1 U21.44
USB30_TX2+: C364.1 U14.D4
USB30_TX2+_C: C364.2 U21.11
USB30_TX2+_R: CN17.24 R402.2
USB30_TX2+_RT: R402.1 U21.36
USB30_TX2-: C357.1 U14.C3
USB30_TX2-_C: C357.2 U21.12
USB30_TX2-_R: CN17.25 R390.2
USB30_TX2-_RT: R390.1 U21.35
USB30_TX3+: C475.1 U14.G12
USB30_TX3+_C: C479.2 R607.1
USB30_TX3+_R: CN7.9 D76.1 R607.2
USB30_TX3+_RTI: C475.2 U30.2
USB30_TX3+_RTO: C479.1 U30.27
USB30_TX3-: C478.1 U14.F11
USB30_TX3-_C: C486.2 R613.1
USB30_TX3-_R: CN7.8 D78.1 R613.2
USB30_TX3-_RTI: C478.2 U30.3
USB30_TX3-_RTO: C486.1 U30.26
USB30_TX4+: C481.2 U14.C14
USB30_TX4-: C480.2 U14.B14
USB_AUX_SW_V1: TP115.1 U23.3
USB_BC_ON: U8.4 U11.4 U18.97 U26.4
USB_CC1: C270.2 CN4.A5 D39.2 R505.1 R527.1
USB_CC2: C250.2 CN4.B5 D34.2 R445.1 R1060.1
USB_CHARGE_ON: R161.2 R194.2 R1080.1 U8.5 U11.5 U18.96 U26.5
USB_CLT1: U8.6 U11.6 U18.79 U26.6
USB_DSCH_CTL: PR130.2 R395.2 R466.2 U23.15
USB_FET_EN_Q: PC329.1 PQ12.2 PQ12.4 PR470.1 PR471.2
USB_FET_EN_R: PQ43.3 PR471.1
USB_I2C_SCL: PR92.2 Q47.1(S) Q63.6 R435.2 R573.2 R959.2 R1109.1 R1133.2 RG134.2
USB_I2C_SCL_3V3OR1V8: Q47.6 R269.2 R304.2 R485.2 R529.2 R1109.2
USB_I2C_SDA: PR95.2 Q47.4 Q63.3 R448.2 R564.2 R975.2 R1114.1 R1134.2 RG129.2
USB_I2C_SDA_3V3OR1V8: Q47.3 R278.2 R349.2 R507.2 R583.2 R1114.2
USB_OC0#: C799.1 EC8.2 R844.2 U14.AH36 U26.13
USB_OC1#: C816.1 R873.2 U8.13 U14.AL40
USB_OC2#: C825.1 R885.2 U11.13 U14.AJ44
USB_OC3#: R882.2 U14.AL41
USB_OC4#: R910.2 U14.AV47
USB_OC5#: R830.2 U14.AR35
USB_OC6#: R828.2 U14.AR37
USB_OC7#: R905.2 U14.AV43
USB_RBIAS: RG137.1 UG1.BA6
USB_RESET: Q37.2 R522.1 R556.1 R1135.2 U27.4
USB_RESET_BUFF: R608.2 R614.2 R625.2 R629.2 R630.2 U29.4 U32.4(Y)
USB_RESET_BUFF_D: D77.2 R608.1
USB_RESET_BUFF_R: D79.1(CATHODE) R614.1 R628.2
USB_RESET_OPTION: R555.1 R556.2 U29.1 U29.2 U32.1 U32.2
USB_RESET_R: Q37.3 R424.2 R987.1
USB_TERMP0: RG157.1 UG1.BG6
USB_TERMP1: RG165.1 UG1.BH6
USB_VBUS_Q: PC329.2 PQ12.1 PQ12.3(S) PR470.2
USBC_PD_ADD: PR84.1 PR107.2 PU7.4
USBC_VBUS: C788.1 C794.2 C795.2 C796.2 CN4.A4 CN4.A9 CN4.B4 CN4.B9(VBUS_4) D99.1 PC106.1 PC111.1 PQ12.5 PR125.1 R1136.1
USBP1+: U8.3 U14.J2
USBP1+_C: CN17.31 U8.10
USBP1-: U8.2 U14.J3
USBP1-_C: CN17.30 U8.11
USBP2+: U11.3 U14.N15
USBP2+_C: CN17.22 U11.10
USBP2-: U11.2 U14.N13
USBP2-_C: CN17.21 U11.11
USBP3+: U14.K3 U26.3
USBP3+_C: R1112.1 U26.10
USBP3+_C_R: CN7.3 D112.1 R1112.2
USBP3-: U14.K4 U26.2
USBP3-_C: R1113.1 U26.11
USBP3-_C_R: CN7.2 D112.2(K2) R1113.2
USBP4+: TP71.1 U14.L9
USBP4-: TP75.1 U14.M10
USBP5+: TP73.1 U14.L2
USBP5-: TP74.1 U14.M1
USBP6+: R66.1 U14.K6
USBP6+_C: CN10.28 D11.1 R66.2
USBP6-: R64.1 U14.K7
USBP6-_C: CN10.29 D10.1 R64.2
USBP7+: R980.1 U14.L3
USBP7+_C: CN10.22 TP62.1
USBP7+_R: CN19.18 D107.1 R980.2
USBP7-: R993.1 U14.L4
USBP7-_C: CN10.23 TP61.1
USBP7-_R: CN19.17 D108.1 R993.2
USBP8+: TP70.1 U14.G5
USBP8-: TP69.1 U14.G4
USBP14+: CN16.3 U14.F6
USBP14-: CN16.5 U14.E5
VA: PC48.1 PC71.1 PC72.1 PC301.1 PC306.2 PC307.1 PD1.1 PD6.1 PJ1.5 PJ1.6 PQ5.5 PR499.1 PR500.1
VGA_XTALIN: CG80.1 UG1.BL6 YG1.1
VGA_XTALOUT: RG44.2 YG1.3
VGA_XTALOUT_R: RG41.1 UG1.BM6
VGPU_CORE_SENSE: PR513.2 UG1.BK45
VGT_VCCSENSE: TP1.1 U3.AH38
VGT_VSSSENSE: TP2.1 U3.AH37
VL: PC273.1 PU28.13(VREG5)
VMA_CLK0: UG1.AG45 VRAM6.J10
VMA_CLK0#: UG1.AG46 VRAM6.K10
VMA_CLK1: UG1.AK46 VRAM8.J10
VMA_CLK1#: UG1.AK45 VRAM8.K10
VMA_DQ0: UG1.U51 VRAM6.G2
VMA_DQ1: UG1.U48 VRAM6.B3
VMA_DQ2: UG1.U50 VRAM6.F2
VMA_DQ3: UG1.U49 VRAM6.E3
VMA_DQ4: UG1.R51 VRAM6.B4
VMA_DQ5: UG1.R50 VRAM6.B2
VMA_DQ6: UG1.R47 VRAM6.E2
VMA_DQ7: UG1.U46 VRAM6.A3
VMA_DQ8: UG1.V46 VRAM6.B11
VMA_DQ9: UG1.Y45 VRAM6.G13
VMA_DQ10: UG1.Y47 VRAM6.E13
VMA_DQ11: UG1.Y46 VRAM6.F13
VMA_DQ12: UG1.V50 VRAM6.E12
VMA_DQ13: UG1.V47 VRAM6.B12
VMA_DQ14: UG1.U52 VRAM6.B13
VMA_DQ15: UG1.V51 VRAM6.A12
VMA_DQ16: UG1.AJ44 VRAM6.P13
VMA_DQ17: UG1.AG48 VRAM6.U13
VMA_DQ18: UG1.AJ45 VRAM6.M13
VMA_DQ19: UG1.AG49 VRAM6.N13
VMA_DQ20: UG1.AF46 VRAM6.U12
VMA_DQ21: UG1.AF47 VRAM6.P12
VMA_DQ22: UG1.AF48 VRAM6.V12
VMA_DQ23: UG1.AD47 VRAM6.U11
VMA_DQ24: UG1.AD49 VRAM6.N2
VMA_DQ25: UG1.AD48 VRAM6.P3
VMA_DQ26: UG1.AC46 VRAM6.M2
VMA_DQ27: UG1.AC47 VRAM6.P2
VMA_DQ28: UG1.AA47 VRAM6.U3
VMA_DQ29: UG1.AA46 VRAM6.V3
VMA_DQ30: UG1.AA45 VRAM6.U4
VMA_DQ31: UG1.Y44 VRAM6.U2
VMA_DQ32: UG1.AW51 VRAM8.B3
VMA_DQ33: UG1.BA52 VRAM8.E2
VMA_DQ34: UG1.AW50 VRAM8.E3
VMA_DQ35: UG1.BA51 VRAM8.A3
VMA_DQ36: UG1.BA50 VRAM8.G2
VMA_DQ37: UG1.BB50 VRAM8.F2
VMA_DQ38: UG1.BA49 VRAM8.B2
VMA_DQ39: UG1.AW49 VRAM8.B4
VMA_DQ40: UG1.AV48 VRAM8.E13
VMA_DQ41: UG1.AT49 VRAM8.F13
VMA_DQ42: UG1.AT47 VRAM8.B13
VMA_DQ43: UG1.AT48 VRAM8.B11
VMA_DQ44: UG1.AT46 VRAM8.B12
VMA_DQ45: UG1.AV51 VRAM8.E12
VMA_DQ46: UG1.AV52 VRAM8.A12
VMA_DQ47: UG1.AV49 VRAM8.G13
VMA_DQ48: UG1.AJ48 VRAM8.U13
VMA_DQ49: UG1.AJ46 VRAM8.U11
VMA_DQ50: UG1.AJ47 VRAM8.V12
VMA_DQ51: UG1.AK49 VRAM8.P13
VMA_DQ52: UG1.AM47 VRAM8.P12
VMA_DQ53: UG1.AM46 VRAM8.U12
VMA_DQ54: UG1.AN48 VRAM8.N13
VMA_DQ55: UG1.AN49 VRAM8.M13
VMA_DQ56: UG1.AM44 VRAM8.V3
VMA_DQ57: UG1.AM45 VRAM8.U4
VMA_DQ58: UG1.AN45 VRAM8.U2
VMA_DQ59: UG1.AN46 VRAM8.U3
VMA_DQ60: UG1.AR48 VRAM8.P2
VMA_DQ61: UG1.AN47 VRAM8.P3
VMA_DQ62: UG1.AR47 VRAM8.M2
VMA_DQ63: UG1.AR46 VRAM8.N2
VMA_WCK01: UG1.U45 VRAM6.D4
VMA_WCK01#: UG1.U44 VRAM6.D5
VMA_WCK23: UG1.AC45 VRAM6.R11
VMA_WCK23#: UG1.AC44 VRAM6.R10
VMA_WCK45: UG1.AV47 VRAM8.D4
VMA_WCK45#: UG1.AV46 VRAM8.D5
VMA_WCK67: UG1.AR45 VRAM8.R11
VMA_WCK67#: UG1.AR44 VRAM8.R10
VMA_WCKB01: UG1.V45 VRAM6.D11
VMA_WCKB01#: UG1.V44 VRAM6.D10
VMA_WCKB23: UG1.AD46 VRAM6.R4
VMA_WCKB23#: UG1.AD45 VRAM6.R5
VMA_WCKB45: UG1.AW48 VRAM8.D11
VMA_WCKB45#: UG1.AW47 VRAM8.D10
VMA_WCKB67: UG1.AT45 VRAM8.R4
VMA_WCKB67#: UG1.AT44 VRAM8.R5
VMB_CLK0: UG1.H42 VRAM3.J10
VMB_CLK0#: UG1.G42 VRAM3.K10
VMB_CLK1: UG1.F47 VRAM4.J10
VMB_CLK1#: UG1.E47 VRAM4.K10
VMB_DQ0: UG1.H32 VRAM3.F2
VMB_DQ1: UG1.D32 VRAM3.B4
VMB_DQ2: UG1.A33 VRAM3.B3
VMB_DQ3: UG1.B32 VRAM3.E2
VMB_DQ4: UG1.E32 VRAM3.B2
VMB_DQ5: UG1.G32 VRAM3.E3
VMB_DQ6: UG1.J30 VRAM3.A3
VMB_DQ7: UG1.F32 VRAM3.G2
VMB_DQ8: UG1.H36 VRAM3.E13
VMB_DQ9: UG1.G36 VRAM3.F13
VMB_DQ10: UG1.J36 VRAM3.G13
VMB_DQ11: UG1.F36 VRAM3.B13
VMB_DQ12: UG1.F33 VRAM3.B12
VMB_DQ13: UG1.D33 VRAM3.B11
VMB_DQ14: UG1.J32 VRAM3.A12
VMB_DQ15: UG1.G33 VRAM3.E12
VMB_DQ16: UG1.E45 VRAM3.V12
VMB_DQ17: UG1.D45 VRAM3.U13
VMB_DQ18: UG1.F45 VRAM3.P12
VMB_DQ19: UG1.G45 VRAM3.M13
VMB_DQ20: UG1.D42 VRAM3.U12
VMB_DQ21: UG1.E42 VRAM3.U11
VMB_DQ22: UG1.F42 VRAM3.P13
VMB_DQ23: UG1.H41 VRAM3.N13
VMB_DQ24: UG1.E41 VRAM3.U4
VMB_DQ25: UG1.F39 VRAM3.P3
VMB_DQ26: UG1.E39 VRAM3.P2
VMB_DQ27: UG1.D39 VRAM3.N2
VMB_DQ28: UG1.F38 VRAM3.M2
VMB_DQ29: UG1.E38 VRAM3.U3
VMB_DQ30: UG1.D36 VRAM3.V3
VMB_DQ31: UG1.E36 VRAM3.U2
VMB_DQ32: UG1.M50 VRAM4.B3
VMB_DQ33: UG1.P48 VRAM4.A3
VMB_DQ34: UG1.M51 VRAM4.E2
VMB_DQ35: UG1.M49 VRAM4.B4
VMB_DQ36: UG1.P47 VRAM4.B2
VMB_DQ37: UG1.P52 VRAM4.F2
VMB_DQ38: UG1.R46 VRAM4.G2
VMB_DQ39: UG1.P46 VRAM4.E3
VMB_DQ40: UG1.L50 VRAM4.B12
VMB_DQ41: UG1.L51 VRAM4.E12
VMB_DQ42: UG1.L52 VRAM4.B11
VMB_DQ43: UG1.L49 VRAM4.A12
VMB_DQ44: UG1.M46 VRAM4.E13
VMB_DQ45: UG1.L47 VRAM4.B13
VMB_DQ46: UG1.M48 VRAM4.F13
VMB_DQ47: UG1.M47 VRAM4.G13
VMB_DQ48: UG1.D48 VRAM4.V12
VMB_DQ49: UG1.C50 VRAM4.P12
VMB_DQ50: UG1.C48 VRAM4.U13
VMB_DQ51: UG1.C49 VRAM4.P13
VMB_DQ52: UG1.E49 VRAM4.U12
VMB_DQ53: UG1.E50 VRAM4.N13
VMB_DQ54: UG1.F49 VRAM4.M13
VMB_DQ55: UG1.F48 VRAM4.U11
VMB_DQ56: UG1.F50 VRAM4.P3
VMB_DQ57: UG1.D52 VRAM4.U3
VMB_DQ58: UG1.J50 VRAM4.M2
VMB_DQ59: UG1.H48 VRAM4.V3
VMB_DQ60: UG1.H51 VRAM4.N2
VMB_DQ61: UG1.J51 VRAM4.P2
VMB_DQ62: UG1.H49 VRAM4.U4
VMB_DQ63: UG1.H52 VRAM4.U2
VMB_WCK01: UG1.J33 VRAM3.D4
VMB_WCK01#: UG1.H33 VRAM3.D5
VMB_WCK23: UG1.J39 VRAM3.R11
VMB_WCK23#: UG1.H39 VRAM3.R10
VMB_WCK45: UG1.L46 VRAM4.D4
VMB_WCK45#: UG1.L45 VRAM4.D5
VMB_WCK67: UG1.H47 VRAM4.R11
VMB_WCK67#: UG1.H46 VRAM4.R10
VMB_WCKB01: UG1.G35 VRAM3.D11
VMB_WCKB01#: UG1.H35 VRAM3.D10
VMB_WCKB23: UG1.F41 VRAM3.R4
VMB_WCKB23#: UG1.G41 VRAM3.R5
VMB_WCKB45: UG1.M44 VRAM4.D11
VMB_WCKB45#: UG1.M45 VRAM4.D10
VMB_WCKB67: UG1.J47 VRAM4.R4
VMB_WCKB67#: UG1.J46 VRAM4.R5
VMC_CLK0: UG1.G15 VRAM1.J10
VMC_CLK0#: UG1.F15 VRAM1.K10
VMC_CLK1: UG1.H21 VRAM2.J10
VMC_CLK1#: UG1.J21 VRAM2.K10
VMC_DQ0: UG1.C6 VRAM1.F2
VMC_DQ1: UG1.D6 VRAM1.B4
VMC_DQ2: UG1.A6 VRAM1.G2
VMC_DQ3: UG1.B6 VRAM1.E2
VMC_DQ4: UG1.B4 VRAM1.B2
VMC_DQ5: UG1.A4 VRAM1.B3
VMC_DQ6: UG1.B3 VRAM1.E3
VMC_DQ7: UG1.C4 VRAM1.A3
VMC_DQ8: UG1.D9 VRAM1.B12
VMC_DQ9: UG1.C9 VRAM1.E13
VMC_DQ10: UG1.E9 VRAM1.G13
VMC_DQ11: UG1.B9 VRAM1.F13
VMC_DQ12: UG1.B8 VRAM1.B13
VMC_DQ13: UG1.A8 VRAM1.E12
VMC_DQ14: UG1.F6 VRAM1.B11
VMC_DQ15: UG1.E6 VRAM1.A12
VMC_DQ16: UG1.F18 VRAM1.M13
VMC_DQ17: UG1.G18 VRAM1.N13
VMC_DQ18: UG1.E18 VRAM1.P12
VMC_DQ19: UG1.H18 VRAM1.P13
VMC_DQ20: UG1.D15 VRAM1.V12
VMC_DQ21: UG1.E15 VRAM1.U13
VMC_DQ22: UG1.G17 VRAM1.U12
VMC_DQ23: UG1.H17 VRAM1.U11
VMC_DQ24: UG1.J15 VRAM1.P2
VMC_DQ25: UG1.H15 VRAM1.U4
VMC_DQ26: UG1.E14 VRAM1.P3
VMC_DQ27: UG1.F14 VRAM1.M2
VMC_DQ28: UG1.H11 VRAM1.U3
VMC_DQ29: UG1.G11 VRAM1.V3
VMC_DQ30: UG1.F11 VRAM1.N2
VMC_DQ31: UG1.E11 VRAM1.U2
VMC_DQ32: UG1.J29 VRAM2.E2
VMC_DQ33: UG1.F30 VRAM2.F2
VMC_DQ34: UG1.H29 VRAM2.A3
VMC_DQ35: UG1.G30 VRAM2.E3
VMC_DQ36: UG1.B30 VRAM2.B3
VMC_DQ37: UG1.A30 VRAM2.G2
VMC_DQ38: UG1.H30 VRAM2.B4
VMC_DQ39: UG1.C30 VRAM2.B2
VMC_DQ40: UG1.D27 VRAM2.B11
VMC_DQ41: UG1.J26 VRAM2.G13
VMC_DQ42: UG1.F27 VRAM2.B13
VMC_DQ43: UG1.G27 VRAM2.A12
VMC_DQ44: UG1.C27 VRAM2.E12
VMC_DQ45: UG1.B27 VRAM2.E13
VMC_DQ46: UG1.A27 VRAM2.B12
VMC_DQ47: UG1.G29 VRAM2.F13
VMC_DQ48: UG1.H20 VRAM2.U12
VMC_DQ49: UG1.D18 VRAM2.U13
VMC_DQ50: UG1.G20 VRAM2.V12
VMC_DQ51: UG1.E20 VRAM2.U11
VMC_DQ52: UG1.F23 VRAM2.P13
VMC_DQ53: UG1.E21 VRAM2.P12
VMC_DQ54: UG1.D21 VRAM2.M13
VMC_DQ55: UG1.E23 VRAM2.N13
VMC_DQ56: UG1.G24 VRAM2.U4
VMC_DQ57: UG1.H26 VRAM2.V3
VMC_DQ58: UG1.F24 VRAM2.U3
VMC_DQ59: UG1.G26 VRAM2.U2
VMC_DQ60: UG1.F26 VRAM2.P3
VMC_DQ61: UG1.D26 VRAM2.P2
VMC_DQ62: UG1.B26 VRAM2.N2
VMC_DQ63: UG1.C26 VRAM2.M2
VMC_WCK01: UG1.F8 VRAM1.D4
VMC_WCK01#: UG1.G8 VRAM1.D5
VMC_WCK23: UG1.H12 VRAM1.R11
VMC_WCK23#: UG1.G12 VRAM1.R10
VMC_WCK45: UG1.J27 VRAM2.D4
VMC_WCK45#: UG1.H27 VRAM2.D5
VMC_WCK67: UG1.G23 VRAM2.R11
VMC_WCK67#: UG1.H23 VRAM2.R10
VMC_WCKB01: UG1.G9 VRAM1.D11
VMC_WCKB01#: UG1.F9 VRAM1.D10
VMC_WCKB23: UG1.G14 VRAM1.R4
VMC_WCKB23#: UG1.H14 VRAM1.R5
VMC_WCKB45: UG1.E29 VRAM2.D11
VMC_WCKB45#: UG1.F29 VRAM2.D10
VMC_WCKB67: UG1.H24 VRAM2.R4
VMC_WCKB67#: UG1.J24 VRAM2.R5
VMD_CLK0: UG1.Y8 VRAM7.J10
VMD_CLK0#: UG1.Y7 VRAM7.K10
VMD_CLK1: UG1.R8 VRAM5.J10
VMD_CLK1#: UG1.R7 VRAM5.K10
VMD_DQ0: UG1.AK8 VRAM7.B3
VMD_DQ1: UG1.AK4 VRAM7.A3
VMD_DQ2: UG1.AK2 VRAM7.F2
VMD_DQ3: UG1.AK3 VRAM7.B2
VMD_DQ4: UG1.AK5 VRAM7.G2
VMD_DQ5: UG1.AK6 VRAM7.B4
