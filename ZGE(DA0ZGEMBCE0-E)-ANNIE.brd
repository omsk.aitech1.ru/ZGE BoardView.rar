# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_EDP on BOTTOM (solid shape): 183.28,92.12 183.28,91.72 183.15,91.58 181.12,91.58 180.94,91.76 180.39,91.76 180.36,91.79 180.36,91.8 179.55,91.8 179.51,91.81 179.5,91.85 179.5,91.95 179.51,91.98 179.55,92 180.36,92 180.36,92.01 180.39,92.04 180.99,92.04 181.07,91.96 181.77,91.96 182.06,92.25 183.15,92.25
+3V_EDP on BOTTOM (solid shape): 173.37,96.28 173.37,95.01 173.6,94.78 174.16,94.78 174.41,94.53 174.41,93.92 174.29,93.8 173.5,93.8 173.27,94.02 173.27,94.33 172.97,94.63 172.59,94.63 172.15,94.2 170.71,94.2 170.45,93.95 170.45,93.64 170.35,93.54 170.01,93.54 169.93,93.62 169.93,94.25 170.87,95.19 172.26,95.19 172.87,95.8 172.87,96.33 172.94,96.41 173.25,96.41
+3V_EDP on BOTTOM (solid shape): 181.25,97.92 181.25,96.28 181.81,95.72 181.81,94.04 181.54,93.77 180.39,93.77 180.36,93.8 179.57,93.8 179.5,93.87 179.5,94.02 180.03,94.56 180.03,94.83 180.18,94.99 180.18,98.02 180.22,98.09 180.3,98.12 180.35,98.11 180.5,98.14 180.63,98.23 180.65,98.23 180.94,98.23
+3V_HDMI on TOP (solid shape): 50.69,166.92 50.69,165.88 50.59,165.78 48.23,165.78 48.1,165.9 48.1,166.34 48.16,166.39 48.16,166.47 48.25,166.56 48.63,166.56 48.73,166.66 48.74,166.67 48.85,166.73 48.91,166.83 48.92,166.85 49.32,167.25 50.36,167.25
+3V_HDMI on BOTTOM (solid shape): 50.12,167.01 50.12,166.76 50.12,166.76 50.12,165.98 50.04,165.9 49.73,165.9 49.71,165.91 49.49,166.08 49.24,166.14 49.21,166.14 49.14,166.21 49.14,167.02 49.27,167.15 49.98,167.15
+3V_HDMI on BOTTOM (solid shape): 55.75,161.13 55.75,160.62 56.16,160.2 58.59,160.2 58.61,160.2 58.63,160.19 58.77,160.04 58.86,159.97 58.95,159.92 58.96,159.92 59.08,159.8 59.08,158.19 58.85,157.96 56.91,157.96 56.26,157.32 56.26,157.31 56.15,157.2 54.39,157.2 54.31,157.28 53.87,157.28 53.72,157.12 52.31,157.12 52.23,157.19 52.23,157.64 52.32,157.72 53.87,157.72 53.89,157.7 55.82,157.7 56.37,158.25 56.4,158.26 56.42,158.26 56.48,158.25 56.53,158.25 57.16,158.25 57.42,158.5 57.44,158.51 57.46,158.52 57.77,158.52 58.09,158.84 58.09,159.18 57.68,159.59 56.55,159.59 56.53,159.6 56.52,159.61 56.47,159.66 56.4,159.7 56.31,159.73 56.21,159.74 56.12,159.73 56.02,159.7 55.95,159.66 55.9,159.61 55.9,159.6 55.87,159.59 55.77,159.59 55.75,159.6 55.74,159.61 55.68,159.67 55.59,159.7 55.57,159.7 55.42,159.85 55,159.85 54.74,160.11 54.74,160.73 54.74,160.75 54.74,161.19 54.81,161.26 55.62,161.26
+3V_LDO_EC on TOP (solid shape): 81.13,40.33 81.13,39.96 81.01,39.83 80.41,39.83 80.29,39.71 79.7,39.71 79.5,39.51 79.2,39.51 79.01,39.71 78.45,39.71 78.35,39.81 77.82,39.81 77.78,39.85 77.78,40.16 77.97,40.35 80.56,40.35 80.61,40.4 81.05,40.4
+3V_RTC on TOP (solid shape): outline of 116 points within 91.84,37.85 96.77,39.56
+3V_RTC on TOP (solid shape): outline of 219 points within 227.07,15.66 236.34,25.14
+3V_S5 on TOP (solid shape): 283.33,59.12 283.33,57.88 283.2,57.75 282.09,57.75 281.93,57.9 281.93,59.07 282.14,59.27 283.18,59.27
+3V_S5 on TOP (solid shape): 54.79,38.78 54.8,38.76 54.97,38.36 55.33,38.1 55.35,38.09 55.36,38.06 55.36,36.78 55.2,36.62 53.61,36.62 53.44,36.45 53.44,36.32 52.82,35.7 51.28,35.7 51.07,35.91 51.07,36.31 51.28,36.52 51.81,36.52 51.98,36.68 51.99,36.69 52.13,36.78 52.22,36.92 52.23,36.94 52.65,37.35 52.65,38.09 52.65,38.09 52.65,38.53 52.93,38.82 54.76,38.82
+3V_S5 on TOP (solid shape): 94.09,20.86 94.13,20.76 94.23,20.72 95.61,20.72 95.62,20.72 95.62,20.04 95.64,20.02 95.64,19.95 95.9,19.69 96.57,19.69 96.79,19.47 96.79,18.78 96.65,18.64 95.56,18.64 95.35,18.43 95.35,18.39 95.27,18.3 94.38,18.3 94.05,17.97 92.98,17.97 92.25,18.71 92.25,18.98 92.26,19.02 92.52,19.17 92.62,19.42 92.5,19.7 92.22,19.82 92.17,19.81 92.11,19.8 92.09,19.81 91.97,19.92 91.97,20.61 91.97,20.62 91.97,20.72 92.12,20.87 94.09,20.87
+3V_S5 on BOTTOM (solid shape): 239.9,53.43 239.9,52.19 239.77,52.06 238.47,52.06 238.46,52.08 238.46,52.94 238.32,53.07 238.32,53.46 238.47,53.61 239.72,53.61
+3V_S5 on BOTTOM (solid shape): 235.02,13.1 235.02,12.67 235.74,11.94 235.74,11.23 235.63,11.12 234.92,11.12 234.71,11.32 234.71,11.65 233.85,12.51 233.52,12.51 233.06,12.97 233.06,13.88 233.2,14.02 234.09,14.02
+3V_S5 on BOTTOM (solid shape): outline of 411 points within 15.33,34.97 33.23,44.87
+3V_S5 on BOTTOM (solid shape): outline of 1344 points within 198.55,9.03 225.01,20.26
+3V_S5 on IN2 (solid shape): 35.2,38.98 36.41,38.98 37.05,38.34 38.04,38.34 38.11,38.28 38.12,38.26 38.12,38.24 38.12,37.53 37.6,37.02 37.06,37.02 36.42,37.66 33.33,37.66 32.43,38.55 32.43,38.57 32.38,38.7 32.28,38.79 32.27,38.8 32.25,38.84 32.25,39.45 32.26,39.45 32.26,39.55 32.35,39.64 34.54,39.64
+3V_S5 on IN2 (solid shape): outline of 103 points within 236.9,18.56 243.63,21.99
+3V_S5 on SVCC (solid shape): outline of 315 points within 32.02,11.22 240.81,53.76
+3V_S5 on IN4 (solid shape): outline of 844 points within 36.65,34.69 53.59,39.21
+3V_SSD1 on TOP (solid shape): 193.8,34.88 193.8,34.38 193.79,34.37 193.67,34.09 193.62,33.8 193.62,33.78 193.39,33.54 190.9,33.54 190.62,33.82 190.62,36.86 190.79,37.03 191.65,37.03
+3V_SSD1 on TOP (solid shape): outline of 120 points within 194.18,48.76 197.02,56.46
+3V_SSD1 on BOTTOM (solid shape): 197.94,53.15 197.94,52.66 197.92,52.63 197.88,52.61 196.35,52.61 196.35,52.39 197.76,52.39 197.8,52.38 197.81,52.34 197.81,52.16 197.8,52.13 197.76,52.11 196.35,52.11 196.35,52.1 196.32,52.07 196.21,52.07 195.6,52.68 195.6,53.14 195.8,53.55 195.78,54.01 195.78,54.04 195.8,54.06 195.9,54.17 196.91,54.17
+3V_SSD1 on BOTTOM (solid shape): 196.19,50.54 196.21,50.54 196.23,50.53 196.26,50.51 196.31,50.46 196.32,50.46 196.35,50.43 196.35,50.39 197.88,50.39 197.92,50.38 197.94,50.34 197.94,50.16 197.92,50.13 197.88,50.11 196.35,50.11 196.35,49.89 197.88,49.89 197.92,49.88 197.94,49.84 197.94,49.66 197.92,49.63 197.88,49.61 196.35,49.61 196.35,49.39 197.88,49.39 197.92,49.38 197.94,49.34 197.94,49.16 197.92,49.13 197.88,49.11 196.35,49.11 196.35,48.89 197.88,48.89 197.92,48.88 197.94,48.84 197.94,48.66 197.92,48.63 197.88,48.61 196.35,48.61 196.35,48.61 196.33,48.57 196.3,48.56 194.99,48.56 194.81,48.73 194.81,50.46 194.94,50.59 196.14,50.59
+3V_SSD1 on BOTTOM (solid shape): outline of 181 points within 192.2,31.24 197.96,36.74
+3V_SSD1 on SVCC (solid shape): 198.9,56.22 198.9,54.88 198.73,54.75 198.67,54.55 198.73,54.35 198.9,54.22 198.9,50.26 198.65,50.15 198.54,49.9 198.65,49.65 198.9,49.55 198.9,43.16 198.7,43.04 198.62,42.82 198.7,42.59 198.9,42.47 198.9,34.54 197.93,33.57 196.06,33.57 194.85,34.98 193.63,33.57 191.75,33.57 191.03,34.29 191.1,43.11 191.12,43.18 191.13,43.25 191.12,43.32 191.1,43.38 191.1,43.77 191.12,43.83 191.13,43.9 191.12,43.96 191.11,44.02 191.12,45.39 191.31,45.52 191.38,45.74 191.31,45.95 191.12,46.08 191.13,46.56 191.18,46.66 191.2,46.78 191.19,46.89 191.13,47 191.15,49.74 194.34,52.93 195.78,53.49 194.84,54.73 194.84,56.35 195.43,56.94 198.18,56.94
+3V_SSD1 on IN3 (solid shape): 193.74,35.02 193.74,34.29 193.69,34.17 193.65,34.04 193.47,33.85 192.53,33.85 192.14,34.23 192.14,34.56 188.77,37.94 188.77,38.14 188.94,38.32 190.45,38.32
+3V_SSD2 on TOP (solid shape): 191.66,13.28 191.69,13.26 191.71,13.23 192.08,12.06 192.78,11.05 192.78,9.85 192.4,9.47 191.48,9.47 191.18,9.77 190.59,9.77 190.57,9.8 190.57,13.17 190.67,13.28
+3V_SSD2 on TOP (solid shape): 194.01,28.21 194.66,27.75 195.44,27.93 195.52,27.95 195.59,27.9 195.74,27.75 195.94,27.69 196.08,27.69 196.12,27.67 196.13,27.64 196.13,27.21 196.12,27.18 196.08,27.16 196,27.16 195.89,27.06 195.88,27.06 195.7,27.01 195.56,26.89 195.49,26.85 195.41,26.87 195.28,26.96 195.12,26.99 194.81,26.86 194.67,26.56 194.66,26.54 194.23,26.11 194.23,25.18 194.85,24.56 195.31,24.56 195.88,23.99 195.88,22.7 195.8,22.62 192.58,22.62 192.2,23 192.2,26.71 192.21,26.75 192.22,26.79 192.22,28.03 192.42,28.24 193.96,28.24
+3V_SSD2 on BOTTOM (solid shape): outline of 653 points within 191.36,9.36 197.99,28.06
+3V_SUS on TOP (solid shape): 12.19,43.81 12.19,43.09 11.95,42.86 11.57,42.86 10.97,42.26 10.97,39.74 11.35,39.36 12.34,39.36 13.13,38.57 13.13,37.74 13.1,37.71 11.55,37.71 9.87,39.39 9.87,40.5 10.14,40.77 10.14,43.49 10.53,43.88 12.11,43.88
+3V_SUS on BOTTOM (solid shape): 271.14,11.83 271.14,11.45 271.44,11.14 271.44,10.89 271.11,10.56 270.07,10.56 269.87,10.76 269.87,11.3 269.9,11.39 269.91,11.47 269.9,11.55 269.87,11.64 269.87,11.85 269.97,11.95 271.01,11.95
+3V_SUS on BOTTOM (solid shape): 246.97,13.53 246.99,13.52 247.01,13.5 247.12,13.37 247.27,13.3 247.3,13.28 247.31,13.25 247.31,11.85 246.98,11.52 245.89,11.52 245.38,12.03 245.38,13.3 245.61,13.53
+3V_SUS on IN1 (solid shape): 194.48,10.99 194.48,10.3 193.49,9.31 192.7,9.31 192.53,9.49 192.53,10.36 192.54,10.39 192.79,10.53 192.88,10.76 192.86,10.89 192.79,11 192.77,11.07 192.8,11.13 192.93,11.27 194.2,11.27
+3V_SUS on IN1 (solid shape): outline of 548 points within 245.64,9.95 271.37,12.54
+3V_SUS on SVCC1 (solid shape): outline of 161 points within 57.3,9.03 194.2,18.48
+3V_SUS on IN3 (solid shape): 194.46,10.81 194.46,9.9 194.45,9.87 194.42,9.85 194.04,9.63 193.77,9.29 193.75,9.27 193.72,9.26 192.73,9.26 192.58,9.41 192.58,10.38 192.6,10.41 192.61,10.42 192.81,10.54 192.88,10.76 192.87,10.85 192.83,10.94 192.83,10.97 192.84,11 193.08,11.24 194.02,11.24
+3V_SUS on IN3 (solid shape): outline of 1519 points within 10.85,14.42 62.17,45.72
+3V_TYPEC_DP1 on TOP (solid shape): 245.9,44.66 246.56,44.66 247.06,44.16 247.06,43.73 246.88,43.55 245.1,43.55 244.73,43.91 244.61,43.91 244.52,44 244.52,44.77 244.54,44.81 244.58,44.82 245.74,44.82
+3V_TYPEC_DP1 on TOP (solid shape): 240.74,45.38 240.78,45.37 240.79,45.33 240.79,45.31 241.6,45.31 241.63,45.3 241.65,45.26 241.65,45.1 240.61,44.07 239.7,44.07 239.64,44.01 239.31,44.01 239.24,44.09 239.24,44.49 239.35,44.59 239.37,44.59 239.79,44.59 240.58,45.38
+3V_TYPEC_DP1 on TOP (solid shape): 246.02,52.11 246.02,50.33 245.76,50.08 245.26,50.08 245.15,49.98 244.57,49.98 244.52,50.02 244.52,50.85 244.52,50.85 244.52,51.07 244.6,51.2 244.63,51.35 244.52,51.63 244.24,51.74 244.07,51.71 243.92,51.58 243.89,51.58 243.86,51.58 243.84,51.59 243.72,51.68 243.57,51.71 243.3,51.6 243.17,51.34 243.17,51.32 242.77,50.92 242.77,50.88 242.74,50.85 242.72,50.85 242.72,50.03 242.71,49.99 242.67,49.98 242.56,49.98 242.52,50.02 242.52,50.86 242.41,50.97 242.35,50.97 242.31,50.98 242.27,50.99 242.17,50.99 242.14,50.98 242.09,50.97 241.95,50.97 241.91,50.98 241.87,50.99 241.77,50.99 241.74,50.98 241.69,50.97 241.52,50.97 241.24,51.25 241.24,52.24 241.42,52.42 245.71,52.42
+3V_TYPEC_DP1 on BOTTOM (solid shape): outline of 426 points within 238.68,41.7 247.14,54.78
+3V_U3 on BOTTOM (solid shape): 272.75,14.8 272.96,14.79 273.3,14.79 273.4,14.79 273.41,14.79 273.5,14.7 273.5,14.35 273.49,14.32 273.49,14.29 273.49,14.01 273.56,13.84 273.73,13.77 274.03,13.77 274.11,13.78 274.18,13.82 274.63,13.82 274.85,13.61 275.23,13.61 275.28,13.55 275.28,13.16 275.26,13.13 275.18,13.05 274.41,13.05 274.37,13.09 273.67,13.09 273.27,13.48 272.41,13.48 272.19,13.26 271.89,13.26 271.89,12.63 271.37,12.11 270.02,12.11 269.79,12.34 269.79,13.15 269.88,13.24 270.02,13.24 270.05,13.23 270.12,13.23 270.16,13.24 270.87,13.24 271.27,13.63 271.75,13.63 271.87,13.75 271.91,13.78 271.95,13.83 271.95,14.42 272.33,14.8
+3V_U3 on IN1 (solid shape): outline of 817 points within 270.81,8.4 281.3,16.81
+3VPCU on TOP (solid shape): 281.6,59.12 281.6,57.88 281.45,57.73 280.36,57.73 280.23,57.85 280.23,59.05 280.43,59.25 281.48,59.25
+3VPCU on TOP (solid shape): 176.3,118.05 176.3,118 176.32,117.98 176.32,117.5 176.18,117.36 176.07,117.36 175.94,117.23 175.94,116.85 175.88,116.79 175.23,116.79 174.98,117.04 174.98,117.95 175.17,118.15 176.2,118.15
+3VPCU on TOP (solid shape): 96.87,28.92 96.87,27.32 96.83,27.25 96.81,27.17 96.81,26.87 96.81,26.81 96.8,26.79 96.25,26.25 96.14,26.25 96.14,26.25 95.45,26.25 95.41,26.29 95.41,26.4 95.43,26.44 95.46,26.45 96.14,26.45 96.14,26.65 95.46,26.65 95.43,26.67 95.41,26.7 95.41,27 94.79,27.63 94.79,27.99 94.61,28.16 94,28.16 93.9,28.27 93.9,28.79 94.06,28.96 94.39,28.96 94.43,29 96.79,29
+3VPCU on TOP (solid shape): 172.55,30.03 172.55,30.01 172.54,29.95 172.54,29.91 172.54,29.61 172.55,29.52 172.6,29.44 172.6,29.39 173.27,28.72 175.1,28.72 175.51,28.31 175.51,25.96 174.94,25.39 173.84,25.39 173.83,25.39 173.22,25.39 173.03,25.2 173.03,24.6 173,24.57 173,23.86 172.97,23.83 172.08,23.83 171.82,24.09 171.82,27.75 171.4,28.17 170.19,28.17 170,28.36 170,30.22 170.02,30.26 170.05,30.28 170.32,30.28 170.38,30.33 172.25,30.33
+3VPCU on TOP (solid shape): 13.51,81.33 13.61,81.35 13.73,81.35 13.9,81.18 13.9,79.93 13.9,79.88 13.9,79.39 14.45,79.39 14.65,79.18 14.65,78.57 14.62,78.48 14.61,78.4 14.62,78.32 14.65,78.23 14.65,78.17 14.61,78.13 14.59,78.12 14.56,78.12 14.27,78.1 14.07,77.89 14.07,77.88 14.02,77.84 13.19,77.84 13.13,77.87 13.07,77.88 13.01,77.88 12.92,77.87 12.83,77.84 12.29,77.84 12.26,77.87 10.68,77.87 10.61,77.89 10.54,77.9 10.5,77.89 10.46,77.89 10.36,77.99 10.36,78.2 10.23,78.32 10.15,78.32 10.08,78.39 9.9,78.39 9.6,78.39 9.56,78.39 8.84,78.39 8.8,78.39 8.5,78.39 8.37,78.39 8.23,78.25 8.23,77.97 7.91,77.65 7.89,77.65 7.69,77.46 7.69,77.13 7.57,77.01 6.88,77.01 6.71,77.18 6.71,77.59 6.7,77.62 6.7,77.85 6.91,78.06 7.65,78.06 7.85,78.27 7.85,78.65 8.93,79.72 8.93,81.03 8.99,81.1 10.34,81.1 10.44,81.2 12.29,81.2 12.44,81.35 13.4,81.35
+3VPCU on TOP (solid shape): outline of 187 points within 94.44,18.11 109.31,27.35
+3VPCU on BOTTOM (solid shape): 239.74,54.91 239.74,53.99 239.59,53.84 237.79,53.84 237.41,54.22 237.41,55.21 237.6,55.4 239.25,55.4
+3VPCU on BOTTOM (solid shape): 274.29,52.24 274.29,51.1 274.11,50.92 273.09,50.92 272.92,51.1 272.92,52.03 272.92,52.07 272.92,52.29 273.04,52.42 274.11,52.42
+3VPCU on BOTTOM (solid shape): 10.89,45.39 10.94,45.39 10.99,45.39 11.05,45.41 13.66,45.41 13.81,45.25 13.81,44.77 13.66,44.62 10.84,44.62 10.53,44.92 10.53,45.28 10.66,45.41 10.83,45.41
+3VPCU on BOTTOM (solid shape): outline of 589 points within 173.62,25.75 188.99,65.38
+3VPCU on IN1 (solid shape): outline of 147 points within 93.05,19.82 98.82,28.87
+3VPCU on IN1 (solid shape): outline of 319 points within 82.8,40.17 89.1,47.21
+3VPCU on IN1 (solid shape): outline of 438 points within 189.71,9.64 227.37,14.37
+3VPCU on IN2 (solid shape): outline of 371 points within 186.86,51.27 238.85,66.06
+3VPCU on IN2 (solid shape): outline of 766 points within 217.09,12.79 233.44,16.76
+3VPCU on IN2 (solid shape): outline of 1977 points within 82.24,10.98 191.05,26.97
+3VPCU on SVCC (solid shape): outline of 1197 points within 6.53,9.03 85.87,45.38
+3VPCU on IN3 (solid shape): outline of 1309 points within 6.57,43.98 13.77,81.8
+3VPCU on IN4 (solid shape): 97.93,58.01 97.93,57.22 98.11,57.04 98.11,56.58 97.88,56.35 97.48,56.35 97.02,56.81 97.02,58.06 97.22,58.26 97.68,58.26
+3VPCU on IN4 (solid shape): outline of 522 points within 81.88,14.42 99.23,23.66
+3VPCU on IN4 (solid shape): outline of 2458 points within 237.25,45.51 281.65,59.38
+3VPCU_EC on TOP (solid shape): 74.13,37.46 74.17,37.44 74.18,37.41 74.18,36.43 74.01,36.26 74.01,36.14 73.96,36.1 73.96,35.85 73.94,35.82 73.94,34.31 73.92,34.27 73.89,34.26 73.78,34.26 73.75,34.27 73.73,34.31 73.73,35.82 73.72,35.82 73.69,35.83 73.67,35.86 73.64,35.91 73.64,36.12 73.63,36.14 73.63,36.21 73.56,36.28 73.56,36.81 73.07,37.3 73.07,37.35 73.17,37.46
+3VPCU_ECPLL on TOP (solid shape): 71.99,37.12 71.99,36.34 71.62,35.98 71.62,35.91 71.59,35.84 71.57,35.82 71.54,35.82 71.54,34.28 71.52,34.25 71.49,34.23 71.39,34.23 71.32,34.3 71.33,34.32 71.33,35.82 71.32,35.82 71.29,35.83 71.27,35.86 71.26,35.89 71.21,35.95 71.21,36.24 71.34,36.36 71.34,36.9 71.28,36.96 71.25,36.98 70.78,37.46 70.78,37.81 70.82,37.85 71.27,37.85
+3VS5_HDMI on TOP (solid shape): 72.36,163.2 72.88,163.2 73.01,163.07 73.01,160.99 72.88,160.7 73.01,160.4 73.01,159.56 72.94,159.48 72.81,159.56 72.67,159.59 72.47,159.54 72.33,159.4 69.83,159.4 69.52,159.7 69.52,160.61 70.3,161.39 70.3,162.22 70.69,162.61 70.69,163.32 70.83,163.45 72.1,163.45
+5V on TOP (solid shape): 30.71,16.7 30.71,15.52 30.08,14.89 29.65,14.89 29.48,15.06 29.48,16.85 29.55,16.91 30.5,16.91
+5V on TOP (solid shape): 23.7,17.6 23.7,16.52 23.79,16.42 23.79,16.15 23.8,16.13 23.8,15.36 23.65,15.21 22.99,15.21 22.8,15.41 22.8,16.16 23,16.36 23,17.61 23.08,17.69 23.6,17.69
+5V on TOP (solid shape): 195.81,64.02 196.12,64.02 197.81,64.02 198.04,63.8 198.04,63.01 197.93,62.9 197.65,62.9 197.45,62.71 195.26,62.71 195.07,62.9 194.74,62.9 194.7,62.92 194.68,62.95 194.68,63.85 194.86,64.02
+5V on TOP (solid shape): 25.49,36.54 25.49,35.78 25.43,35.71 25.32,35.71 25.09,35.49 24.84,35.49 24.74,35.39 24.74,34.75 25,34.49 25,34.47 25.04,34.3 25.17,34.15 25.18,34.13 25.18,32.97 24.99,32.78 23.56,32.78 23.32,33.02 23.32,36.58 23.46,36.72 25.32,36.72
+5V on TOP (solid shape): 48.18,26.64 48.18,26.31 48.38,26.1 49.37,26.1 49.41,26.14 49.64,26.14 50.26,26.76 50.54,26.76 50.67,26.64 50.67,26.33 50.68,26.32 50.68,26.05 50.97,25.76 50.97,25.29 50.74,25.06 48.35,25.06 48.13,25.29 47.17,25.29 46.86,25.6 45.93,25.6 44.93,25.6 44.82,25.71 44.82,26.18 44.94,26.3 45.93,26.3 45.93,26.31 45.99,26.31 45.99,26.31 46.6,26.31 47.05,26.76 48.05,26.76
+5V on TOP (solid shape): 10.76,24.16 11.11,24.16 11.13,24.14 12.12,24.14 12.14,24.12 12.14,24.1 12.16,24.07 12.16,23.46 12.14,23.44 12.09,23.44 11.13,23.44 11.12,23.4 11.08,23.39 10.59,23.39 10.5,23.3 9.8,23.3 9.59,23.09 7.74,23.09 7.63,23.21 7.63,23.74 7.7,23.81 8.07,23.81 8.27,23.61 9.24,23.61 9.39,23.77 9.39,24.3 9.54,24.45 10.48,24.45
+5V on TOP (solid shape): 13.79,63.87 13.79,62.91 13.86,62.83 13.88,62.8 13.87,62.77 13.84,62.68 13.82,62.58 14.02,62.24 14.41,62.23 14.44,62.24 14.47,62.22 14.62,62.07 14.62,61.12 14.52,61.01 14.45,61.02 14.37,61.01 14.29,60.99 14.08,60.99 13.74,61.33 12.98,61.33 12.67,61.64 12.67,63.89 12.78,64 13.66,64
+5V on BOTTOM (solid shape): 43.86,26.22 43.86,24.5 43.96,24.39 43.96,23.87 43.82,23.73 43.32,23.73 43.01,24.05 43.01,26.21 43.13,26.33 43.75,26.33
+5V on BOTTOM (solid shape): 72.66,28.79 72.66,25.16 72.43,24.93 72.37,24.93 72.21,25.08 71.55,25.08 70.99,25.65 70.99,28.92 71,28.96 71.04,28.97 72.48,28.97
+5V on IN1 (solid shape): 30.7,17.31 30.7,15.87 30.6,15.76 29.41,15.76 29.42,15.81 29.31,16.06 29.06,16.16 29.01,16.16 28.95,16.22 28.38,16.22 28.33,16.23 28.28,16.24 28.23,16.23 28.18,16.22 27.55,16.22 27.52,16.23 27.38,16.42 27.17,16.49 27.13,16.49 27.08,16.48 26.88,16.42 26.73,16.23 26.7,16.22 26.41,16.22 26.4,16.23 23.92,16.23 23.78,16.09 23.78,15.26 23.7,15.17 22.54,15.17 22.07,15.64 22.07,16.91 22.11,16.96 24.1,16.96 24.51,16.96 24.71,17.16 25.16,17.16 25.34,17.33 30.68,17.33
+5V on IN1 (solid shape): outline of 98 points within 15.18,35.59 26,41.37
+5V on SVCC1 (solid shape): outline of 1750 points within 6.19,9.03 72.41,63.8
+5V on IN3 (solid shape): outline of 319 points within 10.05,21.66 16.07,41.29
+5V_HDD on TOP (solid shape): 41.47,20.11 41.47,17.61 41.24,17.38 37.85,17.38 37.71,17.52 37.71,19.66 38.36,20.31 41.27,20.31
+5V_HDD on TOP (solid shape): 35.67,16.48 35.67,15.63 35.56,15.53 34.78,15.53 34.37,15.12 31.65,15.12 31.5,15.27 31.5,15.6 31.6,15.69 32.01,15.69 32.34,16.02 32.34,16.31 32.83,16.8 35.35,16.8
+5V_HDD on BOTTOM (solid shape): 33.28,17 33.52,17 33.52,18.15 33.78,18.15 33.78,17 34.02,17 34.02,18.15 34.28,18.15 34.28,17 34.52,17 34.52,18.15 34.78,18.15 34.78,17 34.81,17 34.81,15.79 34.48,15.46 33.14,15.46 33,15.6 33,17 33.02,17 33.02,18.15 33.28,18.15
+5V_HDD on IN1 (solid shape): 40.79,18.85 40.79,17.8 39.7,16.71 35.52,16.71 34.48,15.67 33.32,15.67 32.83,16.16 32.83,16.88 34.05,18.1 37.41,18.1 38.44,19.13 40.51,19.13
+5V_KB_M on TOP (solid shape): 87.11,18.46 87.12,18.44 87.12,18.39 87.12,18.01 87.13,17.99 87.14,17.95 87.13,17.92 86.98,17.76 86.94,17.76 86.85,17.72 86.8,17.62 86.8,16.97 86.63,16.8 86.3,16.8 86.07,17.03 86.07,17.9 86.13,17.96 86.16,17.97 86.18,17.97 86.24,17.96 86.3,17.96 86.6,18.08 86.73,18.38 86.73,18.46 86.74,18.49 86.78,18.51 87.06,18.51
+5V_KB_M on BOTTOM (solid shape): 76.33,22.14 76.33,21.68 76.33,21.65 76.35,21.6 76.35,21.53 76.68,21.2 76.82,21.2 77.07,20.95 77.07,19.92 77.3,19.68 77.3,19.64 77.3,18.84 77.25,18.79 77.05,18.79 77.01,18.81 77,18.84 77,19.64 76.8,19.64 76.8,18.84 76.79,18.81 76.75,18.79 76.55,18.79 76.5,18.84 76.5,19.64 76.45,19.64 76.42,19.65 76.36,19.72 76.31,19.75 76.29,19.75 75.98,20.06 75.76,20.06 75.41,20.41 75.41,20.49 75.26,20.64 75.26,20.87 75.25,20.9 75.24,20.93 75.24,21.12 75.11,21.25 75.11,21.27 75.11,21.28 75.11,21.4 75.08,21.52 75.08,21.66 75.77,22.34 76.13,22.34
+5V_KB_M on BOTTOM (solid shape): outline of 155 points within 85.61,19.81 92.26,24.25
+5V_KB_M on IN1 (solid shape): 88.03,20.23 88.03,18.66 87.99,18.66 87.67,18.3 87.99,17.95 88.03,17.95 88.03,17.54 87.18,16.7 86.16,16.7 85.95,16.91 85.95,17.95 85.98,18.03 86.07,18.05 86.14,17.98 86.47,17.98 86.7,18.22 86.7,18.67 86.14,19.24 85.89,19.24 85.72,19.4 85.72,20.74 85.86,20.87 87.4,20.87
+5V_KB_M on IN3 (solid shape): 76.98,20.39 79.05,20.39 79.05,20.4 81.31,20.4 82.01,19.69 83.53,19.69 84.52,18.71 85.25,18.71 85.34,18.65 85.33,18.55 85.28,18.44 85.26,18.33 85.36,18.08 85.62,17.97 85.78,18.01 85.9,18.12 85.97,18.15 86.05,18.13 86.17,18.05 86.3,18.02 86.4,18.04 86.49,18.08 86.6,18.08 86.65,17.99 86.65,17.9 86.77,17.79 86.77,17.02 86.6,16.86 85.6,16.86 85.12,17.33 84.17,17.33 83.41,18.09 83.43,18.14 83.43,18.2 83.28,18.5 82.95,18.54 81.9,18.54 81.79,18.65 78.44,18.65 78.24,18.86 76.38,18.86 74.97,20.27 74.97,21.1 75.05,21.21 75.08,21.35 75.07,21.42 75.05,21.49 75.06,21.58 75.14,21.63 75.75,21.63
+5V_MCU on TOP (solid shape): 67.12,18.51 67.14,18.51 67.15,18.51 67.15,17.82 66.47,17.14 66.47,15.89 66.34,15.77 65.88,15.77 65.8,15.84 65.8,16.86 65.63,17.03 65.63,17.05 65.42,17.26 65.42,18.97 65.45,19 66.64,19
+5V_MCU on TOP (solid shape): 68.93,14.75 68.93,14.37 68.8,14.24 67.18,14.24 67.07,14.13 67.05,14.13 66.88,14.06 66.81,13.89 66.81,13.61 66.81,13.58 66.81,13.35 66.51,13.05 66.21,13.05 66.11,13.15 66.11,13.86 66.28,14.03 66.29,14.03 66.35,14.07 66.39,14.13 66.39,14.14 67.13,14.88 68.8,14.88
+5V_MCU on TOP (solid shape): 50.71,20.39 50.71,20.06 50.67,20.01 50.02,20.01 49.96,19.95 49.96,19.25 50.2,19.01 51.82,19.01 52.01,18.81 52.01,18.23 51.3,17.52 51.3,17.39 51.15,17.24 50.79,17.24 50.59,17.44 50.59,17.57 50.52,17.64 50.52,17.74 49.42,18.84 49.42,18.85 49.09,19.18 49.09,20.19 49.2,20.3 49.6,20.3 49.74,20.34 49.82,20.46 49.87,20.49 50.61,20.49
+5V_MCU on TOP (solid shape): 7.44,55.77 7.84,55.38 8.23,55.77 8.23,55.82 8.58,55.82 8.93,55.47 8.93,54.93 8.77,54.76 7.75,54.76 7.38,54.39 6.77,54.39 6.61,54.55 6.61,55.66 6.77,55.82 7.44,55.82
+5V_MCU on TOP (solid shape): 11.86,72.41 12.03,72.41 13.22,71.22 13.21,71.19 13.2,71.17 13.2,69.06 13.47,68.79 13.77,68.79 14,68.56 14,66.25 13.68,65.93 12.41,65.93 12.1,65.61 12.1,64.54 12.14,64.49 12.18,64.45 12.22,64.41 12.27,64.37 12.27,62.44 12.2,62.37 11.95,62.37 11.86,62.4 11.78,62.41 11.16,62.41 11.16,62.41 11.16,62.53 10.61,63.07 10.61,63.54 9.01,65.14 9.01,65.62 9.11,65.73 10.53,65.73 10.65,65.84 10.65,65.84 10.65,65.91 10.68,65.94 10.71,65.99 10.76,66.04 10.76,66.33 11.58,67.15 11.58,68.57 12.13,69.13 12.13,70.45 12,70.59 11.86,70.73 11.73,70.73 11.6,70.86 11.6,71.49 11.6,71.49 11.6,72.51 11.75,72.51
+5V_MCU on BOTTOM (solid shape): 70.48,24.38 70.48,24.25 70.47,24.24 70.45,24.18 70.44,24.12 70.44,23.82 70.51,23.65 70.68,23.58 70.77,23.58 70.84,23.56 70.91,23.55 71.11,23.55 71.15,23.53 71.16,23.5 71.16,23.21 71.11,23.12 71.01,23.13 70.9,23.18 70.78,23.19 70.5,23.08 70.39,22.8 70.4,22.72 70.43,22.63 70.42,22.54 70.33,22.49 69.65,22.49 69.51,22.62 69.51,23.33 69.28,23.56 68.82,23.56 68.72,23.66 68.72,23.79 68.76,23.84 69.06,23.84 69.69,24.47 70.38,24.47
+5V_MCU on IN1 (solid shape): 51.28,17.52 51.28,17.26 52.09,16.45 52.09,16.07 51.89,15.87 51.3,15.87 50.79,16.37 50.79,17.09 50.62,17.26 50.62,17.44 50.89,17.72 51.07,17.72
+5V_S5 on TOP (solid shape): 188.34,68.88 188.34,68.87 188.64,68.56 188.64,67.34 188.14,66.84 186.28,66.84 184.79,68.33 184.79,69.75 185.19,70.16 187.07,70.16
+5V_S5 on TOP (solid shape): 106.56,79.63 109.05,79.63 111.03,77.64 111.03,74 110.37,73.34 109.18,73.34 108.82,73.71 108.82,74.93 109.53,74.93 109.53,74.88 109.53,74.82 109.55,74.77 109.57,74.71 109.6,74.67 109.64,74.62 109.68,74.59 109.73,74.56 109.78,74.53 109.84,74.52 109.89,74.51 109.95,74.51 110,74.52 110.06,74.53 110.11,74.56 110.16,74.59 110.2,74.62 110.24,74.67 110.27,74.71 110.29,74.77 110.31,74.82 110.31,74.88 110.31,74.93 110.31,74.99 110.29,75.04 110.27,75.09 110.24,75.14 110.2,75.18 110.16,75.22 110.11,75.25 110.06,75.27 110,75.29 109.95,75.3 109.89,75.3 109.84,75.29 109.78,75.27 109.73,75.25 109.68,75.22 109.64,75.18 109.6,75.14 109.57,75.09 109.55,75.04 109.53,74.99 109.53,74.93 108.82,74.93 108.82,76.94 107.98,77.78 105.29,77.78 103.94,79.13 103.23,79.13 102.97,79.39 102.97,79.7 102.98,79.73 102.99,79.74 103.1,79.75 103.4,80.05 104.56,80.05 104.61,80.11 106.08,80.11
+5V_S5 on TOP (solid shape): outline of 133 points within 180.2,78.52 186.45,84.01
+5V_S5 on BOTTOM (solid shape): 185.72,85.82 185.72,85.29 186.26,84.76 186.26,84.32 186.43,84.14 186.43,82.32 185.86,81.75 185.35,81.64 184.85,81.49 184.57,81.49 184.19,81.88 184.19,84.6 183.67,85.12 183.67,86.28 184.12,86.73 184.81,86.73
+5V_S5 on BOTTOM (solid shape): 215.32,61.97 216.63,61.97 217.19,61.41 220.69,61.41 220.82,61.28 225.06,61.28 226.02,60.32 226.02,60.15 225.92,60.15 225.82,60.11 225.78,60.01 225.78,59.2 225.8,59.12 225.86,59.07 225.71,58.93 224.6,58.93 223.81,59.71 216.53,59.71 215.84,60.39 214.7,60.39 214.18,60.91 212.43,60.91 212.07,61.26 212.07,62.07 212.54,62.53 214.76,62.53
+5V_S5 on BOTTOM (solid shape): 109.45,75.15 109.53,75.11 109.54,75.02 109.53,74.96 109.53,74.9 109.64,74.63 109.92,74.51 110.07,74.54 110.2,74.63 110.67,75.09 112.98,75.09 113.06,75.01 113.06,73.39 112.17,72.49 109.75,72.49 108.41,73.83 108.41,74.59 108.97,75.15
+5V_S5 on BOTTOM (solid shape): 97.8,40.08 97.8,39.46 97.79,39.42 97.5,39.28 97.39,39.01 97.42,38.86 97.51,38.73 97.54,38.66 97.51,38.58 97.17,38.24 96.74,38.24 96.03,38.95 96.03,39.61 96.04,39.64 96.05,39.64 96.61,40.04 97.1,40.51 97.12,40.53 97.14,40.53 97.35,40.53
+5V_S5 on BOTTOM (solid shape): 85.71,28.96 85.71,28.29 86.16,27.84 87.07,27.84 87.51,27.39 87.51,27.01 87.46,26.92 87.36,26.91 87.28,26.94 87.19,26.95 86.91,26.84 86.8,26.56 86.82,26.42 86.9,26.3 86.92,26.23 86.89,26.16 86.73,26 86.25,26 86.23,25.98 86.16,25.98 85.76,25.58 85.76,25.51 85.72,25.47 84.68,25.47 84.6,25.54 84.6,28.79 84.8,29 85.68,29
+5V_S5 on BOTTOM (solid shape): outline of 116 points within 88.94,19.55 95.4,23.09
+5V_S5 on IN1 (solid shape): 94.36,22.97 94.57,22.97 94.73,22.81 94.73,22.56 94.61,22.44 93.11,22.44 92.58,22.97 92.58,24.17 93.16,24.17
+5V_S5 on IN1 (solid shape): 88.93,27.35 88.93,26.79 88.41,26.26 88.19,26.26 87.88,25.95 86.3,25.95 85.98,26.27 85.98,26.59 86.84,26.59 86.84,26.53 86.84,26.48 86.86,26.43 86.88,26.38 86.91,26.34 86.95,26.3 86.99,26.26 87.04,26.24 87.09,26.22 87.14,26.21 87.19,26.2 87.24,26.21 87.3,26.22 87.35,26.24 87.39,26.26 87.43,26.3 87.47,26.34 87.5,26.38 87.52,26.43 87.54,26.48 87.55,26.53 87.55,26.59 87.54,26.64 87.52,26.69 87.5,26.74 87.47,26.78 87.43,26.82 87.39,26.85 87.35,26.88 87.3,26.9 87.24,26.91 87.19,26.92 87.14,26.91 87.09,26.9 87.04,26.88 86.99,26.85 86.95,26.82 86.91,26.78 86.88,26.74 86.86,26.69 86.84,26.64 86.84,26.59 85.98,26.59 85.98,27.5 86,27.51 88.77,27.51
+5V_S5 on IN1 (solid shape): outline of 241 points within 100.71,58.28 104.88,80.71
+5V_S5 on SVCC (solid shape): 87.09,41.53 87.07,41.47 87.06,41.39 87.17,41.14 87.42,41.04 87.49,41.04 87.56,41.07 88.94,39.69 89.11,39.58 89.3,39.54 95.4,39.54 95.59,39.58 95.76,39.69 96.37,40.3 97.73,40.3 98.22,39.8 98.17,39.71 98.16,39.6 98.26,39.35 98.51,39.24 98.62,39.26 98.72,39.31 99.29,38.73 99.29,38.06 98.39,37.15 98.29,37.2 98.18,37.22 97.93,37.12 97.82,36.86 97.84,36.76 97.89,36.66 95.95,34.71 91.33,34.71 91.14,34.67 90.97,34.56 89.83,33.42 89.72,33.26 89.68,33.06 89.68,32.64 89.63,32.54 89.61,32.43 89.63,32.32 89.68,32.22 89.68,30.74 89.5,30.61 89.43,30.39 89.5,30.18 89.68,30.05 89.68,26.26 89.5,26.08 86.34,26.08 85.74,26.67 85.74,40.6 86.68,41.54 87.09,41.54
+5V_S5 on IN3 (solid shape): 189.69,68.19 190.11,68.19 193.42,64.88 205.23,64.88 208.26,61.86 211.12,61.86 211.92,62.65 213.4,62.65 213.79,62.26 213.79,61.33 213.09,60.63 212.68,60.63 212.03,59.98 207.37,59.98 204.15,63.2 192.06,63.2 186.89,68.37 186.89,69.09 187.27,69.47 188.41,69.47
+5V_S5 on IN3 (solid shape): outline of 825 points within 96.56,38.76 107.14,60.12
+5V_S5_TYPEC on TOP (solid shape): 245.7,15.9 246.04,15.9 246.86,15.08 246.87,15.08 246.9,15.05 246.9,15.03 247.22,15.03 247.26,15.01 247.27,14.98 247.27,14.83 247.26,14.79 247.22,14.77 246.9,14.77 246.9,14.71 246.89,14.68 246.86,14.66 246.82,14.65 245.92,14.65 245.82,14.55 245.77,14.52 245.69,14.42 245.69,13.78 245.54,13.63 245.25,13.63 245.19,13.68 244.52,13.68 244.44,13.76 244.44,13.94 244.8,14.29 244.8,15.93 244.94,16.06 245.53,16.06
+5V_S5_TYPEC on TOP (solid shape): 251.05,32.03 251.09,32.01 251.1,31.97 251.1,31.22 251.14,31.13 251.23,31.08 251.25,31.08 251.33,31 251.58,31 251.83,30.75 251.83,30.17 251.63,29.96 251.63,29.28 251.38,29.02 250.28,29.02 250.06,29.25 250.06,30.31 250.09,30.38 250.16,30.41 250.19,30.41 250.47,30.52 250.59,30.8 250.55,30.96 250.44,31.11 250.44,31.13 250.44,31.26 250.44,31.26 250.44,32 250.46,32.03
+5V_S5_TYPEC on TOP (solid shape): outline of 152 points within 237.66,26.52 243.08,28.89
+5V_S5_TYPEC on BOTTOM (solid shape): 243.4,31.82 243.4,31.59 243.91,31.08 243.91,29.4 243.78,29.28 243.78,27.45 243.52,27.18 242.55,27.18 242.22,26.85 241.76,26.85 241.72,26.87 241.71,26.9 241.71,27.59 241.51,27.59 241.51,26.9 241.49,26.87 241.46,26.85 241.33,26.85 241.31,26.88 241.31,27.59 241.29,27.59 241.29,27.69 241.3,27.69 241.3,28.01 241.57,28.29 241.57,29.12 241.37,29.33 239.87,29.33 239.72,29.18 239.72,29.07 239.72,28.87 239.72,28.86 239.72,28.63 239.72,28.62 239.72,28.42 239.72,28.31 239.92,28.12 239.92,27.67 239.92,27.66 239.93,27.63 239.91,27.59 239.91,26.87 239.88,26.84 239.76,26.84 239.72,26.85 239.71,26.89 239.71,27.59 239.51,27.59 239.51,26.89 239.49,26.85 239.46,26.84 239.33,26.84 239.25,26.87 239.11,27.22 238.83,27.33 238.68,27.3 238.55,27.22 237.79,27.22 237.62,27.39 237.62,29.69 237.62,29.7 237.62,31.37 238.17,31.92 243.3,31.92
+5V_S5_TYPEC on IN2 (solid shape): outline of 638 points within 241.19,13.38 248.56,32.17
+5V_S5_TYPEC on SVCC1 (solid shape): 244.65,32.07 244.77,31.85 245,31.77 245.23,31.85 245.35,32.07 250.72,32.07 250.75,32 250.79,31.94 251.68,31.05 251.68,30.52 251.7,30.42 251.76,30.34 252.37,29.73 252.37,28.68 252.31,28.64 252.26,28.6 251.65,27.98 250.33,27.98 250.21,28.08 250.06,28.11 249.91,28.08 249.78,27.98 247.32,27.98 247.23,28.02 247.14,28.03 247.04,28.02 246.95,27.98 244.96,27.98 244.93,27.99 244.89,27.99 244.86,27.99 244.83,27.98 242.11,27.98 242.11,28.01 242.07,28.17 241.95,28.3 241.95,31.73 242.29,32.07
+5V_S5_TYPEC on IN3 (solid shape): outline of 558 points within 241.34,29.05 256.1,36.19
+5VA on TOP (solid shape): 25.74,31.88 25.74,31.67 25.58,31.51 25.55,31.5 25.52,31.48 25.33,31.48 25.24,31.39 25.24,28.46 25.49,28.22 25.49,28.21 25.62,28.07 25.81,28.02 25.89,28.02 25.97,28.05 25.98,28.06 26.26,28.06 26.49,27.98 26.71,28.06 27.91,28.06 27.93,28.03 27.93,27.91 27.89,27.86 26.91,27.86 26.91,27.85 26.79,27.85 26.19,27.25 25.85,27.25 25.13,26.53 24.12,26.53 24.07,26.58 24.07,30.6 23.77,30.9 23.59,30.9 23.57,30.92 23.56,30.93 23.45,31.06 23.3,31.13 23.27,31.15 23.26,31.18 23.26,31.84 23.46,32.05 25.57,32.05
+5VPCU on TOP (solid shape): 19.65,49.05 19.78,48.97 19.93,48.95 20.33,48.95 20.69,48.59 20.69,47.95 20.66,47.92 20.17,47.92 20.01,47.76 20.01,47.51 19.88,47.39 19.54,47.39 19.4,47.53 19.4,49.01 19.44,49.05
+5VPCU on TOP (solid shape): 277.46,21.38 277.46,20.87 277.69,20.64 278.56,20.64 278.78,20.41 278.78,19.19 278.73,19.14 277.7,19.14 277.59,19.37 277.35,19.46 277.18,19.42 277.05,19.3 276.85,19.3 276.47,19.68 276.47,21.33 276.7,21.56 277.29,21.56
+5VPCU on TOP (solid shape): outline of 98 points within 128.95,18.75 141.84,28.19
+5VPCU on BOTTOM (solid shape): 78.01,25.72 78.01,24.92 77.83,24.74 76.98,24.74 76.21,23.97 75.84,23.97 75.53,23.66 74.34,23.66 74.21,23.79 74.21,24.67 74.68,25.14 75.79,25.14 76.07,25.42 76.93,25.42 77.26,25.74 77.99,25.74
+5VPCU on BOTTOM (solid shape): 30,161.61 30,160.5 30.03,160.5 30.06,160.47 30.08,160.42 30.11,160.39 30.13,160.38 30.13,159.94 30.19,159.88 30.19,159.46 30.09,159.36 28.63,159.36 28.45,159.54 28.45,160.06 28.7,160.32 29.56,160.32 29.71,160.47 29.71,161.65 29.72,161.66 29.95,161.66
+5VPCU on BOTTOM (solid shape): 80.68,25.44 81.15,25.44 81.29,25.29 81.31,25.26 81.3,25.23 81.25,25.12 81.23,25.01 81.28,24.82 81.43,24.66 81.44,24.64 81.44,24.33 81.26,24.15 80.82,24.15 80.26,24.71 79.64,24.71 79.63,24.71 79.56,24.71 79.44,24.83 79.44,24.84 79.41,24.88 79.41,25.72 79.44,25.75 80.38,25.75
+5VPCU on BOTTOM (solid shape): 239.46,25.59 239.49,25.58 239.51,25.54 239.51,24.87 239.71,24.87 239.71,25.54 239.72,25.58 239.76,25.59 239.9,25.59 239.91,25.58 239.91,24.87 239.92,24.87 239.92,24.82 239.92,24.8 239.76,24.63 239.71,24.44 239.71,24.4 239.72,24.34 239.71,24.33 239.71,24.29 239.49,24.07 237.97,24.07 237.84,24.2 237.84,25.16 237.94,25.26 238.88,25.26 238.91,25.29 238.91,25.42 239.08,25.59
+5VPCU on BOTTOM (solid shape): 241.46,25.61 241.49,25.59 241.51,25.56 241.51,24.87 241.71,24.87 241.71,25.56 241.72,25.59 241.76,25.61 242.2,25.61 242.26,25.54 242.26,25.21 242.31,25.16 243.2,25.16 243.27,25.09 243.27,24.64 243.27,24.64 243.27,24.35 243.42,24.2 243.42,23.47 243.4,23.44 243.39,23.43 243.28,23.3 243.23,23.13 243.23,23.11 243.2,23.08 242.62,23.08 242.62,23.8 242.27,23.8 242.06,24.02 241.8,24.02 241.78,24.04 241.52,24.04 241.5,24.05 241.48,24.06 241.42,24.12 241.41,24.15 241.42,24.19 241.49,24.31 241.51,24.44 241.46,24.63 241.33,24.77 241.31,24.78 241.3,24.81 241.29,24.84 241.31,24.87 241.31,25.56 241.32,25.59 241.36,25.61
+5VPCU on BOTTOM (solid shape): 277.51,20.09 277.51,20.07 277.6,19.95 277.73,19.9 277.75,19.9 278.35,19.3 278.35,18.79 279.19,17.95 279.21,17.94 279.48,17.83 279.78,17.95 280.06,17.95 280.1,17.94 280.22,17.86 280.36,17.83 280.43,17.84 280.51,17.86 280.53,17.85 280.54,17.84 280.59,17.8 280.59,17.36 280.46,17.24 278.97,17.24 278.94,17.25 278.79,17.51 278.54,17.61 278.52,17.61 278.31,17.81 278.31,17.83 278.24,17.96 278.11,18.03 278.09,18.03 277.55,18.57 277.55,18.61 277.56,18.63 277.63,18.74 277.66,18.86 277.72,18.98 277.74,19.1 277.63,19.38 277.35,19.5 277.19,19.47 277.06,19.37 277.03,19.51 277.03,19.93 277.17,20.07 277.19,20.07 277.26,20.08 277.33,20.11 277.48,20.11
+5VPCU on SVCC1 (solid shape): outline of 445 points within 14.12,10.96 280.94,48.96
+5VPCU on IN4 (solid shape): outline of 230 points within 15.18,40.91 20.19,49.83
+12V_FAN on TOP (solid shape): 221.11,60.6 224.4,60.47 225.96,60.47 225.98,60.46 225.99,60.45 226.33,60.11 226.33,58.33 226.1,58.11 224.15,58.11 223.41,58.84 221.97,58.84 221.95,58.86 221.94,58.88 221.8,59.1 221.56,59.19 221.41,59.16 221.28,59.07 221.05,58.84 219.78,58.84 219.37,58.44 219.37,57.62 219.2,57.45 217.57,57.45 217.56,57.45 216.2,57.45 215.69,57.96 215.69,58.61 215.82,58.74 216.73,58.74 216.95,58.96 216.95,59.19 217.14,59.38 217.26,59.38 217.6,59.71 217.6,60.77 217.79,60.97 217.81,60.98 217.83,60.98
+12V_FAN on BOTTOM (solid shape): 116,72.32 116,71.42 115.74,71.16 113.57,71.16 113.41,71.32 113.41,72.08 113.74,72.41 115.91,72.41
+12V_FAN on BOTTOM (solid shape): 7.44,60.46 7.55,60.46 7.55,60.46 7.69,60.46 7.83,60.32 7.83,59.09 7.46,58.72 6.63,58.72 6.53,58.82 6.53,59.72 5.91,60.34 5.91,61.46 6,61.55 6.35,61.55
+12V_FAN on BOTTOM (solid shape): 209.04,58.57 209.04,54.82 208.92,54.7 208.32,54.7 208.2,54.82 208.2,55.8 208.03,55.97 208.03,57.73 207.99,57.77 207.99,57.9 203.65,62.25 203.65,62.86 203.88,63.08 204.53,63.08
+12V_FAN on BOTTOM (solid shape): 183.41,81.7 183.41,80.79 183.4,80.77 183.38,80.76 182.43,79.94 181.66,78.93 181.64,78.92 181.62,78.91 180.92,78.91 180.36,79.47 180.36,80.25 182.09,81.98 183.13,81.98
+12V_FAN on BOTTOM (solid shape): outline of 692 points within 58.31,46.7 88.16,55.15
+12V_FAN on IN2 (solid shape): 183.43,81.53 183.43,79.54 183.43,79.52 183.42,79.5 183.06,79.15 182.75,78.76 182.75,78.76 182.44,78.45 181.07,78.45 180.77,78.75 180.77,80.94 181.88,82.06 182.9,82.06
+12V_FAN on IN2 (solid shape): outline of 276 points within 202.76,57.73 218.99,65.29
+12V_FAN on IN2 (solid shape): outline of 1494 points within 20.75,50.87 61.97,57.32
+12V_FAN on IN3 (solid shape): 115.66,72.23 115.66,70.88 115.46,70.68 114.75,70.68 114.73,70.7 114.06,70.7 113.43,71.34 113.43,71.78 114.47,72.81 115.08,72.81
+12V_FAN on IN3 (solid shape): outline of 520 points within 86.73,46.35 100.69,59.5
+12V_FAN on IN4 (solid shape): outline of 381 points within 6.53,54.73 22.42,61.1
+12V_FAN1 on BOTTOM (solid shape): 207.89,57.67 207.89,55.68 207.89,55.68 207.89,54.9 207.89,54.9 207.89,54.63 207.77,54.5 206.69,54.5 206.66,54.53 206.66,54.55 206.63,54.69 206.55,54.8 206.29,55.06 206.29,57.34 202.3,61.33 202.3,61.45 201.42,62.33 201.3,62.33 201.29,62.35 199.59,62.35 199.18,62.75 197.73,62.75 197.5,62.98 197.5,63.75 197.55,63.8 201.77,63.8
+12V_FAN2 on BOTTOM (solid shape): 9.02,64.54 9.02,63.1 8.83,62.91 8.12,62.91 7.97,63.06 7.97,63.64 7.79,63.82 7.25,63.82 6.95,63.53 6.9,63.53 6.79,63.51 6.69,63.47 6.65,63.46 6.6,63.46 6.44,63.3 6.44,62.12 6.29,61.97 5.91,61.97 5.86,62.02 5.86,62.75 5.96,62.86 5.96,63.75 6.38,64.16 6.6,64.16 6.63,64.17 6.67,64.16 6.73,64.14 6.8,64.14 7.11,64.29 7.18,64.62 7.32,64.76 8.81,64.76
+VCC3P3_S0 on TOP (solid shape): 251.37,56.66 251.37,56.35 250.92,55.9 250.92,55.12 250.84,55.04 250.43,55.04 250.36,55.11 250.36,56.14 250.99,56.78 251.25,56.78
+VCC3P3_S0 on TOP (solid shape): 272.9,59.33 272.9,59 272.82,58.92 272.23,58.92 271.84,58.54 271.34,58.54 271.29,58.59 271.29,58.87 271.11,59.05 271.11,59.39 271.19,59.47 271.33,59.47 271.33,59.47 272.77,59.47
+VCC3P3_S0 on BOTTOM (solid shape): 272.9,59.36 272.9,58.89 272.86,58.88 272.78,58.83 272.75,58.74 272.75,58.09 272.51,57.86 272.51,56.56 272.23,56.28 271.19,56.28 271.01,56.46 271.01,57.54 270.77,57.78 270.17,57.78 270.15,57.8 269.92,57.8 269.81,57.9 269.81,58.56 269.85,58.59 269.85,58.82 269.85,58.82 270.59,58.82 270.65,58.81 270.71,58.8 270.76,58.81 270.83,58.82 270.9,58.82 271.06,58.99 271.06,59.03 271.09,59.12 271.1,59.2 271.09,59.27 271.08,59.34 271.06,59.37 271.16,59.47 272.79,59.47
+VCC3P3_S0 on BOTTOM (solid shape): 254.07,58.71 254.12,58.71 254.4,58.71 254.44,58.71 254.87,58.71 254.9,58.71 255.18,58.71 255.28,58.72 255.35,58.74 255.53,58.74 255.54,58.73 255.64,58.69 255.74,58.68 255.85,58.69 255.96,58.74 256.45,58.74 257.45,57.74 257.45,57.28 257.33,57.16 256.93,57.16 256.81,57.28 256.81,57.75 256.51,58.06 254.95,58.06 254.73,58.12 254.51,58.06 254.15,58.06 253.19,57.1 253.18,57.09 253.05,57.01 252.97,56.88 252.97,56.88 251.63,55.54 250.97,55.54 250.72,55.79 250.72,56.56 251.06,56.9 251.9,56.9 251.96,56.96 251.98,56.96 252.24,57.08 252.36,57.34 252.36,57.36 253.74,58.74 254,58.74
+VCC3P3_S0 on IN4 (solid shape): outline of 2337 points within 255.95,49.83 272.18,59.47
+VCC3P3_SX on TOP (solid shape): 253.54,57.9 254.32,57.9 254.39,57.97 254.46,57.97 254.52,58.03 254.96,58.03 255.16,57.83 255.16,57.67 254.95,57.45 253.1,57.45 253.07,57.42 252.77,57.42 252.6,57.6 252.6,58.03 252.67,58.11 253.33,58.11
+VCC3P3_SX on TOP (solid shape): 270.96,59.34 270.96,58.92 271.11,58.77 271.11,58.58 271.04,58.51 270.52,58.51 270.46,58.58 270.46,58.95 270.4,59 270,59 269.95,59.05 269.95,59.36 270.04,59.46 270.84,59.46
+VCC3P3_SX on BOTTOM (solid shape): 255.19,57.78 255.19,55.59 254.48,54.88 254.48,54.35 254.4,54.27 253.99,54.27 253.89,54.37 253.89,57.27 254.54,57.92 255.05,57.92
+VCC3P3_SX on BOTTOM (solid shape): 276.29,55.16 276.29,53.05 275.91,52.67 273.04,52.67 272.92,52.8 272.92,53.71 273.02,53.81 273.86,53.81 274.26,54.22 274.26,55.21 274.47,55.41 276.04,55.41
+VCC3P3_SX on BOTTOM (solid shape): 265.85,59.37 265.83,59.34 265.81,59.27 265.81,59.2 265.92,58.92 266.2,58.8 266.28,58.81 266.47,58.62 266.47,58.3 266.44,58.27 265.87,58.27 265.72,58.12 265.4,58.12 265.3,58.22 265.3,58.54 265.3,58.57 265.29,58.6 265.29,59.09 265.3,59.15 265.3,59.2 265.3,59.25 265.28,59.32 265.39,59.44 265.78,59.44
+VCC3P3_SX on IN1 (solid shape): outline of 1294 points within 254.27,52.72 274.59,60.47
+VCC3P3_SX on IN2 (solid shape): outline of 253 points within 273.83,47.87 284.17,55.85
+VCC_CORE on TOP (solid shape): outline of 105 points within 127.2,138.93 170.68,150.99
+VCC_CORE on TOP (solid shape): outline of 228 points within 124.55,112.45 144.41,114.99
+VCC_CORE on TOP (solid shape): outline of 1878 points within 127.37,125.12 144.99,134.95
+VCC_CORE on BOTTOM (solid shape): 150.01,123.64 150.01,115.76 149.6,115.36 145.87,115.36 145.64,115.59 145.64,123.82 145.87,124.04 149.6,124.04
+VCC_CORE on BOTTOM (solid shape): 138.58,127.45 138.58,126.64 138.42,126.48 137.81,126.48 137.71,126.38 137.38,126.38 137.23,126.53 137.23,127.4 137.34,127.51 137.83,127.51 137.89,127.58 138.45,127.58
+VCC_CORE on BOTTOM (solid shape): outline of 2565 points within 126.35,112.44 166.44,150.82
+VCC_CORE on IN1 (solid shape): outline of 14092 points within 116.15,113.22 163.92,150.98
+VCC_CORE on SVCC (solid shape): 163.34,149.18 163.34,145.03 161.2,142.9 161.09,142.73 161.05,142.54 161.05,138.22 161.09,138.02 161.2,137.86 166.39,132.67 166.39,131.39 166.35,131.3 166.34,131.21 166.35,131.11 166.39,131.02 166.39,127.18 166.27,127.05 166.22,126.88 166.27,126.7 166.39,126.57 166.39,113.73 165.98,113.33 144.84,113.33 144.75,113.37 144.65,113.38 144.55,113.37 144.46,113.33 141.18,113.33 141.09,113.37 140.99,113.38 140.89,113.37 140.8,113.33 129.01,113.33 128.04,114.3 128.04,131.91 128.19,132.04 128.24,132.24 128.19,132.43 128.04,132.56 128.04,132.59 128.19,132.72 128.25,132.91 128.19,133.11 128.04,133.24 128.04,133.44 128.24,133.57 128.33,133.8 128.24,134.02 128.04,134.15 128.04,143.04 128,143.24 127.89,143.4 126.93,144.36 126.96,144.43 126.97,144.52 126.91,144.72 126.77,144.87 126.77,144.93 126.91,145.08 126.97,145.28 126.91,145.48 126.77,145.63 126.77,145.69 126.91,145.84 126.97,146.04 126.91,146.24 126.77,146.39 126.77,146.45 126.91,146.6 126.97,146.8 126.91,147.01 126.77,147.16 126.77,149.95 127.74,150.92 161.61,150.92
+VCC_CORE on SVCC1 (solid shape): 163.34,150.2 163.34,145.03 161.2,142.9 161.09,142.73 161.05,142.54 161.05,138.22 161.09,138.02 161.2,137.86 166.39,132.67 166.39,131.39 166.35,131.3 166.34,131.21 166.35,131.11 166.39,131.02 166.39,127.18 166.27,127.05 166.22,126.88 166.27,126.7 166.39,126.57 166.39,114.55 165.16,113.33 144.84,113.33 144.75,113.37 144.65,113.38 144.55,113.37 144.46,113.33 141.18,113.33 141.09,113.37 140.99,113.38 140.89,113.37 140.8,113.33 128.5,113.33 128.04,113.79 128.04,131.91 128.19,132.04 128.24,132.24 128.19,132.43 128.04,132.56 128.04,132.59 128.19,132.72 128.25,132.91 128.19,133.11 128.04,133.24 128.04,133.44 128.24,133.57 128.33,133.8 128.24,134.02 128.04,134.15 128.04,143.04 128,143.24 127.89,143.4 126.93,144.36 126.96,144.43 126.97,144.52 126.91,144.72 126.77,144.87 126.77,144.93 126.91,145.08 126.97,145.28 126.91,145.48 126.77,145.63 126.77,145.69 126.91,145.84 126.97,146.04 126.91,146.24 126.77,146.39 126.77,146.45 126.91,146.6 126.97,146.8 126.91,147.01 126.77,147.16 126.77,150.45 127.23,150.92 162.62,150.92
+VCC_CORE on IN3 (solid shape): outline of 9564 points within 126.99,113.58 163.67,150.92
+VCC_CORE on IN4 (solid shape): outline of 607 points within 127.16,136.34 158.69,150.99
+VCC_CORE on IN4 (solid shape): outline of 2062 points within 128.38,112.86 144.97,133.41
+VCC_GT on TOP (solid shape): outline of 2214 points within 145.39,112.48 161.51,133.65
+VCC_GT on IN4 (solid shape): outline of 4902 points within 144.43,113.28 161.44,133.52
+VCC_SA on TOP (solid shape): 126.43,150.61 126.43,148.56 125.82,147.95 125.19,147.95 124.86,147.62 124.86,144.06 126.59,142.33 126.59,138.27 125.44,137.13 122.83,137.13 122.47,137.48 122.47,141.93 121,143.4 121,150.49 121.4,150.89 121.99,150.89 122.45,150.44 122.58,150.44 122.63,150.39 122.69,150.38 123.07,150.38 123.13,150.39 123.18,150.44 123.18,150.44 123.31,150.56 123.31,150.66 123.62,150.97 126.08,150.97
+VCC_SA on TOP (solid shape): outline of 449 points within 122.78,125.39 127.21,133.67
+VCC_SA on BOTTOM (solid shape): outline of 645 points within 119.23,113.8 127.66,148.6
+VCC_SA on SVCC (solid shape): outline of 272 points within 110.51,113.33 127.02,150.92
+VCC_SA on SVCC1 (solid shape): outline of 252 points within 110.51,113.33 127.02,150.92
+VCC_SA on IN3 (solid shape): outline of 4456 points within 110.18,113.58 127.35,148.3
+VCCA_BCLK on BOTTOM (solid shape): 214.12,40.32 214.12,38.76 214.13,38.72 214.13,38.59 213.91,38.37 213.15,38.37 212.93,38.15 212.93,37.84 212.81,37.71 212.41,37.71 211.98,38.14 211.98,38.89 212.14,39.06 212.64,39.06 213.12,39.54 213.12,40.05 213.51,40.43 214.01,40.43
+VCCA_XTAL on TOP (solid shape): 204.97,39.64 204.97,39.54 204.87,39.44 204.66,39.44 204.21,38.99 203.86,38.99 203.67,38.8 203.35,38.8 203.35,38.79 203.17,38.79 203.14,38.8 202.99,38.95 202.99,39.16 203,39.17 203,39.47 203.29,39.77 203.41,39.77 203.43,39.79 204.82,39.79
+VCCA_XTAL on TOP (solid shape): 211.31,37.51 212.05,37.51 212.07,37.49 212.08,37.48 212.13,37.41 212.19,37.37 212.2,37.36 212.31,37.25 212.31,37.05 212.52,36.85 212.87,36.85 213.02,37 213.15,37 213.25,36.9 213.25,36.75 213.25,36.73 213.23,36.71 213.15,36.61 213.11,36.49 213.11,36.47 213,36.36 211.93,36.36 211.47,36.82 211.09,36.82 210.97,36.95 210.97,37.35 211.12,37.51
+VCCA_XTAL on BOTTOM (solid shape): 204.08,40.1 204.08,39.23 203.9,39.06 203.38,39.06 203.19,39.25 202.95,39.25 202.92,39.26 202.9,39.3 202.9,39.31 202.9,39.82 202.88,39.83 202.88,40.55 202.96,40.62 203.19,40.62 203.19,40.63 203.55,40.63
+VCCA_XTAL on BOTTOM (solid shape): 213.61,42.33 213.68,42.3 213.71,42.23 213.71,41.42 213.72,41.39 213.73,41.36 213.73,40.57 213.45,40.57 212.99,40.1 212.99,39.95 212.11,39.95 212.07,39.91 212.06,39.91 211.99,39.86 211.94,39.79 211.94,39.78 211.24,39.09 211.24,39.04 211.24,39.03 211.2,38.93 211.18,38.83 211.3,38.55 211.58,38.43 211.63,38.44 211.68,38.45 211.76,38.43 211.8,38.35 211.8,37.94 212.21,37.53 212.21,37.08 212.08,36.95 210.89,36.95 210.25,37.58 210.25,40 210.34,40.08 210.36,40.09 210.61,40.2 210.72,40.45 210.73,40.47 210.92,40.67 211,40.7 211.08,40.65 211.22,40.53 211.4,40.49 211.68,40.61 211.79,40.89 211.77,41.01 211.71,41.13 211.69,41.2 211.73,41.27 211.75,41.29 212.11,41.29 213.15,42.33
+VCCA_XTAL on IN2 (solid shape): outline of 203 points within 202.86,36.34 212.41,40.38
+VCCAMPHYPLL on TOP (solid shape): 231.03,47.03 235.15,47.03 235.65,46.53 235.65,45.73 235.57,45.64 234.2,45.64 234.12,45.61 234.07,45.54 232.54,45.54 232.25,45.25 231.17,45.25 230.79,45.63 230.3,45.63 230.27,45.61 230.25,45.6 230.23,45.59 230,45.59 229.65,45.24 229.6,45.25 229.32,45.13 229.21,44.85 229.21,44.8 229.22,44.74 229.21,44.73 228.21,44.73 227.43,43.95 227.12,43.95 227.09,43.96 227.07,44 227.07,45.05 227.19,45.17 227.21,45.17 227.27,45.17 227.32,45.19 227.87,45.19 229.86,47.18 230.88,47.18
+VCCAPLL_1 on TOP (solid shape): 200.04,50.83 200.05,50.81 200.06,50.79 200.06,50.64 200.3,50.4 200.71,50.4 200.78,50.33 200.78,49.68 202.43,48.02 202.43,45.94 203.29,45.08 203.75,45.08 203.88,44.95 204.22,44.95 204.24,44.94 204.24,44.69 204.23,44.67 204.22,44.65 204.13,44.56 204.09,44.52 203.93,44.52 203.88,44.57 203.88,44.61 203.75,44.75 202.88,44.75 201.38,46.26 201.38,46.78 199.91,48.25 199.91,48.51 199.75,48.66 199.13,48.66 198.9,48.89 198.9,49.46 198.91,49.49 199.2,49.64 199.3,49.9 199.18,50.18 198.9,50.3 198.77,50.27 198.65,50.21 198.61,50.19 198.58,50.21 198.52,50.27 198.52,50.76 198.52,50.78 198.54,50.8 198.61,50.87 200,50.87
+VCCAPLL_2 on TOP (solid shape): outline of 200 points within 199.33,45.09 204.86,53.38
+VCCDPHY on TOP (solid shape): 215.16,32.1 215.19,32.03 215.24,31.98 215.25,31.96 215.26,31.94 215.26,31.73 214.3,30.77 214.14,30.77 213.64,31.28 213.64,32.22 213.76,32.34 214.91,32.34
+VCCDPHY on BOTTOM (solid shape): 214.9,32.71 214.9,32.22 215.06,32.07 215.23,32.07 215.33,31.97 215.33,30.95 215.17,30.79 213.24,30.79 213.18,30.85 213.18,31.35 213.23,31.4 213.74,31.4 213.97,31.63 213.97,32.68 214.09,32.81 214.8,32.81
+VCCDPHY on BOTTOM (solid shape): 179.09,47.79 179.09,46.9 177.41,45.23 177.41,44.7 177.25,44.53 177.16,44.52 176.22,44.52 175.99,44.75 175.99,45.33 177.44,46.78 177.69,46.78 178.28,47.36 178.28,47.77 178.45,47.95 178.94,47.95
+VCCDPHY on IN3 (solid shape): outline of 472 points within 176.63,42.84 189.17,46.52
+VCCDPHY on IN4 (solid shape): outline of 653 points within 187.43,30.7 215.26,43.69
+VCCDSW_1.05V on TOP (solid shape): 226.08,23.22 226.08,22.03 226.99,21.12 227.33,21.12 227.91,20.54 227.91,18.78 228.13,18.56 228.27,18.56 228.28,18.55 228.52,18.55 228.72,18.35 228.72,16.96 228.53,16.77 228.16,16.77 228.07,16.8 227.99,16.81 227.88,16.81 227.76,16.93 227.76,18.03 227.57,18.22 227.57,18.66 227.29,18.94 227.29,19.67 227.28,19.68 227.28,20 225.61,21.67 225.6,21.7 225.61,21.72 225.66,21.81 225.67,21.91 225.64,22.05 225.55,22.19 225.54,22.21 225.54,22.86 225.27,23.13 225.27,23.3 225.32,23.35 225.96,23.35
+VCCDUSB on BOTTOM (solid shape): 212.72,36.81 214.4,36.81 214.55,36.66 214.55,36.3 214.36,36.11 211.81,36.11 211.73,36.03 211.12,36.03 211.05,36.11 211.05,36.57 211.28,36.81 211.72,36.81 211.84,36.81 212.53,36.81 212.53,36.81
