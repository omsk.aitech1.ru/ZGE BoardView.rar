# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
24780_BATDRV: length 39.5
  TOP w0.14: PU23.18 95.4,57.7 v1(95.5,57.8)
  TOP w0.508: PR303.2 v1(63.77,47.62) 64.21,47.18 v1(64.28,47.18)
  IN2 w0.508: v1(64.28,47.18) 64.47,47.18 67.71,50.42 71.65,50.42 71.81,50.27 72.58,49.5 77.94,49.5 78.15,49.71 84.81,49.71 87.42,52.31 89.24,52.31 92.04,55.12 92.57,55.12 93.18,55.73 93.18,56.26 94.72,57.8 v1(95.5,57.8)
24780_BATSRC: length 2.3
  TOP w0.178: PU23.17 95.8,57.22 96.71,58.14 PR175.2
24780_BM#: length 2.9
  TOP w0.152: PU23.16 96.2,57.19 96.45,57.45 97.08,57.45 97.12,57.41 97.51,57.41 97.55,57.45 97.66,57.45 v4(97.73,57.52) 97.94,57.72 PR182.2
24780_BST: length 2.3
  TOP w0.178: PU23.25 93.38,54.79 92.59,54.79
  TOP w0.203: 92.59,54.79 92.49,54.89 91.66,54.89 PR243.1
24780_CMPIN: length 6.4
  TOP w0.14: v1(98.7,55.9) 98.11,55.9 97.8,55.58 PU23.13
  BOTTOM w0.14: v1(98.7,55.9) 98.27,56.32 98.27,56.71 97.99,56.99 PR492.1 97.96,57.12 97.61,57.12 97.5,57.01 v4(97.15,57.01) 97,57.17 96.69,57.17 96.17,57.7 PR488.1 95.62,58.54 PR489.2
24780_CMPIN_R: length 4.1
  BOTTOM w0.14: 95.58,59.28 94.99,58.69 PR489.1 94.99,57.65 95.45,57.19 v4(95.57,57.19) ; 95.58,59.28 94.96,59.28 94.66,59.57 PR487.2 ; 95.58,59.28 PR490.1
24780_CMPOUT: length 2.1
  TOP w0.152: PR197.2 PR196.2 98.19,56.41 97.94,56.15 97.8,56.01 97.76,55.98 PU23.14
24780_CMSRC: length 1.9
  TOP w0.178: PR269.2 94.15,51.43 94.84,52.11 95,52.27 PU23.3
24780_DH: length 19.4
  TOP w0.178: PU23.26 92.75,54.38
  TOP w0.305: 92.75,54.38 92.55,54.38 v1(92.31,54.14)
  TOP w0.635: PQ30.4 79.18,43.99 v1(79,44.16)
  IN2 w0.635: v1(92.31,54.14) 92.28,54.14 89.77,51.64 88.58,51.64 83.58,46.65 81.49,46.65 v1(79,44.16)
24780_DL: length 20.7
  TOP w0.178: PU23.23 92.84,55.58
  TOP w0.203: 92.84,55.58 v3(92.35,56.06)
  TOP w0.635: PQ27.4 v3(78.76,47.92)
  IN1 w0.635: v3(78.76,47.92) 79.31,47.38 84.13,47.38 85.67,48.92 85.67,50.77 87.95,53.05 89.33,53.05 92.34,56.06 v3(92.35,56.06)
24780_ILIM: length 7.8
  TOP w0.14: PU23.21 94.2,56.87 94.03,57.04 93.31,57.04 92.98,57.37 91.46,57.37 91.18,57.65 PC158.2 91.19,58.08 PR181.1 92.21,58.33 92.78,58.89 92.78,59.61 PR174.1 91.87,59.7 v1(91.84,59.73)
24780_LX: length 20.8
  TOP w0.178: PU23.27 92.92,53.98 92.73,53.79
  TOP w0.254: v1(92.22,53.14) 92.22,53.28 92.73,53.79
  TOP w0.305: v1(92.22,53.14) 91.96,53.14 91.84,53.25 PC183.1
  TOP w0.508: PR310.1 82.44,45.25
  IN1 w0.635: v1(92.22,53.14) 91.39,53.14 90.09,51.83 88.39,51.83 87.06,50.51 87.06,49.27 83.68,45.89 v1(78.76,45.89)
  vias: v1(82.9,44.24)
24780_SRN: length 40.9
  TOP w0.127: v1(93.54,60.74) 93.61,60.67 94.46,60.67 94.89,60.23 94.89,59.89 94.99,59.8 PC145.2 94.99,59.53 95.14,59.38 PC146.2 95.65,59.12 95.52,58.99 PR180.2 ; v1(66.16,47.58) 66.4,47.82 PR286.1
  IN3 w0.127: v1(93.54,60.74) 93.54,60.59 93.28,60.33 92.2,60.33 90.1,58.23 90.1,55.42 89.7,55.01 88.48,55.01 87.52,54.05 87.52,53.44 86.57,52.49 80.07,52.49 79.9,52.32 78.43,52.32 76.97,50.86 74.61,50.86 73.85,51.61 72.47,51.61 71.39,50.53 67.53,50.53 66.71,49.71 66.71,48.14 66.62,48.05 v1(66.16,47.58)
24780_SRP: length 40
  TOP w0.127: v1(93.84,60.16) 94.1,60.42 94.35,60.42 94.64,60.13 94.64,59.94 94.54,59.84 PC145.1 94.54,59.17 94.76,58.94 PR179.2 94.75,58.81 PC156.2 ; PR302.1 66.96,47.26 v1(67.41,47.71)
  IN3 w0.127: v1(67.41,47.71) 66.96,48.16 66.96,49.6 67.64,50.27 71.49,50.27 72.58,51.36 73.75,51.36 74.5,50.6 77.08,50.6 78.54,52.06 80,52.06 80.18,52.23 86.68,52.23 87.78,53.33 87.78,53.94 88.59,54.75 89.8,54.75 90.36,55.31 90.36,58.13 92.31,60.07 93.38,60.07 93.47,60.16 v1(93.84,60.16)
24780_VCC: length 6.4
  TOP w0.178: PU23.28 93.05,53.58 92.8,53.33 92.8,52.83 92.63,52.65 91.63,52.65 PC186.1
  TOP w0.203: PR259.1 88.72,51.81 v1(89.21,51.81) 89.29,51.74 90.71,51.74 PC186.1
51225_CS1: length 3.5
  TOP w0.14: PU28.1 121.21,25.43 121.46,25.67 121.89,25.67 v1(122.11,25.45) 122.75,24.81 PR398.1
51225_CS2: length 4.1
  TOP w0.14: PU28.5 119.61,25.21 119.51,25.32 v1(118.84,25.32) 118.84,25.48 119.06,25.71 119.06,26.2 118.91,26.36 118.14,26.36 117.69,26.8 PR378.1
51225_DH1: length 9.8
  TOP w0.762: v3(129.89,17.25) PQ34.1
  IN1 w0.762: v3(123.05,21.99) 127.78,17.25 v3(129.89,17.25)
  vias: v1(122.95,21.25)
51225_DH2: length 5.6
  TOP w0.14: v3(117.21,17.54) 117.21,18.3 v1(117.28,18.36)
  IN1 w0.762: v3(117.21,17.54) 117.21,20.74 v3(118.33,21.86)
51225_DL1: length 16.7
  TOP w0.762: v3(130.13,11.11) 129.37,11.11 PQ34.8
  IN1 w0.762: v3(121.78,21.76) 121.78,17.54 128.22,11.11 v3(130.13,11.11)
51225_DL2: length 10.6
  IN1 w0.762: v3(118.99,21.23) 118.99,16.45 118.02,15.48 v3(118.02,11.02)
  vias: v1(118.13,21)
51225_EN1: length 1.7
  TOP w0.14: PR403.1 123.34,24.04 123.31,24.08 v1(122.96,24.08) 122.94,24.06 PU28.20
51225_FB1: length 4.5
  TOP w0.14: PU28.2 120.81,25.58 PR377.1 122.7,26.83 v1(122.89,26.63) 123.07,26.45 PR391.1
51225_FB2: length 3.3
  TOP w0.14: PU28.4 120.01,25.21 119.47,25.75 PR380.2 PR379.1
51225_SW1: length 14.9
  IN1 w0.762: v3(131.53,13.67) 131.53,17.88 130.35,19.07 127.93,19.07 123.67,23.33 v3(123.15,23.33)
  vias: v1(138.07,9.69)
51225_SW2: length 24.2
  TOP w0.508: PR422.1 111.04,16.21 112.23,15.01 v3(112.23,13.83)
  IN1 w0.762: v3(117.55,23.02) 112.23,17.7 v3(112.23,13.83)
  vias: v1(111.23,9.54)
51225_VBST1: length 3.9
  TOP w0.14: v1(124.73,20.74) 124.73,21.16 PR409.2
  TOP w0.203: PR409.2 124,21.89 123.23,22.65 122.85,22.65 122.64,22.86 PU28.17
51225_VBST2: length 2.6
  TOP w0.203: PR410.1 117.23,21.86 v1(117.68,22.31) 117.74,22.31 118.28,22.86 PU28.9
51225_VIN:
  vias: v1(119.78,20.67)
61087COMP: length 3
  TOP w0.254: PU22.1 238.36,56.32 238.65,56.02 238.65,55.77 v1(239.25,55.17) 239.25,54.87 238.9,54.52 PR218.2
61087EN: length 5.3
  TOP w0.079: PR185.1 240.55,57.82 240.71,57.98
  TOP w0.14: PR185.1 PC159.2 238.79,57.32 PU22.3 ; v1(240.3,59.99) 240.81,59.48 240.81,58.08 240.71,57.98
61087FB: length 5
  TOP w0.14: PR199.1 241.06,56.82 241.45,56.43 241.45,55.29 v1(241.57,55.16)
  TOP w0.254: PR199.1 PR198.2 239.29,56.82 PU22.2
61087FREQ: length 4.7
  TOP w0.079: PR251.1 235.28,53.93
  TOP w0.14: 235.28,53.93 235.6,53.61 v1(235.6,53.38)
  TOP w0.203: PR251.1 234.94,54.55 234.77,54.73 234.74,54.73 234.49,54.98 PR208.2 234.18,55.47 234.18,56.43 234.57,56.82 PU22.9
61087SS: length 5.7
  TOP w0.14: v1(237.89,53.51) 237.64,53.76 236.37,53.76 235.98,54.15 PC181.2
  TOP w0.203: PC181.2 235.98,55.17 235.48,55.67 234.71,55.67 234.56,55.82 234.56,56.13 234.76,56.32 PU22.10
61087SW:
  vias: v1(234.59,59.48)
81215_ALERT: length 3.3
  TOP w0.14: PU2.41 178.83,170.02 179.3,170.49 v1(179.93,170.49) 179.93,171.05 179.85,171.13 PR17.1
81215_SCLK: length 3
  TOP w0.14: PU2.42 178.43,170.12 179.04,170.74 v1(179.04,171.4) 179.06,171.42 179.06,172.15 PR13.2
81215_SDIO: length 5
  TOP w0.14: PR14.1 180.78,172.15 181.25,172.15 v1(181.59,171.81) 181.45,171.68 180.99,171.68 180.47,171.16 180.47,170.27 180.13,169.94 179.37,169.94 179.23,169.8 PU2.40
+SMDDR_VREF_CHA_DIMM0_R: length 3
  BOTTOM w0.508: R793.2 178.87,49.65 C729.1 R778.1 178.87,51.61 R771.1
+SMDDR_VREF_CHB_DIMM0_R: length 4
  TOP w0.508: R205.2 R216.2 R224.1 C236.1 180.26,39.37 v1(179.8,38.9)
+SPI_VCC: length 7.8
  TOP w0.508: v1(243.1,32.55) 243.48,32.93 R335.2 ; R340.1 239.64,33.06 v1(239.21,33.49) ; R452.1 236.74,20.69 v1(236.31,20.26) ; v1(241.6,21.3) 241.31,21.59 R456.2 ; R319.2 237.64,34.18 237.13,33.67 v1(237.13,33.55) 237.47,33.21 C320.1 237.81,33.05 237.81,32.21 C328.2 237.75,32.14 237,31.39 U19.8
+TPVDD: length 8.5
  IN2 w0.508: v1(86.18,13.81) 86.61,14.24 88.77,14.24 90.8,16.27 91.68,16.27 v1(92.35,16.93)
  BOTTOM w0.508: v1(96.54,18.07) 96.54,18.08 97.17,18.71 Q79.3
  vias: v1(91.99,17.49)
+USBPWR:
  vias: v1(14.22,41.77) v1(14.34,40.86) v1(14.46,45.24) v1(14.88,41.85) v1(14.9,41.19) v1(16.88,48.2)
+USBPWR3:
  vias: v1(282.31,19.82) v1(283.08,19.98) v1(283.05,19.32) v1(283.13,17.92) v1(285.06,15.64) v1(285.06,14.98) v1(285.46,6.21)
+VREFCA_CHA_DIMM: length 81.4
  TOP w0.254: JDIM2.164 130.32,38.62 130.88,39.18 130.88,39.9 130.63,40.15 v1(130.45,40.15)
  IN1 w0.508: v1(130.45,40.15) 130.93,40.15 131.44,40.66 131.44,44.24 132.61,45.41 169.74,45.41 173.39,49.05 173.39,51.11 174.02,51.74 174.02,52.61 v1(173.78,52.85)
  BOTTOM w0.254: JDIM4.164 128.42,44.34 129.61,43.15 129.61,41.81 129.79,41.63 129.79,40.78 130.42,40.15 v1(130.45,40.15)
  BOTTOM w0.508: v1(179.22,61.51) 179.22,60.74 R730.2 178.89,60.18 C705.2 179.88,59.09 C702.2 178.45,59.09 177.62,58.26 177.62,57.43 C706.1 177.58,56.95 176.89,56.26 176.89,54.78 C709.2 178.11,53.56 C712.2 178.11,51.63 R771.2 177.93,51.62 176.35,53.2 175.61,53.2 175.25,52.85 v1(173.78,52.85)
+VREFCA_CHB_DIMM: length 71.5
  TOP w0.254: JDIM1.164 130.32,52.14 129.89,52.58 129.89,53.27 129.53,53.62 v1(129.46,53.62)
  TOP w0.508: v1(173.04,52.54) 173.4,52.19 174.44,52.19 175.38,53.13 176.39,53.13 178.01,51.5 178.66,51.5 179.6,50.56 R164.2 180.23,50.56 ; C175.2 179.99,49.19 179.99,48.31 C186.1 C197.1 179.99,46.25 179.99,45.32 179.99,45.31 C207.1 179.99,43.95 C210.2 179.48,43.43 R205.1
  IN1 w0.508: v1(173.04,52.54) 172.71,52.54 172,51.83 172,51.2 171.27,50.46 132.28,50.46 130.15,52.58 130.15,53.09 129.63,53.62 v1(129.46,53.62)
  BOTTOM w0.254: JDIM3.164 128.42,54.32 129.12,53.62 v1(129.46,53.62)
  vias: v1(181.32,50.36)
+WL_VDD: length 3.7
  TOP w0.508: v1(48.47,45.49) 48.48,45.51 R191.2 R184.2 ; Q28.2 53.42,41.69 52.91,42.2 v1(52.91,42.34) 52.47,41.9 R220.2
  vias: v1(48.6,50.9) v1(48.63,50.19) v1(48.82,32.01) v1(50.36,32.43) v1(50.87,31.97) v1(51.07,32.6) v1(51.23,38.71) v1(51.79,44.36) v1(52.44,45.05) v1(52.44,44.39)
A0_DP: length 6.8
  TOP w0.14: R30.2 97.75,148.38 97.16,147.78 R29.2 96.7,147.78 96.4,148.08 96.4,148.92 v1(95.5,149.82) v1(93.67,149.82)
  BOTTOM w0.14: U39.11 93.62,149.86 v1(93.67,149.82)
A0_EDP: length 3
  TOP w0.14: v1(178.34,89.37) 178.33,89.36 178.33,89.27 178.33,89.27 R115.2 R116.2
  BOTTOM w0.14: U41.11 178.33,89.38 v1(178.34,89.37)
A0_TBT: length 2.7
  TOP w0.14: U10.11 v1(240.3,48.81)
  BOTTOM w0.14: R795.2 R794.2 240.8,49.31 v1(240.3,48.81)
A_DE: length 3.8
  TOP w0.14: R512.2 43.78,18.52 43.78,19.29 R470.1 44.42,19.26 v1(44.42,18.86)
  BOTTOM w0.14: U43.9 44.98,19.33 44.52,18.86 v1(44.42,18.86)
A_EQ1: length 5.6
  BOTTOM w0.14: U43.18 45.48,24.1 46.39,25.01 46.8,25.01 v1(46.91,25.12) 46.91,25.9 R947.1 47.42,26.4 47.42,27.17 R927.2
A_EQ2: length 5.6
  BOTTOM w0.14: R929.2 47.6,27.52 47.72,27.4 47.72,26.77 v1(47.9,26.59) 47.94,26.55 R955.1 47.38,25.21 47.38,24.76 47.27,24.65 46.53,24.65 45.98,24.1 U43.19
ACIN: length 46.2
  TOP w0.14: v1(83.17,24.01) 83.17,23.95 83.64,23.49 83.99,23.49 84.32,23.82 U18.72 ; PR263.1 96.28,50.67 96.03,50.42 PR276.2 96.03,49.85 96.12,49.76 PR280.1 95.86,49.58 95.57,49.29 95.57,48.81 v1(95.77,48.61)
  IN1 w0.086: v1(95.77,48.61) 95.75,48.63 91.2,48.63 90.82,48.25 86.84,48.25 86.23,47.64 86.23,46.78 86.76,46.24 86.76,45.4 85.18,43.83 v5(85.18,43.17)
  BOTTOM w0.14: v5(85.18,43.17) 85.18,42.74 85.36,42.56 85.36,42 85.01,41.65 85.01,41.24 84.63,40.85 84.63,39.71 85.01,39.32 85.01,38.42 86.12,37.3 86.12,35.01 85.46,34.35 85.46,29.51 85.89,29.08 85.92,29.05 85.92,28.37 86.25,28.05 87.15,28.05 87.65,27.55 87.72,27.48 87.72,27.47 87.72,26.43 87.65,26.36 87.65,26.33 87.53,26.21 87.53,25.07 87.52,25.07 87.52,25.06 87.27,24.81 87.26,24.81 87.22,24.76 84.33,24.76 84.17,24.6 83.66,24.6 83.17,24.11 v1(83.17,24.01)
ACPRESENT: length 180.9
  TOP w0.102: 224.78,19.5 224.78,20.26 224.96,20.44 224.96,20.77 224.71,21.02 224.48,21.02 224.1,21.4 224.1,22.02 223.93,22.19 223.93,22.95 U14.BG42
  TOP w0.14: v1(82.7,21.45) 82.39,21.76 82.39,22.14 81.96,22.57 81.96,24.29 82.39,24.72 82.39,25.3 81.58,26.12 81.58,26.71 82.83,27.96 82.83,29.41 83.14,29.72 83.55,29.72 83.84,29.43 83.84,29.11 84.33,28.62 U18.84 ; 224.78,19.5 224.78,18.95 224.58,18.76 224.58,17.97 224.49,17.87 224.49,17.35 R542.1 223.79,16.65 223.79,15.96 223.72,15.89 223.72,14.96 223.54,14.78 v1(223.54,14.37)
  IN3 w0.089: v1(223.54,14.37) 222.98,13.81 222.98,12.77 222.62,12.41 221.84,12.41 221.35,12.89 219.91,12.89 219.42,12.4 210.3,12.4 210.05,12.15 208.27,12.15 207.79,11.68 206.41,11.68 206.14,11.4 199.19,11.4 197.74,12.85 196.04,12.85 195.47,13.42 191.11,13.42 190.18,14.35 189.98,14.35 185.23,19.1 183.6,19.1 183.12,19.58 178.33,19.58 177.42,18.67 175.87,18.67 174.9,19.64 171.59,19.64 171.39,19.45 166.03,19.45 165.36,18.77 160.12,18.77 158.88,20.01 151.47,20.01 148.87,22.61 144.37,22.61 144.01,22.25 133.92,22.25 131.41,19.74 118.19,19.74 116.16,21.77 116.16,22.38 114.77,23.78 111.59,23.78 111.08,24.28 104.56,24.28 100.81,20.53 100.81,19.45 99.22,17.86 97.53,17.86 96.92,18.47 95.48,18.47 93.88,20.07 92,20.07 91.36,19.43 89.03,19.43 88.65,19.05 84.66,19.05 83.24,20.47 83.24,20.74 82.7,21.28 v1(82.7,21.45)
ACZ_BCLK: length 10.6
  TOP w0.102: 206.57,20.79 207,20.79 207.61,21.4 207.76,21.4 208.61,22.25 208.61,23.48 208.88,23.75 208.88,24.76 U14.BD11
  TOP w0.14: 206.57,20.79 203.68,20.79 203.35,20.47 C442.2 R488.2
ACZ_RST#: length 11.2
  TOP w0.102: U14.BE10 207.94,24.27 207.94,23.83 208.2,23.57 208.2,22.42 207.6,21.81 207.44,21.81 206.91,21.28 205.35,21.28
  TOP w0.14: 205.35,21.28 201.81,21.28 R496.2
ACZ_SDIN0_R: length 10.3
  TOP w0.102: 205.99,21.04 206.96,21.04 207.53,21.61 207.68,21.61 208.4,22.33 208.4,23.57 208.64,23.8 U14.BE11
  TOP w0.14: R491.2 202.52,21.04 205.99,21.04
ACZ_SDO: length 7.1
  TOP w0.102: R492.2 204.59,19.8 204.95,19.8 R493.1 206.04,20.57 207.06,20.57 207.7,21.2 207.85,21.2 208.81,22.16 208.81,23.36 U14.BF12
ACZ_SPKR: length 226.1
  TOP w0.14: v1(218.17,27.56) 218.08,27.56 U14.AW29 ; D32.2 28.77,38.4 v1(29.2,38.83)
  IN3 w0.089: v1(55.13,44.22) 54.81,43.91 54.81,43.09 55.03,42.87 55.03,41.85 54.73,41.55 54.73,40.5 55.03,40.19 55.48,40.19 55.79,40.51 56.57,40.51 58.03,39.04 68.73,39.04 69.05,38.73 70.33,38.73 70.77,39.18 71.99,39.18 72.67,38.5 77.51,38.5 78.29,37.72 79.19,37.72 79.45,37.46 82.49,37.46 83.71,38.67 85.33,38.67 85.78,38.22 87.41,38.22 87.64,38.45 89.93,38.45 90.33,38.05 92.23,38.05 93.48,36.8 94.05,36.8 94.22,36.98 96.43,36.98 96.99,36.41 98.4,36.41 98.55,36.56 176.69,36.56 177.98,37.86 188.19,37.86 191.8,34.24 191.8,33.99 192.09,33.7 193.1,33.7 194.81,32 195.69,32 197.87,29.82 197.87,25.47 198.44,24.9 199.45,24.9 200.73,23.61 204.44,23.61 205.03,24.2 205.73,24.2 205.78,24.15 210.37,24.15 210.49,24.26 211.76,24.26 212.1,23.92 212.54,23.92 212.94,24.32 214.67,24.32 214.88,24.1 216.04,24.1 217.73,25.79 217.73,27.12 v1(218.17,27.56)
  IN4 w0.086: v1(55.13,44.22) 53.85,44.22 51.29,41.66 50.88,41.66 49,39.78 48.38,39.78 47.77,40.39 45.35,40.39 43.47,38.52 37.13,38.52 35.16,36.54 30.46,36.54 29.2,37.8 v1(29.2,38.83)
  BOTTOM w0.102: 221.17,20.77 221.17,20.92 221.33,21.07 221.33,21.71 220.93,22.11 220.93,22.96 219.31,24.58 219.31,25.25 218.96,25.6 218.96,26.93 218.33,27.56 v1(218.17,27.56)
  BOTTOM w0.14: 221.17,20.77 221.17,19.74 R1040.2
ACZ_SYNC: length 5.6
  TOP w0.102: U14.BG13 209.01,22.87 209.01,21.89 208.98,21.86 208.98,21.02 208.61,20.64 208.41,20.64 208.05,20.29 206.73,20.29 R494.2
ADDR0: length 1.8
  TOP w0.14: U30.36 274.87,14.55 274.73,14.69 v1(274.35,14.69)
  BOTTOM w0.14: R1131.1 273.88,14.48 274.09,14.69 v1(274.35,14.69)
ADDR1: length 1.8
  TOP w0.14: v1(275.14,15.01) 275.27,14.88 U30.35
  BOTTOM w0.14: R1130.1 275.02,14.89 v1(275.14,15.01)
ADOGND: length 28.7
  TOP w0.14: v1(36.06,28.69) 36.05,28.71 35.25,28.71 35.2,28.76 U17.47
  TOP w0.203: U17.40 32.81,25.27 v1(32.91,25.16) ; U17.29 28.41,25.46 28.16,25.21 v1(27.98,25.21) ; C343.1 23.56,29.12 v1(23.23,29.46) ; R400.1 15.41,26.44 v1(15.67,26.18) ; C463.1 11.52,14.95 11.02,14.44 v1(11.02,14)
  TOP w0.381: v1(39.62,24.04) 39.96,23.7 R431.1 ; C358.1 39.61,27.47 39.12,27.47 R392.1 38.53,28.14 v1(38.53,28.29) ; v1(35.05,20.98) 35.3,21.23 C420.2 ; v1(23.21,30.75) 23.21,30.56 C338.1 ; C421.2 v1(37.01,21.62) ; C352.2 v1(22.9,28.11) ; C360.2 22.85,26.97 v1(22.17,27.65) ; R427.2 37.89,23.82 v1(37.46,23.38) ; C355.1 v1(37.7,27.04) ; v1(36.36,20.87) 36.16,20.68 R461.1 ; v1(25.37,24.98) 25.87,25.48 C371.1 ; C396.1 24.34,24.65 v1(24.66,24.96) ; v1(21.63,27.22) 21.63,26.86 22.35,26.15 23.33,26.15 C370.1
  TOP w0.508: v1(20.16,23.18) 20.16,22.73 R442.2 ; v1(16.22,21.78) 16.63,21.78 17.17,22.33 C409.1 ; v1(21.13,23.18) 21.13,22.72 20.85,22.44 R443.2 ; R409.2 19.2,25.96 v1(19.58,26.33) ; v1(19.37,23.13) 19.23,23.27 R428.1
  BOTTOM w0.305: v1(11.02,14) CN17.1 ; CN17.10 11.11,18.5 v1(11.02,18.41)
  BOTTOM w0.381: v1(15.67,26.18) 15.01,26.18 R956.1
  vias: v1(17.77,26.28) v1(17.7,25.47) v1(25.24,22.68) v1(25.9,22.71) v1(26.74,22.73) v1(27.5,22.73) v1(28.27,22.73) v1(30.01,23.74) v1(32.4,22.55) v1(33.55,22.52) v1(39.36,25.42)
ADP_BOARD_ID: length 3.9
  TOP w0.14: R257.2 72.23,38.06 72.23,37.57 72.6,37.2 72.87,37.2 73.35,36.72 73.35,36.12 73.43,36.03 U18.122
ADP_ID: length 157.3
  IN2 w0.089: PJ1.7 122.83,165.97 122.83,164.13 118.26,159.55 116.6,159.55 113.81,156.76 113.81,155.36 v1(113.18,154.73)
  IN3 w0.089: v1(93.31,49.27) 94.08,49.27 94.46,49.65 95.44,49.65 96.4,48.69 98.16,48.69 99.8,50.33 99.8,51.95 101.21,53.36 101.21,55.31 102.05,56.14 102.05,59.98 103.35,61.28 105.52,61.28 106.81,62.57 106.81,64.92 108.81,66.92 115.58,66.92 117.05,68.39 117.05,94.7 110.25,101.49 109.63,101.49 106.92,104.21 106.92,108.07 107.31,108.46 107.31,125.06 106.4,125.97 106.4,130.54 108.81,132.95 108.81,137.54 109.51,138.24 109.51,144.7 108.56,145.64 108.56,148.11 109.3,148.85 110.57,148.85 113.16,151.44 113.16,154.71 v1(113.18,154.73)
  BOTTOM w0.14: v1(93.31,49.27) 91.31,49.27 91.02,49.56 PQ54.2 90.33,49.56 90.13,49.76 PR516.1 89.45,49.76 88.69,50.52 PR500.2
AMP_MUTE#: length 122.1
  TOP w0.14: v1(9.41,17.75) 9.38,17.72 D59.1 ; U18.108 79.03,33.7 78.66,33.32 78.66,30.14 78.15,29.63 78.15,29.53 v1(77.74,29.12)
  IN1 w0.086: v1(76.04,14.8) 76.09,14.85 76.09,16.6 71.16,21.53 67.34,21.53 66.35,22.52 66.35,23.14 67.15,23.94 70.78,23.94 72.65,25.81 72.65,26.93 73.83,28.11 76.73,28.11 v1(77.74,29.12) ; v1(9.41,17.75) 9.61,17.75 10.13,18.27 10.13,18.69 11.69,20.24 13,20.24 v1(13.07,20.31)
  IN4 w0.086: v1(76.04,14.8) 76.04,14.7 75.39,14.05 67.94,14.05 67.05,14.95 61.9,14.95 60.95,15.9 60.95,16.12 60.14,16.92 59.42,16.92 57.8,15.31 56.15,15.31 55.72,14.88 54.97,14.88 54.32,15.53 49.62,15.53 47.36,17.79 35.76,17.79 34.79,16.82 34.79,15.89 34.17,15.28 32.61,15.28 32.21,15.67 30.15,15.67 28.22,17.6 19.77,17.6 19.14,16.97 16.37,16.97 14.41,15.01 14.12,15.01 11.86,12.75 10.15,12.75 9.64,13.26 9.64,16.76 9.41,16.99 v1(9.41,17.75)
  BOTTOM w0.14: v1(13.07,20.31) 13.07,20.73 R1021.1
AN_DPSRC_RBIAS_1: length 1.1
  TOP w0.089: U7.N6 v2(262.05,54.03)
  BOTTOM w0.14: v2(262.05,54.03) 262.1,54.09 R766.2
AUD_AZACPU_SCLK: length 188.3
  TOP w0.089: v1(122.5,124.56) 123.09,124.56 U3.G27
  TOP w0.14: v1(194.18,38.12) 194.6,38.12 195.77,36.95 195.95,36.95 197.1,35.81 197.1,35.45 R313.2
  IN2 w0.089: v1(194.18,38.12) 193.8,38.5 193.64,38.5 190.1,42.04 190.1,42.43 189.19,43.35 189.19,43.9 188.85,44.24 187.4,44.24 185.82,45.82 185.82,47.34 185.51,47.64 184.55,47.64 182.9,49.29 182.46,49.29 179.56,52.19 179.56,53.58 180.66,54.68 180.66,55.87 179.8,56.73 178.81,56.73 177.02,58.52 177.02,59.16 176.31,59.87 175.8,59.87 175.69,59.99 175.69,60.5 174.42,61.77 v1(174.42,62.61) ; v1(102.66,70.5) 102.99,70.83 102.99,72.39 104.69,74.09 104.69,75.45 104.9,75.65 104.9,76.68 108.55,80.34 108.55,86.45 108.98,86.88 108.98,89.02 107.89,90.11 107.89,91.09 108.25,91.45 108.25,95.31 108.88,95.95 108.88,104.74 109.46,105.32 109.46,109.78 110.76,111.08 110.76,111.75 111.3,112.29 114.76,112.29 116.56,114.08 116.56,122.42 118.61,124.48 119.85,124.48 120.21,124.12 122.07,124.12 v1(122.5,124.56)
  IN4 w0.086: v1(174.42,62.61) 174.42,62.84 173.78,63.47 173.78,63.59 164.18,73.19 116.3,73.19 113.82,70.71 104.45,70.71 104.16,71.01 103.16,71.01 v1(102.66,70.5)
AUD_AZACPU_SCLK_R: length 8.9
  TOP w0.102: U14.AM3 204.33,30.66 203.92,30.66 203.73,30.85 202.89,30.85 202.61,30.57 201.74,30.57 200.17,32.15
  TOP w0.14: 200.17,32.15 198.75,32.15 198.07,32.82 v1(197.92,32.82) 197.92,33.33 197.95,33.35 R313.1
AUD_AZACPU_SDI: length 187.3
  TOP w0.102: U14.AN3 204.65,29.8 204.1,29.8 203.9,29.61 202.72,29.61 202.36,29.96 201.49,29.96 201.06,30.39 200.46,30.39 200.03,29.96
  TOP w0.14: R61.2 113.03,128.3 112.97,128.36 111.84,128.36 111.82,128.34 110.22,128.34 109.67,127.79 109.67,127.05 108.57,125.95 v1(108.1,125.95) ; 200.03,29.96 198.06,29.96 197.44,30.58 197.44,30.79 196.23,32 196.23,34.2 195.38,35.05 194.44,35.05 191.88,37.61 191.41,37.61 190.33,38.69 190.33,42.12 189.33,43.11 187.24,43.11 186.94,43.42 186.94,46.04 v1(187.65,46.75)
  IN3 w0.089: v1(189.79,55.14) 189.79,54.74 189.88,54.65 190.23,54.65 190.32,54.56 190.32,54.38 190.23,54.29 189.88,54.29 189.79,54.2 189.79,54.03 189.88,53.94 190.23,53.94 190.32,53.85 190.32,53.67 190.23,53.58 189.88,53.58 189.79,53.49 189.79,48.72 188.61,47.54 188.13,47.54 187.65,47.06 v1(187.65,46.75)
  IN4 w0.086: v1(108.1,125.95) 108.04,125.89 108.04,110.72 108.6,110.16 108.6,105.33 108.08,104.82 108.08,91.43 108.93,90.58 109.05,90.58 109.42,90.95 109.54,90.95 109.67,90.82 109.67,90.7 109.3,90.33 109.3,90.21 109.42,90.09 109.56,90.09 109.96,90.5 110.08,90.5 110.2,90.38 110.2,90.25 109.79,89.84 109.79,89.72 109.91,89.6 110.03,89.6 110.48,90.05 110.6,90.05 110.72,89.93 110.72,89.81 110.27,89.37 110.27,89.24 110.39,89.12 110.51,89.12 110.96,89.57 111.08,89.57 111.21,89.44 111.21,89.31 110.76,88.87 110.76,88.75 117.6,81.91 121.91,81.91 124.66,79.16 164.89,79.16 179.65,64.4 179.65,64.27 179.65,64.27 179.65,63.77 180.95,62.47 181.11,62.47 181.34,62.23 181.34,62.2 182.21,61.33 182.21,60.42 182.62,60.01 183.01,60.01 186.8,56.23 188.7,56.23 188.76,56.17 188.83,56.17 189.79,55.21 v1(189.79,55.14)
AUD_AZACPU_SDI_R: length 11.3
  TOP w0.089: v1(123.16,126.13) 123.16,126.06 U3.G29
  TOP w0.14: R61.1 115.11,127.55 115.81,127.55 116.21,127.15 116.21,126.8 117.44,125.58 118.44,125.58 v1(118.76,125.9)
  BOTTOM w0.14: v1(118.76,125.9) 120.26,125.9 120.96,126.6 122.69,126.6 v1(123.16,126.13)
AUD_AZACPU_SDO: length 5.2
  TOP w0.102: R358.1 200.2,31.11 v1(200.56,31.11) 200.92,31.11 201.66,30.37 202.53,30.37 202.89,30.01 203.7,30.01 204.08,30.4 U14.AM2
AUD_AZACPU_SDO_R: length 189.1
  TOP w0.114: U3.G25 123.81,122.91 v1(123.81,122.99)
  TOP w0.14: v1(193.37,38.09) 193.98,37.48 194.5,37.48 195.55,36.43 195.79,36.43 196.61,35.61 196.61,35.3 197.39,34.52 197.39,32.55 197.71,32.23 198.29,32.23 R358.2
  IN2 w0.089: v1(123.81,122.99) 123.23,122.41 118.17,122.41 117.03,121.27 117.03,112.09 114.28,109.35 110.58,109.35 109.93,108.7 109.93,105.13 109.35,104.55 109.35,100.07 109.75,99.67 109.75,96.15 108.91,95.31 108.91,93.79 109.37,93.33 109.37,89.54 109.45,89.47 109.45,86.68 109.02,86.26 109.02,80.14 105.37,76.49 105.37,75.46 105.16,75.25 105.16,73.9 104.58,73.31 103.46,72.19 103.46,70.59 v1(103.38,70.51) ; v1(173.77,62.9) 173.77,61.75 175.2,60.32 175.2,59.81 175.61,59.4 176.12,59.4 176.55,58.97 176.55,58.33 178.62,56.26 179.26,56.26 179.42,56.1 179.42,54.88 178.83,54.29 178.83,52.26 182.09,49 182.09,46.54 182.59,46.04 183.83,46.04 184.95,44.92 186.05,44.92 186.91,44.06 186.91,43.68 187.55,43.04 188.83,43.04 189.63,42.24 189.63,41.84 193.37,38.11 v1(193.37,38.09)
  IN4 w0.086: v1(173.77,62.9) 173.34,62.9 163.51,72.73 116.5,72.73 113.64,69.87 110.79,69.87 110.42,70.24 104.07,70.24 103.79,70.51 v1(103.38,70.51)
AUX_SRCN_TBT_C: length 2.3
  TOP w0.089: U7.W11 259.79,51.77 v2(259.46,52.09)
  BOTTOM w0.14: C731.1 258.45,51.24 258.59,51.24 258.69,51.34 258.69,51.55 259.01,51.87 259.24,51.87 v2(259.46,52.09)
AUX_SRCP_TBT_C: length 2.3
  TOP w0.089: U7.Y11 259.48,51.41 v2(259.49,51.41)
  BOTTOM w0.14: C737.1 258.41,50.92 258.72,50.92 259.01,51.21 259.01,51.42 259.14,51.55 259.34,51.55 v2(259.49,51.41)
B_DE: length 3.5
  TOP w0.14: R513.2 44.9,18.67 44.9,19.39 R471.1 45.37,19.32 v1(45.37,18.88)
  BOTTOM w0.14: U43.8 45.48,18.99 v1(45.37,18.88)
B_EQ1: length 8.2
  BOTTOM w0.14: R930.2 49.88,27.87 50.4,27.35 50.4,26.66 v1(49.58,25.83) 49.03,25.29 48.42,25.29 R972.1 47.5,24.37 46.67,24.37 46.48,24.18 U43.20
B_EQ2: length 4.9
  BOTTOM w0.14: U43.17 44.98,24.1 45.64,24.76 v1(45.64,25.1) 45.97,25.42 R949.1 45.49,26.39 45.49,27.95 R928.2
BAT-V: length 18.8
  TOP w0.203: v1(88.21,48.81) 88.21,48.3 PD6.2
  BOTTOM w0.203: v1(88.21,48.81) 88.21,49.29 v1(86.9,50.61) 85.87,50.61 84.85,49.58 71.88,49.58 v3(71.69,49.39)
  vias: v3(61.74,51.22) v3(61.74,50.46) v3(62.5,51.22) v3(62.5,50.46) v3(63.26,50.21) v3(63.26,49.44) v3(64.03,50.21) v3(64.03,49.44) v3(64.79,50.21) v3(69.37,49.74) v3(70.14,49.37) v3(70.91,49.39)
BATLED0#: length 247.9
  TOP w0.14: U18.29 70.2,22.22 v1(70.78,22.8)
  IN2 w0.089: v1(39.82,160.19) 40.12,159.89 41.66,159.89 41.74,159.97 45.24,159.97 45.99,159.22 48.92,159.22 49.64,159.94 57.29,159.94 57.74,159.49 60.82,159.49 61.14,159.16 63.73,159.16 64.26,158.63 64.54,158.63 65.13,158.05 68.17,158.05 69.87,159.75 71.26,159.75 72.62,161.12 73.77,161.12 74.29,160.6 75.63,160.6 75.99,160.24 77.92,160.24 78.2,160.52 78.63,160.52 80.84,158.31 84.61,158.31 87.42,155.5 87.42,149.81 87.56,149.67 87.56,145.71 88.54,144.73 94.68,144.73 97.14,142.28 97.14,135.91 103.75,129.3 103.75,100.78 102.61,99.64 102.61,97.95 100.86,96.2 100.86,89.68 103.12,87.41 103.65,87.41 v1(104.18,87.94) ; v1(61.79,47.49) 62.57,48.26 63.75,48.26 66.91,51.42 71.4,51.42 71.72,51.74 73.57,51.74 74.26,51.05 77.5,51.05 77.78,51.33 77.78,51.88 78.24,52.34 79.84,52.34 80.11,52.61 86.59,52.61 87.35,53.37 89.4,53.37 91.31,55.28 91.31,58.02 91.9,58.61 91.9,60.04 92.26,60.4 92.26,61.88 92.8,62.42 93.31,62.42 93.48,62.59 v1(93.48,63.12)
  IN3 w0.089: v1(70.78,22.8) 69.59,23.99 69.59,27.1 v1(67.86,28.83) ; v1(93.48,63.12) 93.69,63.33 93.79,63.33 95.46,65 95.46,68.29 96.35,69.18 96.35,70.21 101.67,75.53 101.67,77.26 103.31,78.9 104.09,78.9 105.74,80.55 105.74,83.51 105.38,83.87 104.59,83.87 104.18,84.29 v1(104.18,87.94)
  IN4 w0.086: v1(61.79,47.49) 62.02,47.26 62.02,44.98 64.8,42.2 64.8,38.7 63.69,37.59 63.69,35.89 65.51,34.07 65.51,31.48 65.84,31.15 66.52,31.15 67.17,30.5 67.44,30.5 67.86,30.08 v1(67.86,28.83)
  BOTTOM w0.14: v1(39.82,160.19) 39.82,159.75 D83.1 40.3,159.73 40.3,160.56 40.11,160.75 38.21,160.75 37.99,160.53 37.99,160.3 37.69,160 36.92,160 36.62,160.29 36.52,160.29 36.35,160.46 CN8.16
BATLED1#: length 247.6
  TOP w0.14: v1(65.54,23.63) 65.73,23.44 R430.2
  IN2 w0.089: v1(41.46,160.29) 41.57,160.18 45.33,160.18 46.08,159.43 48.86,159.43 49.56,160.13 57.14,160.13 57.63,160.62 61.03,160.62 61.58,160.07 63.09,160.07 64.34,158.82 64.62,158.82 65.21,158.24 68.09,158.24 69.79,159.94 71.18,159.94 72.54,161.31 73.85,161.31 74.37,160.79 75.71,160.79 76.07,160.43 77.84,160.43 78.12,160.71 78.71,160.71 80.92,158.5 84.69,158.5 87.61,155.58 87.61,149.89 87.75,149.75 87.75,145.79 88.61,144.92 94.76,144.92 97.33,142.36 97.33,135.99 103.94,129.38 103.94,100.7 102.8,99.56 102.8,97.87 101.05,96.12 101.05,90.58 103.45,88.17 103.45,88.02 v1(103.52,87.95) ; v1(61.25,48.94) 61.28,48.98 61.28,51.51 61.51,51.74 62.97,51.74 64.46,53.22 66.61,53.22 66.93,53.53 69.91,53.53 70.22,53.22 71.99,53.22 73.08,54.32 79.17,54.32 79.29,54.43 89.92,54.43 90.93,55.44 90.93,58.18 91.52,58.77 91.52,60.32 91.87,60.67 91.87,62.6 92.86,63.59 v1(92.89,63.59)
  IN3 w0.089: v1(92.89,63.59) 93.78,63.59 95.27,65.08 95.27,68.37 96.16,69.26 96.16,70.29 101.48,75.61 101.48,77.34 103.23,79.09 104.01,79.09 105.55,80.63 105.55,83.44 105.3,83.68 104.51,83.68 103.96,84.24 103.96,84.67 103.52,85.11 v1(103.52,87.95)
  IN4 w0.086: v1(65.54,23.63) 65.43,23.73 64.23,23.73 64,23.5 63.4,23.5 62.34,24.56 62.34,25.35 62.01,25.68 62.01,28.25 63.08,29.32 63.08,29.96 64.75,31.64 64.75,33.76 62.93,35.58 62.93,37.91 64.02,38.99 64.02,41.91 60.73,45.21 60.73,48.11 61.25,48.63 v1(61.25,48.94)
  BOTTOM w0.14: CN8.17 36.85,160.46 37.03,160.28 37.57,160.28 37.71,160.42 37.71,160.65 38.09,161.03 40.23,161.03 40.61,160.65 40.61,159.71 40.81,159.5 D82.1 41.46,159.87 v1(41.46,160.29)
BATLOW#: length 79.7
  TOP w0.102: U14.BF44 225.05,23.43 225.05,23.08 225.35,22.78 225.35,22.22 225.32,22.18 v1(225.32,21.91) 225.32,21.66 225.72,21.26
  TOP w0.14: R534.1 227.36,17.2 227.36,18.57 227.07,18.86 227.07,19.59 226.76,19.9 226.76,20.22 225.72,21.26
  IN2 w0.089: v1(263.21,57.75) 262.96,58 259.13,58 258.86,57.73 255.93,57.73 255.34,58.31 254.35,58.31 252.93,56.9 252.93,56.14 251.54,54.75 250.82,54.75 250.08,54.01 249.93,54.01 248.07,52.15 248.07,47.62 247.24,46.79 247.24,44.75 244.77,42.28 244.77,40.89 242.5,38.63 237.81,38.63 237.38,38.2 237.38,37.89 237.99,37.28 237.99,36.26 237.35,35.62 236.93,35.62 236.38,35.07 236.38,34.28 235.48,33.38 235.48,30.89 237.36,29.01 237.36,27.84 237.56,27.64 237.56,25.41 237.03,24.89 237.03,21.86 236.56,21.39 235.15,21.39 235.02,21.26 225.96,21.26 v1(225.32,21.91)
  BOTTOM w0.14: R738.1 263.81,57.75 v1(263.21,57.75)
BBS_BIT1: length 10.5
  TOP w0.102: U14.BE23 214.5,24.02 214.5,23.58 214.56,23.51 214.56,23.01 214.42,22.87 214.42,21.66 213.79,21.02
  TOP w0.14: 213.79,21.02 213.4,20.64 213.4,18.28 213.1,17.97 212.9,17.97 212.57,17.64 212.57,16.84 R536.1 211.81,16.36 R546.2
BEEP1: length 4.3
  TOP w0.14: R293.2 26.17,35.66 D36.1 25.77,36.87 25.2,37.45 v1(25.2,37.62) 25.2,37.87 25.73,38.4 D32.1
BEEP2: length 3
  TOP w0.14: R293.1 R292.1 25.65,34.89 25.93,34.61 25.93,34.02 26.02,33.93 C289.1 26.02,33.28 26.05,33.25 C321.2
BEEP3: length 1.4
  TOP w0.14: U17.15 26.6,32.36 26.48,32.48 C321.1
BI: length 36.1
  TOP w0.14: v1(89.35,37.15) 89.17,37.33 89.17,39.23 88.73,39.67 87.8,39.67 86.38,41.09 85.55,41.09 85.39,41.25 85.39,42.74 85.64,42.99 85.64,43.98 86.58,44.92 86.58,46.16 85.06,47.68 85.06,51.31 85.06,51.32 85.06,51.68 v1(85.18,51.81)
  IN2 w0.14: v1(73.46,50.84) 73.65,50.64 77.67,50.64 78.19,51.16 78.19,51.65 78.46,51.93 80,51.93 80.28,52.21 84.63,52.21 85.02,51.81 85.17,51.81 v1(85.18,51.81)
  BOTTOM w0.14: v1(89.35,37.15) 89.35,36.57 89.13,36.35 R869.1 ; v1(73.46,50.84) 73.27,51.02 73.27,51.3 72.56,52.01 PR505.2 72.18,51.91 PJ22.7
BI_GATE: length 165.2
  TOP w0.14: Q30.5 94.13,36.97 93.85,36.69 93.44,36.69 92.5,37.63 92.27,37.63 R262.1 90.68,38.42 90.4,38.7 90.4,39.71 88.18,41.92 88.18,42.49 87.56,43.11 v1(86.8,43.11) ; v1(188.21,58.44) 186.35,58.44 184.96,59.83 183.31,59.83 182.26,58.79 181.37,58.79 180.87,58.28 180.87,56.89 v1(179.85,55.87)
  IN4 w0.086: v1(179.85,55.87) 179.52,56.2 175.29,56.2 173.13,58.36 171.92,58.36 162.31,67.97 117.67,67.97 115.38,65.68 111.08,65.68 110.77,65.38 103.37,65.38 101.4,63.4 101.4,51.35 99.59,49.54 99.59,47.32 98.59,46.33 97.29,46.33 95.9,47.72 95.68,47.72 94.98,48.41 91.67,48.41 88.51,45.25 87.92,45.25 86.8,44.13 v1(86.8,43.11)
  BOTTOM w0.14: v1(179.85,55.87) 180.48,56.5 180.48,57.29 182.74,59.55 SW2.4 ; v1(86.8,43.11) 86.35,42.66 86.35,42.36 85.92,41.93 85.92,41.77 85.57,41.42 85.57,41 85.18,40.62 85.18,39.94 85.57,39.56 85.57,38.69 86.68,37.58 86.68,36.02 87.62,35.08 Q73.2 87.84,33.86 88.26,33.44 88.26,32.68 88.6,32.34 88.6,32.04 R901.1 89.05,31.59 C830.1 89.05,30.67 89.13,30.59 89.13,30.36 89.51,29.98 R912.2 ; SW2.3 189.32,59.55 v1(188.21,58.44)
BL#: length 3.4
  TOP w0.14: Q9.2 178.83,116.84 178.69,116.69 178.48,116.69 178.33,116.83 Q9.3 177.32,117.18 v1(177.16,117.01) R82.1
BL_ON: length 19.4
  TOP w0.14: R86.1 179.42,115.74 Q9.6 179.33,116.37 179.83,116.87 179.83,117.88 D14.2 179.05,118.66 Q7.3 v1(180.45,120.44) 181.86,121.85 181.86,129.76 181.02,130.6 R50.1
BLON_EN: length 7
  TOP w0.14: R93.2 R91.2 R89.2 Q11.3 179.4,113.7 179.8,114.1 179.8,114.59 v1(179.96,114.75) 179.87,114.85 R87.1 179.1,115.17 178.83,115.43 Q9.5
BLONCON: length 6.4
  TOP w0.14: v1(176.46,129.59) 176.46,129.92 177.13,130.6 R49.2 177.82,131.11 178.95,131.11 R50.2
  BOTTOM w0.14: v1(176.46,129.59) 175.98,129.11 175.98,128.89 175.34,128.25 CN10.33
BOARD_ID0: length 146.6
  TOP w0.14: R58.1 180.56,128.89 v1(181.1,128.89) ; U14.BB20 213.17,25.95 v1(213.51,25.95)
  IN2 w0.089: v1(213.51,25.95) 213.51,26.65 212.29,27.88 212.29,29.18 212.36,29.25 212.36,30.67 211.59,31.44 211.59,32.34 211.25,32.68 211.25,33.43 211.86,34.04 212.73,34.04 213.35,34.66 213.35,35.2 213.83,35.68 214.67,35.68 214.95,35.96 214.95,37.58 213.73,38.8 212.27,38.8 211.88,38.41 210.61,38.41 210.46,38.56 208.02,38.56 206.98,39.6 205.86,39.6 203.78,41.68 203.78,45.38 203.15,46.01 203.15,47.57 202.38,48.34 202.38,50.06 202.75,50.43 202.75,52.42 201.98,53.19 200.4,53.19 200.01,53.59 199.86,53.59 199.54,53.91 199.54,54.63 198,56.16 195.49,56.16 193.63,58.02 193.63,58.85 193.03,59.45 191.89,59.45 191.34,60 190.33,60 189.69,60.65 188.41,60.65 184.66,64.39 184.66,64.65 179.08,70.23 179.08,80.52 178.99,80.61 178.99,83.96 182.11,87.08 182.11,88.69 180.72,90.08 180.72,93.82 179.71,94.83 179.71,102.89 180.15,103.33 180.15,104.68 179.84,104.98 179.84,112.27 179.29,112.83 179.29,124.06 178.79,124.56 178.79,127.04 180.65,128.89 v1(181.1,128.89)
  BOTTOM w0.14: v1(213.51,25.95) 213.37,25.95 212.88,25.47 212.88,23.21 211.71,22.04 211.71,19.63 R1058.1 211.5,18.82 211.5,17.92 211.4,17.83 R1106.1
BOARD_ID0_R: length 5.7
  TOP w0.14: v1(176.07,127.91) 176.07,128.16 176.43,128.52 177.21,128.52 C54.1 177.76,128.16 179.05,128.16 R58.2
  BOTTOM w0.14: v1(176.07,127.91) 175.41,127.25 CN10.31
BOARD_ID1: length 147.5
  TOP w0.14: U14.BB16 211.28,25.6 v1(212.04,25.6) ; R56.1 v1(181.07,129.58)
  IN2 w0.089: v1(181.07,129.58) 178.6,127.12 178.6,124.48 179.1,123.98 179.1,112.75 179.65,112.19 179.65,104.9 179.96,104.6 179.96,103.41 179.52,102.97 179.52,94.75 180.53,93.74 180.53,90 181.92,88.61 181.92,87.16 178.16,83.4 178.16,80.65 178.89,79.93 178.89,70.15 184.47,64.57 184.47,64.32 188.33,60.46 189.61,60.46 190.25,59.81 191.26,59.81 191.81,59.26 192.95,59.26 193.44,58.77 193.44,57.94 195.41,55.97 195.98,55.97 197.39,54.57 197.39,54.07 198.06,53.39 199.93,53.39 200.33,53 201.9,53 202.42,52.48 202.42,51.59 201.75,50.92 201.75,48.38 202.96,47.16 202.96,45.93 203.59,45.3 203.59,41.6 205.78,39.41 206.9,39.41 207.94,38.37 210.38,38.37 210.53,38.22 211.96,38.22 212.35,38.61 213.65,38.61 214.76,37.5 214.76,36.04 214.59,35.87 213.75,35.87 213.16,35.28 213.16,34.74 212.65,34.23 211.78,34.23 211.06,33.51 211.06,32.6 211.4,32.26 211.4,31.36 212.17,30.59 212.17,29.33 212.01,29.17 212.01,25.63 v1(212.04,25.6)
  BOTTOM w0.102: v1(212.04,25.6) 211.76,25.33 211.76,24.81 211.69,24.73 v1(211.69,24.34)
  BOTTOM w0.14: v1(211.69,24.34) 211.85,24.18 211.85,22.92 210.58,21.65 210.36,21.65 209.63,20.92 209.63,20.62 R1052.1 209.44,19.43 209.44,17.83 R1091.1
BOARD_ID1_R: length 5.9
  TOP w0.14: v1(176.7,128.99) 176.71,128.99 C53.1 177.81,130.09 178.96,130.09 R56.2
  BOTTOM w0.14: CN10.32 175.4,127.75 175.57,127.92 175.57,128.13 176.42,128.99 v1(176.7,128.99)
BOARD_ID2: length 26.4
  TOP w0.14: v1(207.49,13.08) 207.42,13.15 R970.2 207.79,14.13 R991.1 ; v1(212.77,29.63) 212.61,29.63 U14.AN18
  BOTTOM w0.14: v1(207.49,13.08) 206.56,14.01 206.1,14.01 205.77,14.34 205.77,14.66 v1(205.57,14.86) 205.26,14.86 204.97,15.14 204.31,15.14 204,15.45 204,16.02 205.12,17.13 205.12,18.96 205.89,19.73 206.2,19.73 207.76,21.28 207.95,21.28 208.43,21.76 208.68,21.76 208.88,21.95 208.88,22.31 209.79,23.22 209.79,23.86 210.24,24.31 210.41,24.31 211.3,25.2 211.3,26.38 210.85,26.83 210.85,27.51 211.31,27.97 211.76,27.97 212.03,28.25 212.03,28.97 212.69,29.63 v1(212.77,29.63)
BOARD_ID3: length 13.5
  TOP w0.102: R487.2 207.45,20.06 208.11,20.06 208.49,20.44 208.69,20.44 209.19,20.94 209.19,21.78 209.22,21.81 209.22,22.7 209.57,23.05 209.57,23.57 U14.BF14
  TOP w0.14: R487.2 207.71,19.31 207.71,18.19 207.31,17.8 206.81,17.8 206.48,17.47 205.55,17.47 205.16,17.85 v1(205,17.85) 204.46,17.85 204.11,17.5 R544.1 203.3,16.26 R547.1
BOARD_ID4: length 14.6
  TOP w0.14: U14.AR18 212.73,28.75 v1(212.73,28.66)
  BOTTOM w0.14: v1(212.73,28.66) 212.54,28.66 212.27,28.39 212.27,28.15 211.93,27.81 211.93,26.3 211.54,25.91 211.54,25.1 210.44,23.99 210.33,23.99 210.14,23.8 210.14,23.18 209.21,22.26 209.21,20.93 208.43,20.15 208.43,18.91 208.14,18.63 R1045.2 208.3,17.79 R1090.1
BOARD_ID5: length 10.5
  TOP w0.102: 207.97,19.43 207.97,19.63 208.58,20.23 208.77,20.23 210.76,22.22 210.76,23.21 211.23,23.68 U14.BF17
  TOP w0.14: 207.97,19.43 207.99,19.41 207.99,18.08 207.43,17.52 206.93,17.52 206.42,17.01 R554.1 R548.2
BOARD_ID6: length 9.6
  TOP w0.102: R497.2 208.76,19.93 210.97,22.14 211.05,22.14 211.75,22.85 211.75,23.41 211.58,23.58 211.58,23.91 U14.BE17
  TOP w0.14: R549.1 207.41,17.01 207.96,17.56 v1(208.13,17.56) 208.27,17.71 208.27,19.27 R497.2
BOARD_ID7: length 14
  TOP w0.102: v1(220.56,27.7) 220.48,27.78 U14.AV34
  BOTTOM w0.102: 222.19,21.35 221.88,21.67 221.68,21.67 221.21,22.13 221.21,23.06 219.55,24.72 219.55,25.35 219.16,25.74 219.16,26.81 219.37,27.02 219.37,27.27 219.8,27.7 v1(220.56,27.7)
  BOTTOM w0.14: R1102.1 222.8,17.92 222.8,19.06 R1041.2 222.12,19.75 222.12,20.46 222.19,20.54 222.19,21.35
BOARD_ID8: length 15.2
  TOP w0.14: U14.AW32 219.11,26.87 219.56,26.87 v1(219.78,27.1)
  BOTTOM w0.102: 223.43,21.11 223.06,21.48 223.06,21.91 223.43,22.28 223.43,23.47 223.18,23.71 222.34,23.71 222.05,24.01 220.6,24.01 219.75,24.85 219.75,25.49 219.37,25.87 219.37,26.68 v1(219.78,27.1)
  BOTTOM w0.14: R1101.1 223.87,17.97 v1(223.87,18.21) 223.87,18.95 R1051.2 223.18,19.64 223.18,20.23 223.5,20.54 223.5,21.03 223.43,21.11
BOARD_ID9: length 13.9
  TOP w0.14: U14.BA33 219.38,26.51 219.72,26.51 219.78,26.44 219.78,26.45 v1(219.78,26.45)
  BOTTOM w0.102: 224.27,22.14 223.67,22.74 223.67,23.54 223.29,23.92 222.45,23.92 222.15,24.21 220.68,24.21 219.96,24.94 219.96,25.62 219.65,25.94 219.65,26.32 v1(219.78,26.45)
  BOTTOM w0.14: 224.27,22.14 225.18,21.23 225.18,19.65 R1050.2 224.55,19.01 224.55,17.63 R1100.1
BOARD_ID10: length 12.3
  TOP w0.102: 221.14,18.88 220.93,19.09 220.93,20.17 220.57,20.54 220.57,22.13 220.4,22.3 220.4,23.44 220.1,23.75 220.1,24.25 U14.BE34
  TOP w0.14: 221.14,18.88 221.14,18.7 221.25,18.59 221.25,18.24 220.87,17.85 220.67,17.85 R539.2 219.78,17.14 219.48,16.84 219.48,15.52 219.11,15.15 218.51,15.15 R580.1
BOARD_ID11: length 15.6
  TOP w0.14: v1(220.54,25.39) 220.53,25.39 220.36,25.39 219.87,24.9 U14.BD34
  IN1 w0.102: v1(220.54,25.39) 220.54,25.39 220.16,25.01 220.16,24.22 220.86,23.51 220.86,20.95 222.79,19.03 222.79,15.31 v1(222.27,14.79)
  BOTTOM w0.14: R1125.1 220.84,14.48 R1124.2 221.22,14.86 222.19,14.86 v1(222.27,14.79)
BOARD_ID12: length 12.7
  TOP w0.102: U14.BF35 220.56,23.67 220.56,23.58 220.61,23.53 220.61,22.38 220.77,22.22 220.77,20.94 221.15,20.56 221.15,19.21 221.39,18.97
  TOP w0.14: 221.39,18.97 221.39,18.79 221.57,18.61 221.57,18.16 220.98,17.57 220.79,17.57 220.46,17.24 220.46,14.29 R578.2 219.72,13.82 R581.1
BOARD_ID13: length 15.5
  TOP w0.102: U14.BD38 221.47,24.54 221.47,23.94 221.44,23.91 221.44,23.52 221.22,23.31 221.22,22.63 221.38,22.47 221.38,21.84 221.56,21.66 221.89,21.66 222.17,21.38 222.17,20.36 222.55,19.98 222.55,19.5
  TOP w0.14: 222.55,19.5 222.55,18.69 222.49,18.62 222.49,17.89 222.21,17.61 222.21,17.2 R545.2 222.07,16.96 221.29,16.19 221.29,13.34 v1(220.71,12.75) 220.65,12.7 220.12,12.7 219.81,12.39 R616.1
BT_EN: length 78.4
  TOP w0.14: R374.1 89.96,29.38 90.86,28.47 90.86,26.29 90.92,26.23 v1(90.92,26.23) ; v1(51.06,46) 51.05,46 50.48,46 R191.1
  IN2 w0.089: v1(51.06,46) 51.05,46 48.15,46 46.28,44.13 46.28,40.5 47.23,39.54 47.23,38.77 45.5,37.03 45.5,36.01 46.43,35.08 47.23,35.08 48.72,33.59 52.83,33.59 54.86,31.55 54.86,30.45 56.27,29.05 56.97,28.35 56.97,28.01 57.37,27.61 58.87,27.61 60.11,26.38 63.84,26.38 64.23,25.98 64.59,25.98 64.77,25.8 65.41,25.8 66.7,24.52 66.7,24.11 68.61,22.19 71.64,22.19 72.78,23.33 73.56,23.33 74.15,23.92 74.15,24.82 74.68,25.35 79.68,25.35 80.32,26 80.32,26.4 80.93,27.01 83.98,27.01 85.28,25.71 87.21,25.71 87.59,26.08 88.29,26.08 89.34,27.14 90.65,27.14 90.86,26.93 90.86,26.29 90.92,26.23 v1(90.92,26.23)
  BOTTOM w0.14: v1(51.06,46) 51.05,46 CN16.54
BUFRST: length 1.6
  TOP w0.102: v2(42.9,97) 42.9,97.02 42.58,97.35 UG1.BF9
  BOTTOM w0.14: TPG68.1 42.2,96.2 42.9,96.9 v2(42.9,97)
C_GPU_TBT_AUXN: length 5.8
  TOP w0.14: C230.2 245.16,40.91 245.01,40.77 244.15,40.77 243.73,41.19 243.73,42.71 243.87,42.85 R213.2 243.37,43.72 243.37,43.91 243.42,43.96 U10.25
C_GPU_TBT_AUXP: length 5.8
  TOP w0.14: U10.24 243.02,43.62 243.3,43.34 243.3,43.18 R212.2 243.41,42.41 243.41,41.06 244.02,40.45 245.01,40.45 C233.2
C_GPU_TBT_D0: length 2.1
  TOP w0.14: C167.2 239.64,50.08 240.1,50.08 240.57,49.61 U10.9
C_GPU_TBT_D0#: length 2.1
  TOP w0.14: C172.2 239.58,49.76 239.97,49.76 240.44,49.29 240.66,49.29 240.74,49.21 U10.10
C_GPU_TBT_D1: length 2
  TOP w0.14: U10.12 240.77,48.41 240.73,48.37 240.11,48.37 239.9,48.58 239.61,48.58 C182.2
C_GPU_TBT_D1#: length 2
  TOP w0.14: U10.13 240.77,48.01 240.73,48.05 239.97,48.05 239.76,48.26 239.6,48.26 C187.2
C_GPU_TBT_D2: length 2
  TOP w0.14: C193.2 239.6,47.07 239.89,47.07 239.99,47.17 240.72,47.17 240.76,47.21 U10.15
C_GPU_TBT_D2#: length 2
  TOP w0.14: C201.2 239.62,46.75 240.02,46.75 240.12,46.85 240.68,46.85 240.73,46.81 U10.16
C_GPU_TBT_D3: length 2.1
  TOP w0.14: U10.18 240.76,46.01 240.72,45.97 240.41,45.97 239.99,45.55 239.6,45.55 C203.2
C_GPU_TBT_D3#: length 2.1
  TOP w0.14: C208.2 239.61,45.23 240.12,45.23 240.54,45.65 240.74,45.65 240.78,45.61 U10.19
C_INT_DP_AUXN: length 35.4
  IN4 w0.086: CN2.17 89.04,164.84 89.04,164.09 87.7,162.74 86.77,162.74 85.58,161.55 85.07,161.55 84.84,161.78 84.84,161.99 v1(84.63,162.2)
  BOTTOM w0.14: U39.25 88.09,152.9 87.72,153.27 87.72,155.03 87.47,155.27 87.47,155.83 R663.1 87.45,156.19 87.45,158.97 87.8,159.33 87.8,160.5 88.32,161.02 88.32,162.47 87.81,162.98 85.24,162.98 84.85,162.6 84.85,162.42 v1(84.63,162.2) 84.8,162.03 84.8,161.34 ESD1.9 84.8,161.18 84.8,160.46 ESD1.2 84.83,160.28 84.83,159.37 85.13,159.07 85.13,158.2 84.99,158.06 84.61,158.06 84.38,158.3 R650.2 83.82,158.23 82.12,158.23 81.09,159.26 80.51,159.26 C512.1 79.19,159.74 79.05,159.88 Q57.6
C_INT_DP_AUXP: length 35.5
  IN4 w0.086: v1(85.32,162.17) 85.27,162.22 85.12,162.22 85.03,162.13 85.03,161.85 85.15,161.74 85.5,161.74 86.7,162.93 87.62,162.93 88.86,164.16 88.86,165.18 88.69,165.35 88.55,165.35 CN2.15
  BOTTOM w0.14: U39.24 88.65,152.5 88.57,152.58 87.96,152.58 87.4,153.14 87.4,154.9 87.16,155.14 87.16,155.48 R664.2 86.99,156 87.13,156.14 87.13,159.1 87.49,159.46 87.49,160.63 88.01,161.15 88.01,162.34 87.68,162.67 85.37,162.67 85.17,162.46 85.17,162.32 v1(85.32,162.17) 85.11,161.96 85.11,161.37 ESD1.10 85.11,161.16 85.11,160.49 ESD1.1 85.15,160.32 85.15,159.51 85.45,159.2 85.45,158.07 85.13,157.74 84.73,157.74 R661.1 84.38,157.55 84.02,157.91 81.99,157.91 80.96,158.94 80.65,158.94 80.31,158.59 C521.1 80.03,158.06 79.86,157.89 Q60.6
C_OUT_DP_TXN0: length 13.3
  TOP w0.14: C31.1 90.81,160.25 90.71,160.35 90.71,160.57 90.82,160.68 90.91,160.68 91.1,160.87 D8.2 90.85,160.93 90.7,161.08 90.7,162.06 90.02,162.74 89.37,162.74 88.36,163.74 84.85,163.74 84.14,164.46 82.34,164.46 81.94,164.86 81.94,165 82.14,165.2 CN2.3
C_OUT_DP_TXN1: length 16.9
  TOP w0.14: CN2.6 83.52,166.32 83.52,166.14 83.19,165.81 80.92,165.81 80.57,165.46 80.57,164.26 81.39,163.44 83.89,163.44 84.37,162.96 88.05,162.96 88.49,162.52 88.49,161.26 88.77,160.97 D2.2 88.9,160.83 88.82,160.75 88.61,160.75 88.5,160.63 88.5,160.43 88.63,160.3 C25.1
C_OUT_DP_TXN2: length 21.5
  TOP w0.14: CN2.9 85.05,164.85 85.05,164.71 85.24,164.52 88.51,164.52 89.03,164.01 89.48,164.01 90.11,164.63 90.91,164.63 91.24,164.31 91.24,163.44 91.07,163.26 91.07,163 91.41,162.65 91.62,162.65 91.76,162.79 91.76,164.91 92.09,165.24 92.69,165.24 93.2,164.73 93.2,164.13 93.34,163.99 93.94,163.99 94.51,163.42 94.51,162.91 94.19,162.58 93.48,162.58 93.42,162.65 93.08,162.65 92.94,162.51 92.94,162.09 93.08,161.95 93.08,161.12 93.24,160.96 D4.2 93.49,160.87 93.35,160.74 93.17,160.74 93.04,160.6 93.04,160.43 93.18,160.29 C27.1
C_OUT_DP_TXN3: length 20.6
  TOP w0.14: C29.1 95.41,160.26 95.33,160.34 95.33,160.48 95.47,160.62 95.68,160.62 95.78,160.73 D6.2 95.75,160.94 95.24,161.44 95.24,162.05 96.03,162.84 96.61,162.84 96.92,162.53 97.88,162.53 98.28,162.93 98.28,163.95 97.59,164.65 94.65,164.65 94.07,165.22 93.21,166.08 86.81,166.08 86.62,166.27 86.62,166.42 CN2.12
C_OUT_DP_TXP0: length 13.2
  TOP w0.14: C30.1 90.24,160.25 90.38,160.39 90.38,160.57 90.26,160.7 90.01,160.7 89.93,160.78 D7.2 90.23,160.93 90.38,161.08 90.38,161.93 89.88,162.42 89.24,162.42 88.23,163.43 84.72,163.43 84.01,164.14 82.21,164.14 81.62,164.73 81.62,164.98 CN2.1
C_OUT_DP_TXP1: length 16.9
  TOP w0.14: CN2.4 83.2,166.4 83.2,166.27 83.06,166.12 80.79,166.12 80.26,165.6 80.26,164.13 81.26,163.12 83.76,163.12 84.24,162.64 87.92,162.64 88.17,162.39 88.17,161.24 87.9,160.97 D1.2 87.75,160.87 87.9,160.72 88.08,160.72 88.18,160.62 88.18,160.4 88.08,160.3 C24.1
C_OUT_DP_TXP2: length 21.5
  TOP w0.14: CN2.7 84.74,164.86 84.74,164.57 85.1,164.21 88.38,164.21 88.9,163.69 89.61,163.69 90.24,164.32 90.78,164.32 90.92,164.18 90.92,163.57 90.75,163.39 90.75,162.87 91.28,162.33 91.75,162.33 92.08,162.66 92.08,164.78 92.22,164.92 92.56,164.92 92.88,164.6 92.88,163.99 93.21,163.67 93.81,163.67 94.19,163.28 94.19,163.04 94.05,162.9 93.61,162.9 93.55,162.97 92.94,162.97 92.62,162.64 92.62,161.96 92.76,161.82 92.76,161.17 92.56,160.96 D3.2 92.27,160.84 92.41,160.7 92.61,160.7 92.71,160.6 92.71,160.46 92.54,160.29 C26.1
C_OUT_DP_TXP3: length 20.6
  TOP w0.14: C28.1 94.87,160.26 95.01,160.4 95.01,160.62 94.91,160.72 94.7,160.72 94.56,160.86 D5.2 94.6,160.94 94.93,161.27 94.93,162.18 95.9,163.15 96.74,163.15 97.05,162.84 97.75,162.84 97.96,163.06 97.96,163.82 97.45,164.33 94.52,164.33 93.76,165.09 93.08,165.77 86.68,165.77 86.3,166.14 86.3,166.4 86,166.7 CN2.10
C_OUT_EDP_TXN0: length 34.3
  IN4 w0.086: v1(180.36,100.23) 180.01,99.88 179.76,99.88 179.65,99.99 179.65,101.65 178.14,103.17 176.73,103.17 174.51,105.38 174.51,105.91 173.62,106.8 173.62,108.46 173.71,108.54 174.84,108.54 175.04,108.74 175.04,109.32 174.84,109.51 173.71,109.51 172.97,110.25 172.97,114.65 172.77,114.85 172.32,114.85 172.22,114.94 172.22,115.35 172.31,115.44 172.77,115.44 172.97,115.64 172.97,116.54 172.68,116.83 171.39,116.83 v1(171.14,117.08)
  BOTTOM w0.14: U41.39 178.73,95.01 178.78,95.06 178.78,95.38 179.28,95.88 179.28,99.44 179.76,99.92 180.04,99.92 v1(180.36,100.23) ; C628.1 172.05,117.05 171.17,117.05 v1(171.14,117.08)
C_OUT_EDP_TXN1: length 34.3
  IN4 w0.086: v1(171.07,118.62) 170.77,118.31 170.6,118.31 170.15,117.86 170.15,115.09 171.79,113.45 171.79,107.82 171.99,107.63 172.56,107.63 172.65,107.54 172.65,107.13 172.55,107.03 171.99,107.03 171.79,106.83 171.79,106.26 171.99,106.06 172.52,106.06 172.61,105.97 172.61,105.57 172.5,105.47 171.99,105.47 171.79,105.27 171.79,104.36 173.17,102.98 175.43,102.98 177.02,101.39 177.02,100.61 177.29,100.34 177.6,100.34 177.69,100.24 v1(177.69,99.99)
  BOTTOM w0.14: v1(177.69,99.99) 177.95,100.25 178.17,100.25 178.31,100.11 178.31,96.91 177.57,96.17 177.57,95.04 177.53,95 U41.36 ; C619.1 171.94,118.47 171.23,118.47 171.2,118.5 171.2,118.5 v1(171.07,118.62)
C_OUT_EDP_TXN2: length 34.3
  IN4 w0.086: v1(171.16,120.15) 170.88,119.86 170.37,119.86 169.45,118.94 169.45,113.76 171.04,112.17 171.04,109.48 170.56,109 170.56,104.52 172.76,102.32 175.16,102.32 176.37,101.11 176.37,100.01 176.82,99.56 176.82,98.3 177.01,98.1 177.31,98.1 v1(177.67,97.74)
  BOTTOM w0.14: v1(177.67,97.74) 177.37,98.04 177,98.04 176.69,97.73 176.69,95.1 176.73,95.06 U41.34 ; C610.1 171.98,120.03 171.28,120.03 v1(171.16,120.15)
C_OUT_EDP_TXN3: length 34.3
  IN4 w0.086: v1(174.91,98.95) 174.55,99.31 174.31,99.31 167.88,105.73 167.88,118.85 170.45,121.42 170.73,121.42 170.85,121.41 v1(171.11,121.66)
  BOTTOM w0.14: C601.1 171.92,121.49 171.28,121.49 v1(171.11,121.66) ; U41.31 175.53,94.99 175.45,95.07 174.49,96.03 174.49,97.79 174.25,98.02 174.25,98.97 174.4,99.13 174.73,99.13 v1(174.91,98.95)
C_OUT_EDP_TXP0: length 34.3
  IN4 w0.086: v1(180.36,99.33) 180.36,99.38 180.05,99.7 179.68,99.7 179.46,99.92 179.46,101.58 178.06,102.98 176.65,102.98 174.32,105.31 174.32,105.83 173.43,106.72 173.43,108.53 173.63,108.73 174.77,108.73 174.85,108.82 174.85,109.24 174.77,109.33 173.63,109.33 172.78,110.17 172.78,114.57 172.69,114.66 172.24,114.66 172.04,114.87 172.04,115.43 172.23,115.63 172.69,115.63 172.78,115.72 172.78,116.46 172.6,116.64 171.25,116.64 171.12,116.51 v1(171.12,116.38)
  BOTTOM w0.14: U41.40 179.13,95.02 179.1,95.05 179.1,95.25 179.6,95.75 179.6,99.3 179.89,99.6 180.09,99.6 v1(180.36,99.33) ; v1(171.12,116.38) 171.48,116.73 171.99,116.73 172.13,116.59 C635.1
C_OUT_EDP_TXP1: length 34.3
  IN4 w0.086: v1(171.07,117.9) 170.84,118.13 170.68,118.13 170.34,117.78 170.34,115.17 171.98,113.53 171.98,107.9 172.06,107.81 172.64,107.81 172.84,107.62 172.84,107.05 172.63,106.84 172.06,106.84 171.98,106.76 171.98,106.34 172.06,106.25 172.6,106.25 172.8,106.05 172.8,105.5 172.58,105.28 172.06,105.28 171.98,105.19 171.98,104.44 173.25,103.17 175.51,103.17 177.21,101.46 177.21,100.69 177.37,100.53 177.52,100.53 177.69,100.7 v1(177.69,100.89)
  BOTTOM w0.14: C626.1 172.13,118 171.99,118.15 171.32,118.15 v1(171.07,117.9) ; v1(177.69,100.89) 178.02,100.57 178.31,100.57 178.63,100.24 178.63,96.78 177.89,96.04 177.89,95.04 177.93,95 U41.37
C_OUT_EDP_TXP2: length 34.3
  IN4 w0.086: v1(171.14,119.42) 170.88,119.68 170.45,119.68 169.64,118.86 169.64,113.83 171.22,112.25 171.22,109.4 170.75,108.93 170.75,104.59 172.83,102.51 175.23,102.51 176.55,101.19 176.55,100.09 177.01,99.64 177.01,98.38 177.09,98.29 177.31,98.29 v1(177.67,98.64)
  BOTTOM w0.14: C616.1 171.84,119.71 171.43,119.71 v1(171.14,119.42) ; v1(177.67,98.64) 177.37,98.35 176.87,98.35 176.37,97.86 176.37,95.06 176.33,95.02 U41.33
C_OUT_EDP_TXP3: length 34.3
  IN4 w0.086: v1(174.91,99.85) 174.55,99.49 174.39,99.49 168.07,105.81 168.07,118.77 170.53,121.23 170.72,121.23 170.84,121.22 v1(171.09,120.96)
  BOTTOM w0.14: v1(171.09,120.96) 171.31,121.18 171.9,121.18 C606.1 ; U41.30 175.13,94.94 174.17,95.9 174.17,97.65 173.93,97.89 173.93,99.1 174.27,99.44 174.5,99.44 v1(174.91,99.85)
C_PEG_TXN0: length 9
  TOP w0.089: U3.B10 120.5,110.78 120.57,110.71 120.57,110.59 120.46,110.48 118.3,110.48 118.17,110.35 117.5,110.35 117.45,110.4 117.43,110.4
  TOP w0.14: 117.43,110.4 117.3,110.4 114.65,107.74 113.65,107.74 113.48,107.91 C90.2
C_PEG_TXN1: length 7.3
  TOP w0.089: 117.44,110.97 117.47,110.97 117.51,111.01 118,111.01 118.3,111.32 118.84,111.32 119.07,111.09 119.89,111.09 120.11,111.31 120.11,111.44 U3.B11
  TOP w0.14: C89.2 114.75,108.78 114.91,108.78 117.1,110.97 117.44,110.97
