# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_WRXN1: length 182.7
  TOP w0.102: v1(201.69,26.08) 202.16,26.54 203.27,26.54 203.36,26.64 203.89,26.64 204.13,26.4 204.13,26.36 U14.BA3
  IN2 w0.089: v1(201.69,26.08) 201.84,26.08 202,25.92 202,25.79 201.83,25.62 201.08,25.62 200.67,26.03 200.67,26.53 201.25,27.11 202.03,27.11 202.36,26.78 203.13,26.78 204.21,27.85 204.21,29.07 203.23,30.05 202.93,30.05 202.3,30.67 201.76,30.67 200.86,31.58 200.86,31.71 195.09,37.48 193.12,37.48 189.03,41.57 189.03,41.99 188.58,42.44 187.31,42.44 186.3,43.44 186.3,43.83 185.8,44.33 184.24,44.33 183.68,43.77 182.51,43.77 181.96,44.31 181.96,45.56 181.11,46.41 177.26,46.41 176.59,45.73 176.59,40.47 174.36,38.24 107.89,38.24 107.67,38.46 101.51,38.46 100.27,39.7 100.27,40.12 98.97,41.42 96.79,41.42 95.47,40.11 95.13,40.11 94.72,39.71 88.51,39.71 88.34,39.54 87.66,39.54 87.32,39.88 86.68,39.88 86.45,39.65 85.98,39.65 85.78,39.85 82.27,39.85 80.87,38.45 77.97,38.45 77.75,38.67 76.94,38.67 76.34,38.07 74.94,38.07 73.66,39.35 72.48,39.35 71.59,40.23 68.92,40.23 68.66,39.97 68.08,39.97 67.89,40.16 63.83,40.16 63.36,39.69 62.76,39.69 62.66,39.8 62.66,39.89 v1(62.97,40.2)
  BOTTOM w0.14: CN16.9 58.26,34.75 58.37,34.87 59.17,34.87 60.29,35.98 60.29,37.01 62.39,39.11 62.39,39.25 62.73,39.6 62.73,39.97 v1(62.97,40.2)
CNV_WRXP0: length 182.3
  TOP w0.102: U14.BB4 204.52,25.37 204.2,25.69 203.52,25.69 203.14,25.32 202.03,25.32 201.59,24.88 201.59,24.63 v1(201.38,24.41)
  IN2 w0.089: v1(201.38,24.41) 201.61,24.41 201.72,24.53 201.72,24.65 201.53,24.85 200.45,24.85 199.88,25.41 199.88,27.43 200.47,28.02 203.17,28.02 203.42,28.28 203.42,28.75 203.09,29.09 202.53,29.09 201.96,29.66 201.43,29.66 201.11,29.34 200.39,29.34 200.08,29.65 200.08,31.22 198.6,32.69 198.21,32.69 197.34,33.56 197.34,34.01 194.65,36.7 192.81,36.7 188.43,41.08 187.57,41.08 186.98,41.67 185.08,41.67 184.72,42.04 181.82,42.04 181.46,42.4 181.46,43.72 181.18,43.99 181.18,44.67 180.28,45.57 178.36,45.57 177.85,45.07 177.85,43.38 177.45,42.98 177.45,40.15 174.77,37.47 107.41,37.47 107.2,37.68 101.15,37.68 99.47,39.35 99.47,39.74 99.01,40.2 96.66,40.2 95.74,39.27 95.47,39.27 95.13,38.93 91.84,38.93 91.35,38.44 86.78,38.44 86.59,38.63 83.57,38.63 82.4,37.46 81.28,37.46 81.08,37.66 78.49,37.66 78.12,37.29 74.59,37.29 73.36,38.53 72.15,38.53 71.63,39.05 70.87,39.05 70.67,38.86 69.23,38.86 68.94,39.15 67.43,39.15 67.2,39.39 64.21,39.39 63.71,38.88 62.33,38.88 61.32,39.89 61.32,40.03 61.09,40.27 v1(61,40.27)
  BOTTOM w0.14: CN16.17 58.28,36.75 58.51,36.52 58.98,36.52 59.16,36.7 59.16,37.4 61.23,39.47 61.23,40.04 v1(61,40.27)
CNV_WRXP1: length 182.7
  TOP w0.102: v1(202.52,25.93) 202.37,25.78 202.22,25.78 202.1,25.9 202.1,26.2 202.24,26.34 203.36,26.34 203.45,26.43 203.81,26.43 203.93,26.31 203.93,26.21 203.86,26.15 203.86,25.98 203.93,25.91 204.02,25.91 U14.BA2
  IN2 w0.089: v1(202.52,25.93) 202.28,25.93 202.19,25.84 202.19,25.71 201.91,25.43 201,25.43 200.48,25.95 200.48,26.61 201.17,27.3 202.11,27.3 202.44,26.97 203.05,26.97 204.01,27.93 204.01,28.99 203.15,29.86 202.85,29.86 202.23,30.48 201.69,30.48 200.67,31.5 200.67,31.63 195.01,37.29 193.04,37.29 188.84,41.49 188.84,41.91 188.5,42.25 187.23,42.25 186.11,43.37 186.11,43.75 185.73,44.14 184.32,44.14 183.76,43.58 182.43,43.58 181.77,44.24 181.77,45.48 181.03,46.22 177.34,46.22 176.78,45.66 176.78,40.39 174.44,38.05 107.81,38.05 107.59,38.27 101.43,38.27 100.08,39.62 100.08,40.04 98.89,41.23 96.87,41.23 95.55,39.92 95.21,39.92 94.8,39.51 88.59,39.51 88.42,39.35 87.59,39.35 87.24,39.69 86.76,39.69 86.53,39.46 85.9,39.46 85.7,39.66 82.35,39.66 80.95,38.26 77.89,38.26 77.67,38.48 77.02,38.48 76.41,37.88 74.86,37.88 73.58,39.16 72.4,39.16 71.51,40.04 69,40.04 68.74,39.78 68,39.78 67.81,39.97 63.91,39.97 63.44,39.5 62.69,39.5 62.47,39.72 62.47,40.06 v1(62.3,40.22)
  BOTTOM w0.14: CN16.11 58.27,35.25 58.38,35.14 59.06,35.14 60.02,36.1 60.02,37.12 62.12,39.22 62.12,39.36 62.47,39.71 62.47,40.06 v1(62.3,40.22)
CNV_WT_CLKN: length 182.2
  TOP w0.102: U14.BC5 206.29,25.25 v1(206.33,25.29)
  IN2 w0.089: v1(206.33,25.29) 205.96,25.29 205.57,24.9 205.57,24.69 204.87,24 203.95,24 203.02,23.07 200.34,23.07 198.21,25.19 198.21,27.35 198.49,27.63 198.49,30.1 198.76,30.37 198.76,30.67 198.42,31.01 197.62,31.01 196.34,32.29 194.19,32.29 192.81,33.67 192.41,33.67 191.83,34.25 191.83,35.81 189.16,38.48 188.01,38.48 186.14,40.35 184.52,40.35 184.17,40.71 183.47,40.71 183.12,40.35 179.54,40.35 175.32,36.13 106.83,36.13 106.67,36.29 100.53,36.29 99.18,37.64 97.09,37.64 96.49,37.04 94.38,37.04 93.96,36.62 93.18,36.62 92.69,37.11 90.2,37.11 89.62,36.53 88.41,36.53 87.83,37.11 84.57,37.11 84.4,36.93 83.75,36.93 82.8,35.99 82.12,35.99 81.85,35.72 79.88,35.72 79.01,34.85 76.55,34.85 76.34,35.06 73.43,35.06 71.42,37.08 68.88,37.08 68.66,37.29 66.67,37.29 66.4,37.55 61.79,37.55 60.74,38.6 60.17,38.6 58.21,40.56 58.21,45.72 57.4,46.53 57.4,49.24 56.28,50.36 55.89,50.36 v1(55.63,50.1)
  BOTTOM w0.14: CN16.71 56.42,50.25 56.28,50.39 55.93,50.39 v1(55.63,50.1)
CNV_WT_CLKP: length 182.2
  TOP w0.102: v1(205.79,25.75) 205.83,25.79 U14.BB6
  IN2 w0.089: v1(55.63,50.95) 55.63,50.74 55.82,50.55 56.36,50.55 57.59,49.32 57.59,46.61 58.4,45.79 58.4,40.64 60.25,38.79 60.82,38.79 61.87,37.75 66.48,37.75 66.74,37.48 68.74,37.48 68.96,37.27 71.5,37.27 73.51,35.25 76.42,35.25 76.63,35.04 78.93,35.04 79.8,35.91 81.77,35.91 82.04,36.18 82.72,36.18 83.67,37.13 84.32,37.13 84.49,37.3 87.9,37.3 88.49,36.72 89.54,36.72 90.12,37.3 92.77,37.3 93.26,36.81 93.88,36.81 94.3,37.23 96.41,37.23 97.01,37.83 99.26,37.83 100.61,36.49 106.75,36.49 106.91,36.32 175.24,36.32 179.46,40.54 183.04,40.54 183.4,40.9 184.25,40.9 184.6,40.54 186.22,40.54 188.09,38.68 189.23,38.68 192.02,35.89 192.02,34.33 192.49,33.86 192.89,33.86 194.27,32.48 196.42,32.48 197.7,31.2 198.5,31.2 198.95,30.75 198.95,30.29 198.68,30.02 198.68,27.55 198.41,27.27 198.41,25.27 200.41,23.26 202.94,23.26 203.87,24.19 204.79,24.19 205.38,24.77 205.38,24.98 205.79,25.38 v1(205.79,25.75)
  BOTTOM w0.14: v1(55.63,50.95) 55.63,50.8 55.77,50.66 56.33,50.66 56.42,50.75 CN16.73
CNV_WTXN0: length 182.5
  TOP w0.102: v1(207.38,22.47) 207.38,22.6 207.28,22.7 206.9,22.7 206.48,23.12 206.48,23.49 206.32,23.65 206.32,23.79 206.48,23.94 206.48,24.1 206.43,24.14 U14.BE6
  IN2 w0.089: v1(207.38,22.47) 207.36,22.5 207.36,22.58 207.24,22.7 206.32,22.7 206.06,22.95 205.9,23.12 204.01,23.12 203.3,22.41 200.04,22.41 198.71,23.74 198.22,23.74 197.55,24.4 197.55,28.61 197.8,28.85 197.8,29.9 196.07,31.63 193.92,31.63 192.57,32.97 192.17,32.97 191.17,33.98 191.17,35.17 189.04,37.29 188.87,37.29 188.33,37.82 187.73,37.82 185.91,39.65 179.77,39.65 175.6,35.47 106.53,35.47 106.37,35.63 100.07,35.63 99.48,36.22 95.83,36.22 95.78,36.28 94.56,36.28 94.23,35.95 92.06,35.95 91.68,36.33 90.39,36.33 89.8,35.73 88.21,35.73 87.88,36.06 85.41,36.06 84.68,35.33 82.44,35.33 82.16,35.05 80.14,35.05 79.29,34.19 76.17,34.19 75.97,34.39 72.44,34.39 70.86,35.97 68,35.97 67.61,36.36 66.61,36.36 66.09,36.88 61.53,36.88 60.47,37.94 59.9,37.94 57.54,40.3 57.54,45.45 56.71,46.28 56.71,48.38 56.15,48.95 55.76,48.95 55.59,48.78 v1(55.59,48.6)
  BOTTOM w0.14: v1(55.59,48.6) 55.89,48.89 56.28,48.89 56.42,48.75 CN16.65
CNV_WTXN1: length 181.6
  TOP w0.102: v1(206.27,21.95) 206.1,21.95 206.01,22.04 206.01,22.24 206.18,22.41 206.18,22.84 206.27,22.93 206.27,23.3 206.19,23.38 206.09,23.38 206,23.29 U14.BG6
  IN2 w0.089: v1(206.27,21.95) 206.04,21.72 206.04,21.51 205.71,21.19 200.85,21.19 200.25,21.8 199.71,21.8 198.78,22.73 197.99,22.73 196.93,23.79 196.93,29.05 197.21,29.33 197.21,29.66 195.82,31.04 193.67,31.04 193.05,31.66 192.48,31.66 190.51,33.64 190.51,35 188.83,36.68 188.59,36.68 188.09,37.18 187.5,37.18 185.61,39.06 180.02,39.06 175.84,34.88 166.01,34.88 165.46,34.33 148.23,34.33 148.14,34.24 112.79,34.24 112.16,34.88 106.18,34.88 106.02,35.04 99.68,35.04 99.18,35.54 95.61,35.54 95.45,35.7 94.82,35.7 94.48,35.36 92.14,35.36 91.89,35.11 88,35.11 87.66,35.44 85.8,35.44 85.06,34.7 82.81,34.7 82.52,34.42 80.34,34.42 79.46,33.54 78.59,33.54 78.37,33.32 76.95,33.32 76.69,33.07 76.01,33.07 75.29,33.78 71.8,33.78 70.72,34.86 68.92,34.86 68.4,35.38 67.75,35.38 67.35,35.77 66.35,35.77 65.83,36.29 63.07,36.29 62.64,35.85 62.11,35.85 61.74,36.23 60.69,36.23 56.93,39.99 56.93,42.35 56.43,42.85 56.43,43.27 56.75,43.59 56.75,44.03 56.53,44.24 56.53,44.9 56.73,45.1 56.73,45.43 56.09,46.08 56.09,47.27 56,47.36 55.75,47.36 v1(55.62,47.24)
  BOTTOM w0.14: v1(55.62,47.24) 55.7,47.31 56.58,47.31 56.64,47.25 CN16.59
CNV_WTXP0: length 182.5
  TOP w0.102: v1(207.59,23.06) 207.44,22.91 206.98,22.91 206.68,23.21 206.68,24.19 206.49,24.38 U14.BD7
  IN2 w0.089: v1(207.59,23.06) 207.42,22.89 206.4,22.89 205.98,23.31 203.93,23.31 203.22,22.6 200.12,22.6 198.79,23.93 198.3,23.93 197.75,24.48 197.75,28.53 197.99,28.77 197.99,29.98 196.15,31.82 194,31.82 192.65,33.16 192.25,33.16 191.36,34.06 191.36,35.25 189.12,37.48 188.94,37.48 188.41,38.01 187.81,38.01 185.98,39.84 179.69,39.84 175.52,35.66 106.61,35.66 106.45,35.82 100.15,35.82 99.56,36.41 95.91,36.41 95.86,36.47 94.49,36.47 94.15,36.14 92.13,36.14 91.76,36.52 90.32,36.52 89.72,35.92 88.29,35.92 87.96,36.25 85.33,36.25 84.6,35.52 82.36,35.52 82.08,35.24 80.07,35.24 79.21,34.38 76.25,34.38 76.05,34.58 72.51,34.58 70.93,36.16 68.08,36.16 67.69,36.55 66.69,36.55 66.17,37.07 61.61,37.07 60.55,38.13 59.98,38.13 57.73,40.38 57.73,45.53 56.9,46.36 56.9,48.46 56.22,49.14 55.91,49.14 v1(55.59,49.45)
  BOTTOM w0.14: CN16.67 56.42,49.25 56.33,49.16 55.89,49.16 v1(55.59,49.45)
CNV_WTXP1: length 181.6
  TOP w0.102: v1(205.61,21.95) 205.8,22.15 205.8,22.32 205.98,22.5 205.98,22.77 205.75,23 205.75,23.33 206,23.59 U14.BF6
  IN2 w0.089: v1(205.61,21.95) 205.85,21.72 205.85,21.59 205.64,21.38 200.93,21.38 200.32,21.99 199.79,21.99 198.86,22.92 198.07,22.92 197.12,23.87 197.12,28.97 197.4,29.25 197.4,29.73 195.9,31.23 193.74,31.23 193.13,31.85 192.56,31.85 190.7,33.72 190.7,35.08 188.9,36.87 188.66,36.87 188.17,37.37 187.58,37.37 185.69,39.25 179.94,39.25 175.76,35.07 165.93,35.07 165.38,34.52 148.15,34.52 148.06,34.43 112.87,34.43 112.23,35.07 106.26,35.07 106.1,35.23 99.76,35.23 99.26,35.73 95.69,35.73 95.53,35.89 94.74,35.89 94.4,35.55 92.06,35.55 91.81,35.3 88.08,35.3 87.74,35.63 85.72,35.63 84.98,34.89 82.73,34.89 82.45,34.61 80.26,34.61 79.38,33.73 78.51,33.73 78.29,33.51 76.87,33.51 76.61,33.26 76.09,33.26 75.37,33.97 71.88,33.97 70.8,35.05 68.99,35.05 68.48,35.57 67.82,35.57 67.43,35.96 66.43,35.96 65.91,36.48 62.99,36.48 62.56,36.04 62.19,36.04 61.82,36.42 60.77,36.42 57.12,40.07 57.12,42.43 56.62,42.93 56.62,43.19 56.94,43.51 56.94,44.11 56.72,44.32 56.72,44.82 56.92,45.02 56.92,45.51 56.28,46.15 56.28,47.35 56.08,47.55 55.89,47.55 55.62,47.82 v1(55.62,47.93)
  BOTTOM w0.14: CN16.61 56.65,47.75 56.47,47.58 55.97,47.58 v1(55.62,47.93)
COMP_4PH_A: length 4
  TOP w0.203: PR33.1 170.4,167.57 PC25.2 171.92,167.57 v1(172.11,167.38) 172.58,166.91 PU2.6
CON_UTC_D1N: length 10.4
  TOP w0.14: CN4.A7 290.74,28.2 290.62,28.08 290.01,28.08 289.64,28.45 289.64,30.07 289.1,30.62 289.1,31.13 287.55,32.68 287.55,32.94 286.91,33.58 286.53,33.58 D46.2 286.02,33.59 285.7,33.59 285.56,33.72 L6.2 285.12,33.72 R327.2
CON_UTC_D1P: length 10.4
  TOP w0.14: CN4.A6 290.78,27.7 290.66,27.82 289.9,27.82 289.38,28.34 289.38,29.96 288.83,30.51 288.83,31.02 287.28,32.57 287.28,32.83 286.8,33.31 286.53,33.31 D47.2 286.01,33.32 285.67,33.32 285.52,33.17 L6.3 285.12,33.17 R342.2
CON_UTC_D2N: length 11.6
  BOTTOM w0.14: R899.2 285.17,32.3 L34.2 285.54,32.3 285.68,32.44 286.32,32.44 D103.2 286.84,32.44 287.38,32.44 287.98,31.84 288.33,31.84 289.03,31.14 289.03,30.72 289.46,30.28 289.46,28.46 290.1,27.82 292.58,27.82 CN4.B7
CON_UTC_D2P: length 11.6
  BOTTOM w0.14: R892.2 285.17,32.85 L34.3 285.57,32.85 285.72,32.71 286.32,32.71 D101.2 286.84,32.71 287.49,32.71 288.09,32.11 288.44,32.11 289.3,31.25 289.3,30.83 289.73,30.39 289.73,28.57 290.21,28.08 292.58,28.08 CN4.B6
CON_UTC_RX1N: length 34.9
  TOP w0.14: C373.1 267.87,26.22 267.87,26.46 R397.2 267.91,27.28 267.91,27.45 v1(268.2,27.74)
  IN1 w0.086: v1(282.37,30.8) 282.05,30.48 280.98,30.48 278.21,27.72 270.77,27.72 270.16,27.11 268.24,27.11 267.91,27.43 267.91,27.65 268,27.74 v1(268.2,27.74)
  BOTTOM w0.14: v1(282.37,30.8) 282.57,30.6 283.15,30.6 283.29,30.46 285.15,30.46 285.43,30.74 286.54,30.74 286.75,30.53 287.48,30.53 D104.2 288.06,30.5 288.06,30.5 288.07,30.48 288.17,30.48 288.37,30.48 288.84,30.02 288.84,28.08 289.43,27.5 289.43,26.53 289.98,25.98 291.66,25.98 292.37,25.26 293.3,25.26 CN4.B10
CON_UTC_RX1P: length 35.2
  TOP w0.14: C372.1 267.61,26.33 267.61,26.6 R396.2 267.65,27.27 267.65,27.45 v1(267.35,27.74)
  IN1 w0.086: v1(267.35,27.74) 267.62,27.74 267.75,27.61 267.75,27.36 268.17,26.94 270.23,26.94 270.84,27.55 278.28,27.55 281.05,30.32 282.16,30.32 v1(282.39,30.09)
  BOTTOM w0.14: v1(282.39,30.09) 282.63,30.33 283.04,30.33 283.18,30.19 285.26,30.19 285.54,30.47 286.43,30.47 286.64,30.26 287.48,30.26 D105.2 287.98,30.22 288.08,30.22 288.26,30.22 288.58,29.9 288.58,27.97 289.16,27.39 289.16,26.42 289.87,25.71 291.55,25.71 292.26,25 293.34,25 CN4.B11
CON_UTC_RX2N: length 42.2
  TOP w0.14: v1(261.81,28.04) 261.61,27.84 261.61,27.24 R399.2 261.65,26.47 261.65,25.94 261.75,25.83 C378.1 ; CN4.A10 290.76,29.7 290.65,29.81 290.44,29.81 290.19,30.06 290.19,30.32 289.69,30.82 289.69,31.72 290.01,32.04 290.01,33.04 289.68,33.37 289.27,33.37 D48.2 288.61,33.38 287.94,33.38 287.38,33.94 287.38,34.37 287.09,34.66 286.15,34.66 285.73,35.08 283.72,35.08 v1(283.51,34.87)
  IN1 w0.086: v1(283.51,34.87) 283.24,35.13 279.79,35.13 278.99,34.33 278.99,32.4 276.07,29.48 270.45,29.48 269.96,29.96 266.97,29.96 266.52,29.51 265.2,29.51 264.19,28.5 261.65,28.5 261.56,28.42 261.56,28.29 v1(261.81,28.04)
CON_UTC_RX2P: length 42.4
  TOP w0.14: v1(283.53,35.58) 283.76,35.35 285.84,35.35 286.26,34.93 287.2,34.93 287.65,34.48 287.65,34.05 288.05,33.65 288.63,33.65 D45.2 289.27,33.64 289.79,33.64 290.28,33.15 290.28,31.93 289.96,31.61 289.96,30.93 290.46,30.43 290.46,30.18 290.55,30.08 290.68,30.08 290.81,30.2 CN4.A11 ; C377.1 261.28,25.83 261.38,25.94 261.38,26.47 R398.2 261.35,27.17 261.35,27.82 v1(261.13,28.04)
  IN1 w0.086: v1(283.53,35.58) 283.25,35.3 279.72,35.3 278.82,34.4 278.82,32.47 276,29.65 270.52,29.65 270.03,30.13 266.9,30.13 266.45,29.68 265.13,29.68 264.12,28.67 261.58,28.67 261.4,28.48 261.4,28.31 v1(261.13,28.04)
CON_UTC_SBU1: length 72.7
  TOP w0.14: CN4.A8 290.42,28.7 v1(290.37,28.64) ; v1(291.06,34.41) 291.2,34.41 291.47,34.68 291.47,34.73 290.98,35.22 D41.2 291.09,35.35 291.22,35.35 291.36,35.49 291.36,36.74 291.22,36.88 v1(291.03,36.88) ; R595.2 257.78,13.87 257.32,13.87 C477.2 256.77,13.92 256.57,13.92 v1(256.41,13.76) ; C429.2 256.72,20.83 256.39,20.83 v1(256.23,20.67)
  IN1 w0.086: v1(291.06,34.41) 291.4,34.07 291.4,33.62 290.12,32.34 290.12,30.66 291.29,29.49 291.29,27.95 291.09,27.76 289.73,27.76 289.58,27.91 289.58,28.41 289.81,28.64 v1(290.37,28.64)
  IN2 w0.089: v1(291.03,36.88) 291.36,37.21 291.36,37.34 291.07,37.62 286.3,37.62 285.31,38.61 284.25,38.61 282.66,37.02 281.52,37.02 281.11,36.62 281.11,35.98 280.26,35.13 278.96,35.13 278.36,34.53 278.36,32.03 277.22,30.89 274.01,30.89 272,28.88 267.69,28.88 266.91,28.11 266.91,26.67 264.48,24.25 262.39,24.25 262.1,23.95 262.1,23.29 260.13,21.33 259.8,21.33 259.1,20.63 257.52,20.63 257.31,20.84 256.41,20.84 v1(256.23,20.67) 256.22,20.65 256.22,20.35 257.02,19.55 257.02,14.32 256.75,14.05 256.7,14.05 v1(256.41,13.76)
CON_UTC_SBU2: length 73.3
  TOP w0.14: v1(291.91,34.41) 291.74,34.58 291.74,34.98 D42.2 291.95,35.23 291.62,35.56 291.62,36.63 v1(291.88,36.88) ; v1(256.39,14.43) 256.63,14.19 256.85,14.19 C477.1 257.33,14.14 257.77,14.14 R571.2 ; C425.2 256.65,21.1 256.43,21.1 v1(256.22,21.31)
  IN1 w0.086: CN4.B8 292.62,26.18 291.81,26.18 291.45,26.54 291.45,29.56 290.29,30.73 290.29,32.27 291.57,33.55 291.57,34.07 v1(291.91,34.41)
  IN2 w0.089: v1(256.39,14.43) 256.41,14.43 256.59,14.24 256.67,14.24 256.83,14.4 256.83,19.48 255.82,20.48 255.82,20.95 256.19,21.31 v1(256.22,21.31) 256.5,21.04 257.38,21.04 257.6,20.82 259.02,20.82 259.73,21.52 260.06,21.52 261.91,23.37 261.91,24.03 262.31,24.44 264.4,24.44 266.72,26.75 266.72,28.19 267.61,29.07 271.93,29.07 273.93,31.08 277.14,31.08 278.17,32.11 278.17,34.61 278.89,35.32 280.18,35.32 280.92,36.06 280.92,36.69 281.44,37.21 282.58,37.21 284.17,38.8 285.39,38.8 286.38,37.81 291.15,37.81 291.55,37.41 291.55,37.21 v1(291.88,36.88)
CON_UTC_TX1N: length 34
  TOP w0.14: v1(283.3,31.77) 283.4,31.67 284.79,31.67 285.54,30.93 286.35,30.93 286.79,30.5 287.26,30.5 D50.2 287.86,30.51 288.04,30.51 288.82,29.73 288.82,28.11 289.43,27.5 289.43,26.58 289.98,26.03 290.57,26.03 290.74,26.2 CN4.A3 ; C374.1 265.36,26.12 265.36,26.65 v1(265.26,26.75)
  IN1 w0.086: v1(283.3,31.77) 283.03,31.49 281.04,31.49 277.92,28.36 269.92,28.36 269.42,28.86 267.5,28.86 266.71,28.07 265.89,28.07 265.54,27.72 265.54,27.03 v1(265.26,26.75)
CON_UTC_TX1P: length 34
  TOP w0.14: v1(265.91,26.74) 265.62,26.45 265.62,26.12 265.88,25.86 C375.1 ; v1(283.36,31.06) 283.71,31.41 284.68,31.41 285.43,30.66 286.24,30.66 286.68,30.23 287.34,30.23 D51.2 287.83,30.24 287.93,30.24 288.55,29.62 288.55,28 289.16,27.39 289.16,26.47 289.85,25.78 290.68,25.78 290.77,25.7 CN4.A2
  IN1 w0.086: v1(265.91,26.74) 265.7,26.95 265.7,27.65 265.96,27.91 266.78,27.91 267.56,28.69 269.36,28.69 269.85,28.2 277.99,28.2 281.11,31.32 283.09,31.32 v1(283.36,31.06)
CON_UTC_TX2N: length 40.6
  TOP w0.14: C380.1 263.9,25.68 263.71,25.68 263.54,25.85 263.54,26.81 264.07,27.35 264.26,27.35 v1(264.48,27.12)
  IN1 w0.086: v1(282.26,33.62) 282.01,33.86 281.77,33.86 281.27,33.36 281.27,32.4 279.35,30.47 278.1,30.47 276.47,28.85 270.17,28.85 269.69,29.33 267.29,29.33 266.84,28.88 265.76,28.88 265.55,28.67 265.55,28.41 265.07,27.93 265.07,27.56 264.88,27.37 264.73,27.37 v1(264.48,27.12)
  BOTTOM w0.14: CN4.B3 293.39,30.55 292.55,30.55 292.47,30.47 290.45,30.47 289.87,31.05 289.87,32.13 290.02,32.28 290.02,32.98 289.62,33.38 289.28,33.38 D102.2 288.62,33.37 288.05,33.37 287.5,33.93 287.5,34.26 287.06,34.7 286.09,34.7 285.7,35.09 284.9,35.09 283.6,33.79 282.43,33.79 v1(282.26,33.62)
CON_UTC_TX2P: length 40.7
  TOP w0.14: v1(264.46,27.81) 264.26,27.61 263.96,27.61 263.27,26.92 263.27,26.07 C379.1
  IN1 w0.086: v1(264.46,27.81) 264.73,27.54 264.82,27.54 264.9,27.62 264.9,28 265.39,28.48 265.39,28.74 265.69,29.04 266.77,29.04 267.22,29.49 269.75,29.49 270.24,29.01 276.4,29.01 278.03,30.64 279.28,30.64 281.11,32.47 281.11,33.43 281.7,34.03 281.98,34.03 v1(282.26,34.31)
  BOTTOM w0.14: CN4.B2 293.25,30.81 292.44,30.81 292.36,30.74 290.56,30.74 290.14,31.16 290.14,32.02 290.29,32.17 290.29,33.09 289.73,33.65 289.26,33.65 D100.2 288.62,33.64 288.16,33.64 287.76,34.04 287.76,34.37 287.17,34.97 286.2,34.97 285.81,35.35 284.79,35.35 283.49,34.05 282.52,34.05 v1(282.26,34.31)
CORE_PLLVDD: length 4.6
  TOP w0.2: UG1.BD21 51.21,98.49 v2(51.48,98.49) ; UG1.BD12 44.3,98.75 v2(44.18,98.87) 44.44,99.13 44.44,99.24 44.65,99.45 UG1.BC12
  TOP w0.254: UG1.BD15 46.78,98.75 v2(47.12,98.4) ; v2(44.14,111.85) 43.95,111.66 UG1.AF11
  TOP w0.3: UG1.BB24 53.36,100.46 v2(53.41,100.46) ; UG1.BD18 49.19,98.4 49.19,98.42 v2(49.19,98.42) ; v2(65.21,117.44) 65.44,117.44 UG1.U42
  vias: v1(23.06,101.45) v1(23.05,100.8) v1(25.22,100.19)
CPU_2_PCH_TRIG: length 163.9
  TOP w0.102: v1(202.18,31.69) 202.51,31.69 202.53,31.72 204.24,31.72 U14.AK2
  TOP w0.14: v1(110.1,126.33) 110.1,126.56 110.35,126.81 R63.1
  IN2 w0.089: v1(190.03,56.08) 189.68,55.73 189.48,55.73 189.14,55.39 189.14,51.1 192.35,47.89 192.35,44.19 192.45,44.09 192.45,43.63 192.35,43.53 192.35,42.2 194.41,40.14 194.7,40.14 195.1,39.73 195.1,39.29 196.46,37.94 196.46,37.28 202.05,31.69 v1(202.18,31.69)
  IN4 w0.086: v1(190.03,56.08) 190.03,56.34 189.61,56.75 189.44,56.75 189.14,57.06 187.08,57.06 184.97,59.16 184.97,59.9 182.98,61.9 182.75,61.9 181.47,63.18 181.36,63.18 181.35,63.19 181.34,63.19 180.43,64.1 180.43,64.73 164.84,80.32 125.14,80.32 122.39,83.07 121.55,83.07 109.24,95.37 109.24,104.34 109.76,104.85 109.76,110.64 109.2,111.2 109.2,125.25 110.1,126.15 v1(110.1,126.33)
CPU_2_PCH_TRIG_R: length 25.3
  TOP w0.089: v1(125.27,121.4) 124.88,121.01 U3.J23
  TOP w0.14: R63.2 111.82,127.56 v1(111.98,127.71)
  IN4 w0.086: v1(125.27,121.4) 124.75,121.91 124.75,125.43 125.29,125.97 125.29,127.33 124.66,127.96 124.66,129.08 124.57,129.17 123.81,129.17 121.84,131.14 114.57,131.14 113.18,129.76 113.18,128.91 v1(111.98,127.71)
CPU_PCI_BCLKN: length 164.2
  TOP w0.089: U14.B6 206,45.39 205.73,45.67 205.73,46.61 205.45,46.89 205.45,48.16 204.97,48.63 204.97,49.56 204.86,49.67 204.73,49.67 v1(204.53,49.47)
  TOP w0.102: U3.C36 120.97,129.69 v1(120.78,129.5)
  IN4 w0.086: v1(204.53,49.47) 204.3,49.7 204.13,49.7 203.74,50.09 203.74,53.04 200.83,55.95 192.61,55.95 191.02,57.53 189.77,57.53 189.45,57.85 187.39,57.85 185.76,59.49 185.76,60.22 183.3,62.68 183.08,62.68 182.2,63.56 182.2,64.67 180.47,66.4 179.87,66.4 165.16,81.1 125.54,81.1 122.79,83.85 121.87,83.85 110.02,95.7 110.02,102.3 110.92,103.2 110.92,104.53 112.01,105.62 112.01,106.17 113.43,107.59 113.43,110.3 114.73,111.6 114.73,127.53 116.33,129.13 119.82,129.13 120.14,128.81 120.83,128.81 121.21,129.19 121.21,129.41 121.12,129.5 v1(120.78,129.5)
CPU_PCI_BCLKP: length 164.4
  TOP w0.089: U14.A6 205.91,45.91 205.91,46.68 205.63,46.96 205.63,48.23 205.15,48.71 205.15,49.64 204.93,49.85 204.79,49.85 v1(204.53,50.12)
  TOP w0.102: U3.D35 121.33,129.54 121.22,129.65 121.22,129.85 121.36,129.99 v1(121.72,129.99)
  IN4 w0.086: v1(204.53,50.12) 204.27,49.86 204.2,49.86 203.9,50.16 203.9,53.11 200.9,56.11 192.68,56.11 191.09,57.7 189.83,57.7 189.52,58.02 187.46,58.02 185.92,59.56 185.92,60.29 183.37,62.84 183.15,62.84 182.36,63.63 182.36,64.74 180.54,66.56 179.94,66.56 165.23,81.26 125.61,81.26 122.86,84.01 121.94,84.01 110.19,95.77 110.19,102.23 111.08,103.13 111.08,104.46 112.17,105.55 112.17,106.1 113.59,107.52 113.59,110.23 114.89,111.53 114.89,127.46 116.4,128.97 119.75,128.97 120.07,128.64 120.9,128.64 121.38,129.12 121.38,129.64 v1(121.72,129.99)
CPU_PLTRST#: length 1.9
  TOP w0.14: U14.AG5 205.69,32.75 206.19,32.75 v1(206.52,33.08)
  BOTTOM w0.14: v1(206.52,33.08) 206.64,33.2 R887.1
CPU_PLTRST#R: length 144.7
  TOP w0.127: U3.BP35 158.91,129.37 159.25,129.03 v1(160.75,129.03)
  IN2 w0.089: v1(160.75,129.03) 161.93,127.85 164,127.85 164.34,127.51 167.49,127.51 170.11,124.88 171.01,124.88 173.18,122.71 173.18,112.31 176.51,108.98 176.96,108.98 177.29,108.65 177.29,103.23 178.16,102.36 178.16,93.22 178.53,92.86 178.53,90.44 177.77,89.68 177.77,86.26 175.69,84.18 175.69,81.23 174.87,80.41 174.87,73.82 175.69,73 175.69,65.73 178.3,63.12 180.46,63.12 182.19,61.39 182.19,60.42 182.7,59.9 183.17,59.9 187.3,55.77 v1(188.66,55.77)
  IN3 w0.089: v1(188.66,55.77) 188.66,56.06 192.31,59.71 193.31,59.71 193.84,59.18 193.84,58.31 197.4,54.75 197.4,47.89 194.31,44.8 194.31,41.56 196.34,39.54 196.34,38.46 199.98,34.82 203.6,34.82 204.33,35.55 204.33,35.86 204.81,36.34 205.12,36.34 205.81,37.03 206.99,37.03 207.32,36.71 v1(207.32,36.1)
  BOTTOM w0.14: v1(207.32,36.1) 207.32,35.41 207.89,34.83 207.89,34.24 R887.2
CPU_THERMDA: length 7.9
  BOTTOM w0.14: U38.2 23.06,157.8 22.42,158.44 v1(22.42,158.52) 22.42,158.64 23.22,159.44 C519.1 23.8,159.44 24.45,158.79 Q59.3 25.06,159.18 25.84,159.95 26.85,159.95 Q59.2
CPU_THERMDC: length 5.8
  BOTTOM w0.14: U38.3 23.71,157.73 23.34,158.1 C519.2 23.91,158.66 v1(24.15,158.41) 24.43,158.41 25,157.84 Q59.1
CPU_VCCIO_PWR_GATE: length 23
  TOP w0.14: PR289.1 185.9,47.08 186.23,46.75 186.23,42.76 186.2,42.73 186.2,34.56 v1(188.35,32.41) 188.98,31.78 R351.1 190.16,32.44 190.16,32.78 190.34,32.96 191.89,32.96 192.17,32.68 192.17,32.03 Q34.3
CRISIS_DISK_ENABLE: length 1.5
  TOP w0.14: R365.1 v1(88.66,30.39)
  BOTTOM w0.14: v1(88.66,30.39) 88.73,30.33 R912.1
CSCL: length 3.2
  BOTTOM w0.14: R654.2 54.03,158.74 53.79,158.74 53.4,159.13 v1(53.09,159.13) 53.09,159.44 52.82,159.71 U34.29
CSCOMP_4PH_A: length 29.4
  TOP w0.203: PU2.8 172.58,166.11 172.52,166.06 v1(172.03,166.06) 171.45,166.06 PC36.1 PC35.2 169.83,166.34 169.69,166.49 PR40.1 ; PR117.2 171.38,146.05 v1(171.09,146.35)
  IN3 w0.203: v1(171.09,146.35) 171.28,146.54 171.53,146.54 172.15,147.16 172.15,156.75 169.97,158.94 169.97,165.35 170.35,165.73 171.7,165.73 v1(172.03,166.06)
  BOTTOM w0.203: PR447.1 171.38,166.06 v1(172.03,166.06)
CSDA: length 3.6
  BOTTOM w0.14: R660.2 54.63,159.07 v1(54.49,159.07) 53.86,159.07 53.22,159.71 U34.28
CSN_1PH: length 88.1
  TOP w0.203: v1(126.76,156.89) 126.54,156.89 125.47,157.95 PR79.2 ; v1(119.55,147.87) 119.09,147.87 PR114.2 ; PC9.2 PC4.1 177.05,173.85 v1(176.17,173.85)
  IN4 w0.203: v1(176.17,173.85) 176.78,173.85 177.06,173.57 177.06,172.84 176.73,172.51 174.9,172.51 173.97,171.58 173.16,171.58 172.45,170.87 171.53,170.87 170.27,172.13 170.27,172.89 168.93,174.24 147.2,174.24 144.44,171.47 142.64,171.47 138.65,167.48 136.59,167.48 134.54,165.42 128.46,165.42 126.64,163.6 126.64,157.01 v1(126.76,156.89) 126.76,148.63 125.39,147.26 121.23,147.26 120.62,147.87 v1(119.55,147.87)
  BOTTOM w0.203: PR430.1 176.17,173.74 v1(176.17,173.85)
CSP1_3PH_A: length 8.9
  TOP w0.203: PU2.11 172.88,164.91 172.46,164.5 172.46,164.27 172.46,164.26 v1(172.46,163.76) 171.93,163.76 171.93,163.76 PC50.2 ; PR73.2 170.49,160.12 v1(170.43,160.06)
  BOTTOM w0.203: v1(170.43,160.06) 170.43,162.22 171.97,163.76 v1(172.46,163.76)
CSP2_3PH_A: length 11.9
  TOP w0.203: PC54.2 172.05,162.78 172.36,163.09 v1(172.4,163.09) 172.49,163.09 172.99,163.59 172.99,164.34 173.16,164.51 PU2.12 ; v1(167.67,167.42) 167.82,167.56 PR31.2
  IN4 w0.203: v1(167.67,167.42) 168.73,166.36 168.73,164.77 170.41,163.09 v1(172.4,163.09)
CSP3_3PH_A: length 17.9
  TOP w0.191: 173.34,163.83 173.62,164.11 PU2.13
  TOP w0.203: PC58.2 171.55,161.79 v1(172.64,161.79) 172.64,162.62 173.34,163.32 173.34,163.83 ; v1(167.76,172.05) 167.85,171.97 PR18.2
  IN4 w0.203: v1(167.76,172.05) 167.76,170.6 169.67,168.7 169.67,167.33 171.52,165.47 172.1,165.47 173.22,164.35 173.22,162.37 v1(172.64,161.79)
CSP4_4PH_A: length 22.8
  TOP w0.191: 179.42,162.92 179.23,163.11 PU2.26
  TOP w0.203: 179.42,162.92 180.1,162.92 180.31,162.72 180.31,162.09 180.62,161.77 PC64.1 180.88,161.17 v1(181.32,161.61) ; v1(170.52,171.14) 170.52,171 170.16,170.64 PR20.1
  IN1 w0.203: v1(181.32,161.61) 179.42,163.52 179.42,168.04 178.89,168.57 176.55,168.57 173.68,171.44 172.43,171.44 172.13,171.14 v1(170.52,171.14)
CSREF_4PH_A: length 98.7
  TOP w0.203: v1(158.69,158.49) 158.59,158.39 PR81.2 ; PR82.2 v1(137.05,158.54) ; v1(147.82,158.54) PR83.2 ; PU2.10 172.76,165.31 171.99,164.54 PC50.1 171.23,164.54 170.76,165.01 v1(170.73,165.01) 170.73,164.55 170.77,164.5 PC54.1 170.77,162.29 170.75,162.26 PC58.1 170.75,161.59 171.02,161.32 171.02,161.02 171.31,160.73 PR76.2 ; PC64.2 179.84,160.83 180.08,160.6 v1(181.35,160.6)
  BOTTOM w0.203: 147.44,167.27 146.99,167.27 145.97,168.29 141.1,168.29 136.8,163.98 136.8,160.57 137.05,160.32 v1(137.05,159.23) v1(137.05,158.54) ; 147.44,167.27 151.63,167.27 152.55,168.19 156.84,168.19 158.39,166.64 ; 147.44,167.27 147.44,160.09 147.82,159.71 v1(147.82,158.54) ; 158.39,166.64 158.51,166.51 158.51,159.17 158.69,158.99 v1(158.69,158.49) ; 158.39,166.64 158.39,166.67 158.96,167.24 165.82,167.24 166.64,166.41 169.36,166.41 170.73,165.04 v1(170.73,165.01) 170.76,165.04 172.1,165.04 172.78,165.72 PC300.1 173.22,164.88 173.22,163.08 172.54,162.4 171.98,162.4 170.96,161.38 170.96,158.21 171.75,157.42 178.92,157.42 181.35,159.85 v1(181.35,160.6)
CSSUM_4PH_A: length 15.5
  TOP w0.203: v1(168.57,168.14) 168.57,168.57 167.82,169.32 PR30.2 PR24.2 168.56,170.35 PR19.2 ; PU2.9 172.62,165.71 172.31,165.4 171.33,165.4 PC36.2 PC35.1 PR49.1 169.11,165.54 169.11,165.04 v1(169.26,164.89) 169.74,164.41 PR68.2
  IN4 w0.203: v1(168.57,168.14) 169.26,167.45 v1(169.26,164.89)
CTL0_DP: length 8.4
  TOP w0.14: v1(88.06,151.3) 88.78,151.3 89.17,150.9 89.17,150.63 90.84,148.97 R23.2 90.84,147.64 v1(90.06,146.86)
  BOTTOM w0.14: R671.2 v1(90.06,146.86) ; U39.22 88.46,151.7 v1(88.06,151.3)
CTL0_EDP: length 5.8
  BOTTOM w0.14: U41.22 173.5,91.5 173.15,91.15 173.15,90.41 172.17,89.44 R713.2 171.47,88.89 170.74,88.89 170.2,89.42 R714.2
CTL0_TBT_SDA: length 4.3
  TOP w0.14: R209.2 240.45,43.5 v1(241.73,43.5) 241.85,43.5 242.22,43.87 U10.22
  BOTTOM w0.14: C782.2 241.95,43.27 v1(241.73,43.5)
CTL1_DP: length 4.9
  BOTTOM w0.14: R667.2 R668.2 R670.1 87.09,152.82 v1(87.47,152.44) 87.81,152.1 U39.23
CTL1_EDP: length 6.3
  BOTTOM w0.14: R710.1 169.82,90.45 R712.2 170.37,90.95 171.52,90.95 R711.2 172.34,90.45 172.81,90.92 172.81,91.33 173.38,91.9 U41.23
CTL1_TBT_HPDIN: length 3.7
  TOP w0.14: R210.2 R211.1 241.96,42.85 v1(242.46,43.35) 242.62,43.51 U10.23
  BOTTOM w0.14: v1(242.46,43.35) 242.96,42.85 R826.2
CTL2_1: length 6.4
  TOP w0.14: U8.7 18.08,51.8 17.93,51.96 17.93,52.15 v1(17.64,52.43) 17.56,52.43 16.93,51.81 16.93,51.29 16.68,51.04 14.01,51.04 13.91,51.14 R165.2
CTL2_2: length 1.4
  TOP w0.254: U11.7 16.84,45.54 17.27,45.97 R183.2
CTL2_3: length 2.3
  TOP w0.14: U26.7 280.1,16.02 v1(280.14,15.98)
  BOTTOM w0.14: R1085.1 279.55,16.44 279.68,16.44 v1(280.14,15.98)
CTL3_1: length 2.5
  TOP w0.14: R166.2 15.81,50.76 17.34,50.76 17.58,51.01 U8.8
CTL3_2: length 1.3
  TOP w0.254: R182.2 16.5,45.86 16.34,45.7 U11.8
CTL3_3: length 2.1
  TOP w0.14: v1(280.82,15.99) 280.79,15.99 280.6,16.18 U26.8
  BOTTOM w0.14: R1084.1 280.21,16.58 280.79,15.99 v1(280.82,15.99)
D/C#: length 1.7
  TOP w0.14: PR253.1 99.45,52.72 TP23.1 99.69,52.8 99.69,53.27 PC182.2
DCI_EN: length 11
  TOP w0.14: U30.12 275.27,9.32 v1(275.24,9.29)
  BOTTOM w0.14: v1(275.24,9.29) 275.75,9.8 277.26,9.8 277.95,9.11 279.93,9.11 282.33,6.71 R1142.2 283.48,5.93 R1143.1
DCIN_ENB: length 13.1
  TOP w0.14: v1(59.18,165.75) 59.18,164.82 R3.1
  IN2 w0.089: v1(59.18,165.75) 58.57,165.75 58.01,165.19 52.91,165.19 50.79,167.31 v1(50.79,167.96)
  BOTTOM w0.14: U34.3 50.82,167.94 v1(50.79,167.96)
DDCCLK_NOR: length 3.2
  BOTTOM w0.14: R677.2 9.61,140.13 9.47,140.52 9.47,141.32 9.54,141.76 9.59,141.93 9.75,142.04 Q62.4
DDCCLK_NOR-1: length 5.1
  BOTTOM w0.14: Q62.3 7.37,142.04 7.27,142.15 7.27,143.98 7.4,144.12 7.75,144.12 7.88,143.99 7.88,143.29 8.01,143.16 R675.1
DDCDATA_NOR: length 3.1
  BOTTOM w0.14: Q62.1 9.11,140.74 9.2,140.66 9.2,140.46 9.03,140.29 9.03,140.09 9.42,139.7 9.42,139.5 9.31,139.39 9.13,139.39 8.89,139.62 R678.2
DDCDATA_NOR-1: length 5.1
  BOTTOM w0.14: Q62.6 11.38,140.74 11.86,141.22 11.86,142.13 10.82,143.16 R674.1
DDI1_TX0_DN: length 2.9
  TOP w0.14: U10.39 245.71,49.21 245.75,49.25 246.19,49.25 arc(246.38,49.29) 246.54,49.4 246.89,49.75 arc(246.95,49.79) 247.02,49.8 247.41,49.8 arc(247.58,49.77) 247.73,49.67 C173.2
DDI1_TX0_DN_C: length 12.1
  TOP w0.089: U7.AC7 258.03,53.4 arc(258.09,53.38) 258.15,53.35 arc(258.17,53.29) 258.15,53.23 258.12,53.2 arc(258.07,53.17) 258.02,53.16 257.78,53.16 arc(257.74,53.17) 257.7,53.19 257.62,53.27 arc(257.59,53.3) 257.54,53.3 256.6,53.3 arc(256.57,53.3) 256.55,53.28 arc(256.48,53.25) 256.41,53.23
  TOP w0.14: C173.1 248.37,49.67 arc(248.53,49.78) 248.72,49.81 252.61,49.81 arc(253.31,49.95) 253.91,50.35 254.21,50.65 arc(254.42,50.95) 254.51,51.3 arc(254.65,51.81) 254.95,52.25 255.89,53.18 arc(255.95,53.22) 256.01,53.23 256.41,53.23
DDI1_TX0_DP: length 2.9
  TOP w0.14: U10.40 245.75,49.61 245.79,49.57 246.19,49.57 arc(246.26,49.59) 246.32,49.62 246.67,49.97 arc(246.83,50.08) 247.02,50.12 247.41,50.12 arc(247.59,50.15) 247.75,50.26 C168.2
DDI1_TX0_DP_C: length 12.1
  TOP w0.089: U7.AB7 258.36,53.47 258.33,53.5 258.29,53.54 258.26,53.57 arc(258.21,53.61) 258.14,53.62 257.89,53.62 arc(257.8,53.6) 257.71,53.55 arc(257.63,53.5) 257.54,53.48 256.61,53.48 arc(256.58,53.49) 256.55,53.5 arc(256.48,53.54) 256.41,53.55
  TOP w0.14: C168.1 248.31,50.3 arc(248.5,50.17) 248.72,50.13 252.61,50.13 arc(253.19,50.25) 253.69,50.58 253.98,50.87 arc(254.13,51.08) 254.19,51.33 arc(254.36,51.95) 254.73,52.47 255.66,53.41 arc(255.82,53.51) 256.01,53.55 256.41,53.55
DDI1_TX1_DN: length 2.7
  TOP w0.14: C188.2 247.65,48.22 arc(247.58,48.27) 247.49,48.29 arc(247.41,48.28) 247.34,48.24 arc(247.08,48.09) 246.79,48.04 245.8,48.04 arc(245.77,48.03) 245.74,48.01 U10.36
DDI1_TX1_DN_C: length 12.3
  TOP w0.089: U7.AC9 258.02,52.48 arc(258.1,52.46) 258.16,52.42 arc(258.19,52.35) 258.16,52.28 arc(258.11,52.25) 258.06,52.24 257.85,52.24 arc(257.79,52.25) 257.73,52.28 arc(257.67,52.31) 257.61,52.32 256.62,52.32 arc(256.59,52.32) 256.56,52.3 arc(256.51,52.26) 256.46,52.25 256.41,52.25
  TOP w0.14: 256.41,52.25 256.39,52.25 arc(256.33,52.24) 256.29,52.21 255.83,51.75 arc(255.68,51.53) 255.63,51.28 arc(255.52,50.74) 255.22,50.28 254.23,49.29 arc(253.17,48.59) 251.93,48.34 248.7,48.34 arc(248.58,48.32) 248.47,48.25 C188.1
DDI1_TX1_DP: length 2.7
  TOP w0.14: U10.37 245.69,48.41 arc(245.73,48.4) 245.77,48.38 arc(245.81,48.36) 245.86,48.36 246.79,48.36 arc(246.98,48.39) 247.14,48.48 arc(247.3,48.57) 247.49,48.61 arc(247.61,48.63) 247.72,48.7 C183.2
DDI1_TX1_DP_C: length 12.3
  TOP w0.089: U7.AB9 258.25,52.66 258.25,52.66 arc(258.18,52.7) 258.09,52.71 257.88,52.71 arc(257.8,52.69) 257.72,52.65 257.61,52.54 arc(257.58,52.51) 257.53,52.5 256.61,52.5 arc(256.58,52.51) 256.56,52.52 arc(256.49,52.56) 256.41,52.57
  TOP w0.14: 256.41,52.57 256.39,52.57 arc(256.21,52.54) 256.06,52.43 255.6,51.97 arc(255.39,51.65) 255.31,51.28 arc(255.23,50.86) 254.99,50.51 254,49.52 arc(253.05,48.88) 251.93,48.66 248.53,48.66 arc(248.44,48.68) 248.35,48.73 C183.1
DDI1_TX2_DN: length 2.7
  TOP w0.14: U10.34 245.68,47.21 arc(245.72,47.21) 245.75,47.19 arc(245.79,47.18) 245.83,47.17 246.38,47.17 arc(246.51,47.16) 246.63,47.11 arc(246.75,47.07) 246.88,47.06 247.42,47.06 arc(247.58,47.09) 247.72,47.19 C194.2
DDI1_TX2_DN_C: length 12.2
  TOP w0.089: U7.AC11 258.07,51.56 arc(258.15,51.59) 258.18,51.67 arc(258.18,51.71) 258.16,51.74 258.15,51.75 arc(258.11,51.78) 258.05,51.79 257.84,51.79 arc(257.77,51.78) 257.71,51.74 257.68,51.71 257.57,51.6 arc(257.55,51.59) 257.52,51.58 257.5,51.58 arc(257.23,51.53) 257,51.37 256.52,50.89 arc(256.46,50.83) 256.41,50.77
  TOP w0.14: C194.1 248.27,47.27 arc(248.35,47.1) 248.52,47.03 250.72,47.03 arc(252.73,47.43) 254.43,48.57 255.97,50.1 arc(256.13,50.3) 256.25,50.51 arc(256.32,50.64) 256.41,50.77
DDI1_TX2_DP: length 2.7
  TOP w0.14: C202.2 247.75,46.6 arc(247.59,46.7) 247.42,46.74 246.88,46.74 arc(246.68,46.76) 246.49,46.83 246.49,46.83 arc(246.44,46.85) 246.38,46.85 245.81,46.85 arc(245.78,46.85) 245.74,46.84 arc(245.7,46.82) 245.66,46.81 U10.33
DDI1_TX2_DP_C: length 12.2
  TOP w0.089: U7.AB11 258.29,51.41 258.27,51.39 arc(258.21,51.35) 258.13,51.33 257.85,51.33 arc(257.8,51.34) 257.76,51.37 arc(257.74,51.39) 257.71,51.4 arc(257.71,51.4) 257.71,51.4 arc(257.69,51.4) 257.68,51.4 257.5,51.4 arc(257.3,51.36) 257.13,51.25 256.64,50.77 arc(256.57,50.58) 256.54,50.38
  TOP w0.14: C202.1 248.34,46.59 arc(248.48,46.68) 248.65,46.71 250.72,46.71 arc(252.85,47.14) 254.66,48.34 256.19,49.88 arc(256.39,50.11) 256.54,50.38
DDI1_TX3_DN: length 2.8
  TOP w0.14: U10.31 245.74,46.01 arc(245.81,46.01) 245.88,45.99 arc(245.94,45.97) 246,45.97 246.45,45.97 arc(246.64,45.93) 246.8,45.82 247.02,45.6 arc(247.08,45.56) 247.15,45.55 247.45,45.55 arc(247.6,45.58) 247.72,45.66 C204.2
DDI1_TX3_DN_C: length 12.3
  TOP w0.089: U7.AC13 257.99,50.64 arc(258.07,50.65) 258.14,50.69 258.14,50.69 arc(258.17,50.73) 258.18,50.77 arc(258.17,50.82) 258.14,50.85 arc(258.11,50.87) 258.08,50.87 257.9,50.87 arc(257.81,50.85) 257.74,50.8 257.66,50.73 arc(257.65,50.69) 257.64,50.64 arc(257.63,50.58) 257.59,50.53 257.07,50.01 arc(257,49.93) 256.96,49.84 256.82,49.52 arc(256.8,49.48) 256.78,49.44 256.56,49.23 arc(256.52,49.2) 256.47,49.19 arc(256.44,49.18) 256.41,49.17
  TOP w0.14: C204.1 248.33,45.71 arc(248.47,45.62) 248.63,45.58 249.15,45.58 arc(249.21,45.59) 249.26,45.62 arc(249.48,45.73) 249.73,45.77 250.55,45.77 arc(252.82,46.23) 254.74,47.51 256.39,49.16 arc(256.4,49.16) 256.41,49.17
DDI1_TX3_DP: length 2.8
  TOP w0.14: U10.30 245.73,45.61 arc(245.78,45.62) 245.82,45.63 arc(245.83,45.64) 245.85,45.64 arc(245.87,45.65) 245.89,45.65 246.45,45.65 arc(246.52,45.63) 246.58,45.6 246.8,45.37 arc(246.96,45.27) 247.15,45.23 247.45,45.23 arc(247.58,45.2) 247.7,45.12 C209.2
DDI1_TX3_DP_C: length 12.3
  TOP w0.089: U7.AB13 258.25,50.45 arc(258.21,50.42) 258.16,50.41 257.77,50.41 arc(257.76,50.41) 257.74,50.41 arc(257.71,50.4) 257.69,50.38 257.19,49.88 arc(257.15,49.83) 257.12,49.77 256.99,49.45 arc(256.95,49.38) 256.9,49.32 256.68,49.1 arc(256.66,49.06) 256.65,49.01 arc(256.64,48.97) 256.61,48.93
  TOP w0.14: 256.61,48.93 254.97,47.29 arc(252.94,45.93) 250.55,45.46 249.73,45.46 arc(249.58,45.43) 249.44,45.36 arc(249.3,45.29) 249.15,45.27 248.63,45.27 arc(248.55,45.25) 248.48,45.21 C209.1
DDPB_CLK: length 11.8
  TOP w0.14: U14.AL13 209.19,31.8 v1(209.19,31.87)
  BOTTOM w0.14: R874.1 201.19,34.66 203.27,34.66 204.33,33.6 204.33,33.05 205.08,32.3 208.78,32.3 209.19,31.89 v1(209.19,31.87)
DDPB_DATA: length 9.9
  TOP w0.14: U14.AR8 206.99,29.03 207.41,28.62 v1(207.41,28.62)
  BOTTOM w0.14: R893.1 v1(201.07,32.65) 201.45,32.27 202.6,32.27 203.4,31.47 203.4,30.83 203.88,30.34 204.26,30.34 204.77,29.84 205.89,29.84 206.55,29.18 206.85,29.18 207.41,28.62 v1(207.41,28.62)
DDPB_HPD0: length 13.3
  TOP w0.14: U14.AT6 206.43,28.84 206.85,28.42 v1(206.85,28.34)
  BOTTOM w0.14: R1004.2 200.62,22.88 202.98,22.88 v1(203.47,23.37) 203.89,23.8 204.58,23.8 205.05,23.33 205.68,23.33 206.83,24.48 206.83,25.72 206.32,26.23 206.32,27.41 206.85,27.94 v1(206.85,28.34)
DDPC_CLK: length 14.2
  TOP w0.14: U14.AN13 209.72,30.65 v1(209.67,30.7)
  BOTTOM w0.14: v1(209.67,30.7) 209.65,30.72 209.65,32.11 209.19,32.58 205.2,32.58 204.61,33.17 204.61,34.08 v1(203.96,34.73) 203.51,35.18 201.1,35.18 200.93,35.35 200.93,35.89 R862.1
DDPC_DATA: length 9.5
  TOP w0.14: v1(207.71,31.77) 207.71,31.75 U14.AL10
  BOTTOM w0.14: R880.1 200.86,33.98 v1(201.29,33.98) 201.63,33.63 203.36,33.63 204.97,32.02 207.46,32.02 v1(207.71,31.77)
DDPD_CLK: length 11
  TOP w0.14: U14.AL9 207.61,31 207.83,30.79 v1(207.97,30.79)
  BOTTOM w0.14: R888.1 200.47,33.35 201.45,33.35 201.84,32.97 TP95.1 202.61,33.24 203.26,33.24 203.75,32.75 203.75,31.26 204.11,30.9 204.5,30.9 204.73,30.68 206.16,30.68 206.56,31.07 207.54,31.07 207.83,30.79 v1(207.97,30.79)
DDPD_DATA: length 7.3
  TOP w0.102: U14.AR3 204.37,29.25 204.18,29.25 204.03,29.4 202.64,29.4 202.28,29.76 200.98,29.76 v1(200.76,29.98)
  BOTTOM w0.14: v1(200.76,29.98) 201.41,30.63 TP100.1 201,31.6 R902.1
DDR0_ALERT#: length 82.4
  TOP w0.079: v1(148.21,102.31) 148.53,102.63 148.53,103.21 147.52,104.23 147.52,106.88 U3.AU5
  TOP w0.102: v1(143.2,40.26) 143.28,40.26 143.43,40.11 143.7,40.11 143.85,39.96 143.85,39.84 143.49,39.48 143.49,39.34 143.63,39.19 143.77,39.19 143.91,39.33 144.05,39.33 144.2,39.18 144.2,39.04 144.06,38.9 144.06,38.76 144.32,38.5 JDIM2.116
  IN2 w0.079: v1(148.21,102.31) 147.43,101.53 147.43,97.59 147.92,97.09
  IN2 w0.178: 147.92,97.09 148.41,96.6 148.41,94.69 149.98,93.12 149.98,82.99 148.09,81.1 148.09,59.41 146.41,57.73 146.41,50.51 144.85,48.95 144.85,45.61 144.43,45.19 144.43,44.31 143.64,43.52 143.64,40.71 v1(143.2,40.26)
  BOTTOM w0.102: JDIM4.116 142.42,44.26 142.67,44.01 142.67,40.8 v1(143.2,40.26)
DDR0_PAR: length 79.6
  TOP w0.079: 140.17,99.56 138.91,100.82 138.91,105.91 U3.AG3
  TOP w0.102: v1(136.32,41.88) 135.82,42.38 135.82,42.88 136.01,43.06 136.22,43.06 136.44,42.84 136.66,42.84 136.93,43.11 136.93,43.33 136.72,43.53 136.72,43.86 137.04,44.18 137.38,44.18 137.57,44.37 JDIM2.143
  TOP w0.267: v1(140.72,99.01) 140.17,99.56
  IN2 w0.178: v1(136.32,41.88) 136.35,41.92 136.35,45.15 135.65,45.86 135.65,51.05 135.09,51.6 135.09,54.28 135.32,54.51 135.32,55.99 136.02,56.69 136.02,57.61 136.49,58.07 136.49,64.86 136.91,65.28 136.91,84.01 141.27,88.37 141.27,93.41 140.84,93.84 140.84,98.89 v1(140.72,99.01)
  BOTTOM w0.102: JDIM4.143 135.67,38.11 135.54,38.25 135.25,38.25 135,38.5 135,38.92 135.77,39.69 135.77,41.34 v1(136.32,41.88)
DDR1_ALERT#: length 74.6
  TOP w0.089: v1(144.63,109.77) 144.78,109.77 U3.AR8
  TOP w0.102: v1(143.19,52.82) 143.19,52.7 143.31,52.58 143.58,52.58 143.63,52.63 143.63,53.21 143.73,53.31 143.88,53.31 143.98,53.21 143.98,52.45 143.8,52.28 143.8,52.15 143.98,51.97 143.98,51.82 143.91,51.74 143.53,51.74 143.41,51.62 143.41,51.48 143.53,51.36 144.14,51.36 144.32,51.17 JDIM1.116
  IN1 w0.079: v1(144.63,109.77) 144.63,109.66 144.25,109.28 144.25,108.85 144.63,108.48 144.63,104.53 144.73,104.42 144.73,103.9 144.41,103.59 144.41,102.61 144.37,102.57 144.37,97.9
  IN1 w0.152: 144.37,97.9 147.23,95.03 147.23,93.17 148.81,91.59 148.81,68.05 146.63,65.87 146.63,63.23 145.95,62.55 145.95,60.03 143.7,57.78 143.7,54.66 142.71,53.67 142.71,53.26 143.16,52.82 v1(143.19,52.82)
  BOTTOM w0.102: v1(143.19,52.82) 142.63,53.38 142.63,55.75 142.42,55.96 JDIM3.116
DDR1_PAR: length 70.5
  TOP w0.089: U3.AJ7 140.84,109.1 v1(141.06,109.1)
  TOP w0.102: v1(136.34,54.79) 135.87,55.26 135.87,56.07 136.08,56.28 136.54,56.28 137.57,57.32 JDIM1.143
  IN1 w0.079: v1(141.06,109.1) 141.06,108.72 139.92,107.58 139.92,105.43 139.52,105.03 139.52,97.08 139.22,96.78 139.22,96.25
  IN1 w0.152: v1(136.34,54.79) 136.37,54.83 136.37,55.36 136.04,55.7 136.04,57.1 136.3,57.37 136.3,57.9 136.08,58.12 136.08,58.56 136.3,58.78 136.3,59.11 136.08,59.32 136.08,59.64 136.3,59.86 136.3,60.33 135.19,61.45 135.19,66.36 137.61,68.78 137.61,71.32 138.13,71.84 138.13,73.16 138.99,74.01 138.99,87.27 139.14,87.43 139.77,87.43 139.93,87.59 139.93,87.88 139.77,88.04 139.14,88.04 138.99,88.19 138.99,88.49 139.14,88.65 139.51,88.65 139.67,88.8 139.67,89.1 139.52,89.26 139.14,89.26 138.99,89.41 138.99,94.96 139.22,95.19 139.22,96.25
  BOTTOM w0.102: v1(136.34,54.79) 135.67,54.13 JDIM3.143
DDR4_SUSON_2V5: length 87.6
  TOP w0.14: R458.2 63.39,20.72 v1(63.27,20.84) 63.27,21.06 63.56,21.35 v1(63.7,21.35) ; PR162.1 v1(92.25,70.43)
  IN2 w0.089: v1(60.67,48.65) 60.67,48.66 60.67,48.96 60.99,49.28 60.99,51.63 61.41,52.05 62.88,52.05 64.33,53.51 66.49,53.51 66.8,53.82 70.03,53.82 70.34,53.51 71.86,53.51 72.96,54.61 79.05,54.61 79.17,54.73 89.8,54.73 90.64,55.56 90.64,58.3 91.22,58.89 91.22,60.52 91.58,60.87 91.58,63.3 92.99,64.71 92.99,69.69 v1(92.25,70.43)
  IN4 w0.086: v1(60.67,48.65) 60.67,48.65 60.44,48.42 60.44,45.09 63.73,41.79 63.73,40.32 63.07,39.67 62.8,39.67 60.46,37.33 60.46,36.47 61.82,35.11 61.82,33.82 62.18,33.46 62.18,32.93 61.63,32.38 61.63,31.56 61.03,30.96 61.03,29.99 59.91,28.87 59.91,24.2 60.19,23.92 61.19,23.92 61.44,23.66 62.07,23.66 62.5,23.23 62.5,22.55 v1(63.7,21.35)
DDR_DRAMRST#: length 187.3
  TOP w0.102: v1(146.06,40.88) 146.32,40.61 JDIM2.108 146.32,37.02 ; v1(146.86,54.13) 146.24,53.51 146.24,51.54 146.32,51.46 JDIM1.108
  TOP w0.14: R437.2 231.91,22.32 232.13,22.55 232.86,22.55 C407.1 232.97,23.03 v1(232.3,23.03) ; R336.1 C322.2 146.59,32.25 C323.2 C319.2 145.73,34.17 C284.2 146.32,34.83 146.32,37.02
  IN1 w0.086: v1(187.89,63.94) 186.07,63.94 183.29,61.15 182.56,61.15 181.09,59.69 178.65,59.69 175.34,56.38 175.34,53.78 174.83,53.26 174.83,51.41 174.19,50.77 174.19,48.72 170.08,44.6 146.64,44.6 146.06,44.03 v1(146.06,40.88)
  IN2 w0.089: v1(232.3,23.03) 234.11,23.03 236.11,25.04 236.11,27.47 235.48,28.11 235.48,29.94 234.9,30.51 234.9,33.31 234.64,33.58 234.64,34.78 236.11,36.25 236.11,38.16 237.48,39.52 237.48,41.17 236.92,41.72 236.92,43.52 235.47,44.97 234.19,44.97 233.7,45.46 233.7,46.47 234.94,47.72 234.94,48.3 232.29,50.96 227.32,50.96 227.26,51.02 225.39,51.02 225.01,51.4 225.01,52.72 224.48,53.25 223.01,53.25 222.65,52.9 221.79,52.9 221.27,53.42 206.05,53.42 203.98,55.49 203.98,56.42 202.79,57.61 202.6,57.61 200.17,60.04 194.94,60.04 193.8,61.18 192.6,61.18 191.98,61.8 191.15,61.8 190.12,62.83 189.07,62.83 187.97,63.94 v1(187.89,63.94)
  IN4 w0.086: v1(146.86,54.13) 146.06,53.33 v1(146.06,40.88)
  BOTTOM w0.102: JDIM4.108 144.42,43.83 146.24,42.02 146.24,41.72 146.38,41.59 146.38,41.19 v1(146.06,40.88) ; v1(146.86,54.13) 145.9,55.1 145.9,55.67 144.42,57.14 JDIM3.108
DDR_DRAMRST#_L: length 6.5
  TOP w0.102: 229.16,24.85 228.47,25.54 226.96,25.54 226.89,25.46 226.55,25.46 226.46,25.37 U14.BB46
  TOP w0.14: 229.16,24.85 230.33,23.68 231.05,23.68 R437.1
DDR_PG_CNTL: length 5.3
  TOP w0.089: R90.2 164,112.73 v1(164,112.29) 163.74,112.02 163.02,112.02 162.13,112.91 U3.BT13
DDR_VTT: length 85.1
  TOP w0.203: PU27.2 158.38,23.7 v3(159.18,22.9)
  TOP w0.254: v1(106.88,40.49) 106.88,40.22 106.87,40.22 106.87,39.44 106.82,39.39 JDIM2.258 ; JDIM1.258 106.82,49.08 106.32,48.58 104.11,48.58 103.96,48.43 103.75,48.43 v1(103.71,48.39)
  TOP w0.381: C191.1 100.87,47.69 102.06,48.89 v1(102.08,48.89)
  TOP w0.508: v1(97.61,60.8) 98.32,61.51 100.12,61.51 102.15,59.48 102.15,58.39 102.66,57.88 v1(103.06,57.88)
  IN1 w0.508: v1(103.71,48.39) 103.4,48.7 103.4,51.88 103.35,51.93 103.35,52.03 102.2,53.18 102.2,55.13 102.89,55.82 102.89,57.11 103.06,57.28 v1(103.06,57.88)
  IN3 w1.016: 121.57,24.74 119.31,24.74 119,24.43 116.5,24.43 115.72,25.21 112.17,25.21 111.68,25.71 103.07,25.71 101.13,23.77 v1(101.13,23.59) ; 148.68,24.45 148.27,24.04 143.78,24.04 143.42,23.68 133.31,23.68 131.02,21.4 124.89,21.4
  BOTTOM w0.254: v1(103.06,57.88) 103.54,57.88 104.02,58.36 104.02,59.44 104.28,59.7 104.67,59.7 104.92,59.44 JDIM3.258 ; JDIM4.258 104.92,43.9 v1(104.97,43.85)
  BOTTOM w0.381: v1(103.71,48.39) 103.68,48.39 103.18,48.89 v1(102.08,48.89)
  vias: v1(97.83,60.14) v1(99.72,30.11) v1(100.35,30.38) v1(101.77,39.01) v1(101.92,39.64) v1(102.43,39.13) v3(157.73,21.86)
DDR_VTTT_PG_CTRL: length 112.8
  TOP w0.14: PR364.1 160.84,30.47 165.01,30.47 168.14,33.6 176.24,33.6 181.2,38.55 181.2,42.39 181.98,43.17 181.98,45.28 182.71,46.02 v1(182.71,46.5) ; R95.2 166.69,111.31 R92.1 167.69,111.32 168.07,111.71 Q12.3 169.14,111.71 v1(169.77,112.34)
  IN3 w0.089: v1(169.77,112.34) 170.3,112.34 173.13,109.5 173.13,93.94 173.69,93.38 173.69,88.64 173.02,87.96 173.02,87.29 173.41,86.9 173.41,86.41 171.79,84.79 171.79,81.31 172.16,80.93 172.16,67.3 175.56,63.9 175.56,63.22 176.1,62.67 176.1,61.41 176.86,60.66 176.86,60.06 176.66,59.87 176.66,58.75 178.56,56.86 178.72,56.86 179.44,56.14 179.44,55.18 179.12,54.86 179.12,49.32 181.93,46.5 v1(182.71,46.5)
DDRA_ACT#: length 83.1
  TOP w0.079: v1(148.21,99.05) 146.87,100.39 146.87,100.94 146.46,101.35 146.46,105.74 U3.AU3
  TOP w0.102: v1(144.51,40.22) 144.51,40.59 144.82,40.9 144.82,41.05 145.1,41.33 145.29,41.33 145.43,41.18 145.43,40.83 145.18,40.58 145.18,38.49 144.82,38.14 JDIM2.114
  IN2 w0.178: v1(144.51,40.22) 144.51,40.59 145.99,42.06 145.99,44.54 147.02,45.57 147.02,47.88 148.9,49.76 148.9,50.96 149.09,51.15 149.09,58.2 149.65,58.76 149.65,80.19 151.55,82.08 151.55,93.32 149.82,95.04 149.82,96.85 148.22,98.45 148.22,99.04 v1(148.21,99.05)
  BOTTOM w0.102: JDIM4.114 142.92,44.02 144.58,42.37 144.58,40.65 144.51,40.59 v1(144.51,40.22)
DDRB_ACT#: length 76.7
  TOP w0.089: U3.AT9 145.68,110.43 v1(145.56,110.43)
  TOP w0.102: v1(143.21,53.47) 143.21,53.81 143.37,53.97 143.72,53.97 144.23,53.46 144.23,51.71 144.82,51.12 JDIM1.114
  IN1 w0.079: 145.86,98.7 145.46,99.1 145.03,99.1 144.84,99.29 144.84,101.94 144.94,102.04 144.94,103.36 145.33,103.74 145.33,108.79 145.18,108.94 145.18,110.06 v1(145.56,110.43)
  IN1 w0.152: 146.11,97.68 148.55,95.23 148.55,93.99 151.51,91.03 151.51,88.93 150.29,87.72 150.29,67.43 148.23,65.37 148.23,59.71 145.39,56.87 145.39,53.23 144.99,52.82 143.95,52.82 143.3,53.47 v1(143.21,53.47)
  IN1 w0.165: 146.11,97.68 145.86,97.93 145.86,98.7
  BOTTOM w0.102: JDIM3.114 142.92,56.97 143.1,56.79 143.1,54.31 143.21,54.2 v1(143.21,53.47)
DEVSLP0_HDD: length 253.3
  TOP w0.102: U14.AL48 227.18,31.71 230.42,31.71 230.51,31.61 230.96,31.61
  TOP w0.14: R328.2 234.59,33.08 v1(234.36,32.86) 233.81,32.3 232.47,32.3 231.78,31.61 230.96,31.61 ; R530.1 36.65,16.87 v1(37.2,16.32)
  IN1 w0.086: v1(62.35,31.77) 61.88,31.77 61.41,31.29 60.6,31.29 60.09,31.8 59.56,31.8 59.17,31.41 57.01,31.41 55.88,30.27 54.1,30.27 52.91,29.08 52.91,26.01 52.57,25.67 51.94,25.67 51.11,24.84 49.35,24.84 48.18,23.68 48.18,20.34 47.8,19.96 47.8,19.14 46.73,18.08 41.88,18.08 40.33,16.53 37.41,16.53 v1(37.2,16.32)
  IN3 w0.089: v1(62.41,36.46) 62.41,36.78 62.61,36.99 66.34,36.99 67.53,35.79 68.68,35.79 68.93,36.04 69.61,36.04 69.78,35.87 71.49,35.87 72.27,35.1 75,35.1 75.2,34.9 79,34.9 79.59,34.31 82.5,34.31 83.45,35.26 85.54,35.26 86.03,35.75 87.6,35.75 89.07,34.29 90.21,34.29 91.03,33.47 95.49,33.47 96.03,32.94 97.08,32.94 97.37,33.22 98.39,33.22 99.51,34.35 111.12,34.35 111.8,33.66 166.06,33.66 166.23,33.84 179.2,33.84 180.94,35.57 184.9,35.57 189.87,30.6 189.87,27.46 192.76,24.58 192.76,22.95 193.12,22.59 195.47,22.59 195.92,22.13 195.92,21.59 197.54,19.97 205.13,19.97 205.52,19.58 215.91,19.58 216.15,19.82 218.37,19.82 219.26,20.71 222.17,20.71 222.75,21.28 227.43,21.28 229.77,23.62 235.09,23.62 236.14,24.67 236.14,27.45 235.76,27.83 234.03,27.83 233.28,28.58 233.28,31.77 v1(234.36,32.86)
  BOTTOM w0.14: v1(62.35,31.77) 62.35,32.45 62.93,33.04 62.93,34.44 62.41,34.96 v1(62.41,36.46)
DEVSLP0_R: length 2.5
  TOP w0.14: R530.2 35.87,16.58 36.16,16.29 v1(36.2,16.29)
  BOTTOM w0.14: v1(36.2,16.29) 35.65,16.84 CN20.1
DEVSLP1_SSD1: length 62.9
  TOP w0.14: U14.AH35 220.19,32.49 220.38,32.68 v1(220.38,33.15) ; v1(234.11,39.06) 233.57,39.59 R241.2 ; R187.2 194.18,45.72 v1(193.43,45.72)
  IN2 w0.089: v1(220.38,33.15) 220.66,33.15 221.05,33.54 222.29,33.54 222.4,33.44 222.4,33.29 222.98,32.71 224.09,32.71 224.66,32.13 226.08,32.13 226.55,31.67 226.55,30.45 227.22,29.77 229.72,29.77 230.73,30.78 230.73,36.41 231.8,37.48 232.3,37.48 233.88,39.06 v1(234.11,39.06)
  IN3 w0.089: v1(193.43,45.72) 193.43,41.23 195.62,39.04 195.62,38.49 200.41,33.7 202.37,33.7 203,34.34 203.8,34.34 204.61,35.14 205.51,35.14 205.87,35.5 207.59,35.5 208.19,36.09 212.18,36.09 214.77,33.51 220.02,33.51 v1(220.38,33.15)
DEVSLP4_SSD2: length 78.3
  TOP w0.102: U14.AR47 226.36,29.19 226.76,29.19 227.37,29.81 228.08,29.81 v1(228.49,30.22)
  TOP w0.14: v1(206.92,14.49) 206.92,14.63 206.55,15 205.48,15 205,14.52 204.21,14.52 203.96,14.78 203.96,15.03 203.68,15.31 203.04,15.31 202.56,15.79 202.56,16.16 202.32,16.4 201.4,16.4 200.82,16.97 R520.2
  IN4 w0.086: v1(206.92,14.49) 207.37,14.94 210.12,14.94 210.17,14.89 210.93,14.89 211.08,14.74 211.49,14.74 211.72,14.51 213.57,14.51 215.68,12.4 218.29,12.4 219.73,10.96 221.32,10.96 222.76,12.4 224.65,12.4 226,13.74 226,14.11 226.68,14.79 228.07,14.79 228.62,15.34 228.62,15.89 228.42,16.09 228.42,16.7 228.74,17.03 229.53,17.03 229.78,16.78 229.96,16.78 230.07,16.68 230.07,15.28 230.99,14.36 235.29,14.36 236.46,15.53 236.46,16.04 237.73,17.31 237.73,19.68 237.61,19.8 237.61,21.13 v1(236.11,22.62)
  BOTTOM w0.14: v1(228.49,30.22) 230.17,30.22 230.84,30.89 230.84,31.01 231.44,31.61 231.87,31.61 232.17,31.92 232.17,32.12 232.43,32.38 234.69,32.38 235.22,32.91 235.84,32.91 R896.2 237.41,31.34 237.41,23.92 v1(236.94,23.45) v1(236.11,22.62)
