# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA1440-INTEL-CFL-H
  round 0.406 smd: A3(-20.314,-12.06) A37(-20.314,12.739) B2(-19.654,-12.654) B38(-19.761,13.314) BR1(19.748,-13.314) BR38(19.722,13.314) BT2(20.314,-12.743) BT37(20.314,12.722) C1(-19.047,-13.314)
  round 0.381 smd: A4(-20.314,-11.343) A34(-20.314,11.146) A36(-20.314,11.958) B3(-19.616,-11.933) B37(-19.612,12.595) BN1(18.3,-13.314) BN38(18.285,13.314) BP1(19.024,-13.314) BP38(18.996,13.314) BR2(19.619,-12.596) BR37(19.613,12.59) BT3(20.314,-12.019) BT4(20.314,-11.295) BT35(20.314,11.184) BT36(20.314,11.996) C2(-18.953,-12.616) C38(-18.98,13.314) D1(-18.323,-13.314) D38(-18.218,13.314)
  round 0.356 smd: A5(-20.314,-10.543) A33(-20.314,10.345) B4(-19.344,-11.283) B36(-19.613,11.884) BM1(17.5,-13.314) BM38(17.573,13.314) BN2(18.328,-12.664) BN37(18.35,12.651) BP2(18.965,-12.486) BP37(18.943,12.374) BR3(19.664,-11.927) BR36(19.657,11.879) BT5(20.314,-10.495) BT34(20.314,10.384) C37(-18.912,12.594) D3(-18.492,-12.081) E1(-17.536,-13.314) E2(-17.84,-12.664) E38(-17.418,13.314)
  round 0.33 smd: A6(-20.314,-9.768) A32(-20.314,9.558) B5(-19.664,-10.571) B34(-19.645,11.129) BK1(16.722,-13.314) BL2(17.124,-12.664) BL38(16.862,13.314) BM2(17.738,-12.352) BM37(17.672,12.664) BN3(18.387,-12.014) BN36(18.324,11.999) BP3(19.02,-11.831) BP35(19.014,11.247) BR5(19.67,-11.148) BR34(19.664,10.46) BR35(19.664,11.222) BT6(20.314,-9.721) BT32(20.314,9.609) C36(-18.926,11.831) D4(-18.66,-11.42) D37(-18.329,12.289) E3(-17.84,-12.014) E37(-17.71,12.664) F2(-17.155,-12.664) G1(-16.733,-13.314) G38(-16.643,13.314)
  round 0.305 smd: A8(-20.314,-8.996) A9(-20.314,-8.209) A10(-20.314,-7.421) A11(-20.314,-6.634) A12(-20.314,-5.847) A13(-20.314,-5.059) A14(-20.314,-4.272) A15(-20.314,-3.484) A16(-20.314,-2.697) A17(-20.314,-1.91) A18(-20.314,-1.122) A19(-20.314,-0.335) A20(-20.314,0.453) A21(-20.314,1.24) A22(-20.314,2.027) A23(-20.314,2.815) A24(-20.314,3.602) A25(-20.314,4.39) A26(-20.314,5.177) A27(-20.314,5.964) A28(-20.314,6.752) A29(-20.314,7.539) A30(-20.314,8.53) AA1(-6.295,-13.314) AA2(-6.295,-12.664) AA3(-6.295,-12.014) AA4(-6.295,-11.363) AA5(-6.295,-10.713) AA6(-6.346,-10.063) AA7(-5.766,-9.403) AA8(-5.766,-8.753) AA9(-5.766,-8.103) AA10(-5.766,-7.452) AA11(-5.766,-6.802) AA12(-5.766,-6.152) AA13(-5.766,-5.502) AA14(-5.766,-4.851) AA29(-5.899,7.411) AA30(-5.899,8.061) AA31(-5.899,8.762) AA32(-5.899,9.413) AA33(-5.899,10.063) AA34(-5.899,10.713) AA35(-5.899,11.363) AA36(-5.899,12.014) AA37(-5.899,12.664) AA38(-5.899,13.314) AB1(-5.559,-13.314) AB2(-5.559,-12.664) AB3(-5.559,-12.014) AB4(-5.559,-11.363) AB5(-5.559,-10.713) AB6(-5.508,-10.063) AB29(-5.111,7.411) AB30(-5.111,8.061) AB31(-5.111,8.762) AB32(-5.111,9.413) AB33(-5.111,10.063) AB34(-5.111,10.713) AB35(-5.111,11.363) AB36(-5.111,12.014) AB37(-5.111,12.664) AB38(-5.111,13.314) AC1(-4.67,-13.314) AC2(-4.67,-12.664) AC3(-4.67,-12.014) AC4(-4.67,-11.363) AC5(-4.67,-10.713) AC6(-4.67,-10.063) AC7(-4.852,-9.403) AC8(-4.852,-8.753) AC9(-4.852,-8.103) AC10(-4.852,-7.452) AC11(-4.852,-6.802) AC12(-4.852,-6.152) AC13(-4.852,-5.502) AC14(-4.852,-4.851) AC29(-4.324,7.411) AC30(-4.324,8.061) AC31(-4.324,8.762) AC32(-4.324,9.413) AC33(-4.324,10.063) AC34(-4.324,10.713) AC35(-4.324,11.363) AC36(-4.324,12.014) AC37(-4.324,12.664) AC38(-4.324,13.314) AD1(-3.781,-13.314) AD2(-3.781,-12.664) AD3(-3.781,-12.014) AD4(-3.781,-11.363) AD5(-3.781,-10.713) AD6(-3.831,-10.063) AD7(-3.937,-9.403) AD8(-3.937,-8.753) AD9(-3.937,-8.103) AD10(-3.937,-7.452) AD11(-3.937,-6.802) AD12(-3.937,-6.152) AD13(-3.937,-5.502) AD14(-3.937,-4.851) AD29(-3.537,7.411) AD30(-3.537,8.061) AD31(-3.537,8.762) AD32(-3.537,9.413) AD33(-3.537,10.063) AD34(-3.537,10.713) AD35(-3.537,11.363) AD36(-3.537,12.014) AD37(-3.537,12.664) AD38(-3.537,13.314) AE1(-3.044,-13.314) AE2(-3.044,-12.664) AE3(-3.044,-12.014) AE4(-3.044,-11.363) AE5(-3.044,-10.713) AE6(-2.993,-10.063) AE7(-3.023,-9.403) AE8(-3.023,-8.753) AE9(-3.023,-8.103) AE10(-3.023,-7.452) AE11(-3.023,-6.802) AE12(-3.023,-6.152) AE13(-3.023,-5.502) AE14(-3.023,-4.851) AE29(-2.749,7.411) AE30(-2.749,8.061) AE31(-2.749,8.762) AE32(-2.749,9.413) AE33(-2.749,10.063) AE34(-2.749,10.713) AE35(-2.749,11.363) AE36(-2.749,12.014) AE37(-2.749,12.664) AE38(-2.749,13.314) AF1(-2.155,-13.314) AF2(-2.155,-12.664) AF3(-2.155,-12.014) AF4(-2.155,-11.363) AF5(-2.155,-10.713) AF6(-2.155,-10.063) AF7(-2.108,-9.403) AF8(-2.108,-8.753) AF9(-2.108,-8.103) AF10(-2.108,-7.452) AF11(-2.108,-6.802) AF12(-2.108,-6.152) AF13(-2.108,-5.502) AF14(-2.108,-4.851) AF29(-1.962,7.411) AF30(-1.962,8.061) AF31(-1.962,8.762) AF32(-1.962,9.413) AF33(-1.962,10.063) AF34(-1.962,10.713) AF35(-1.962,11.363) AF36(-1.962,12.014) AF37(-1.962,12.664) AF38(-1.962,13.314) AG1(-1.266,-13.314) AG2(-1.266,-12.664) AG3(-1.266,-12.014) AG4(-1.266,-11.363) AG5(-1.266,-10.713) AG6(-1.317,-10.063) AG7(-1.194,-9.403) AG8(-1.194,-8.753) AG9(-1.194,-8.103) AG10(-1.194,-7.452) AG11(-1.194,-6.802) AG12(-1.194,-6.152) AG13(-1.194,-5.502) AG14(-1.194,-4.851) AG29(-1.174,7.411) AG30(-1.174,8.061) AG31(-1.174,8.762) AG32(-1.174,9.413) AG33(-1.174,10.063) AG34(-1.174,10.713) AG35(-1.174,11.363) AG36(-1.174,12.014) AG37(-1.174,12.664) AG38(-1.174,13.314) AH1(-0.529,-13.314) AH2(-0.529,-12.664) AH3(-0.529,-12.014) AH4(-0.529,-11.363) AH5(-0.529,-10.713) AH6(-0.479,-10.063) AH7(-0.28,-9.403) AH8(-0.28,-8.753) AH9(-0.28,-8.103) AH10(-0.28,-7.452) AH11(-0.28,-6.802) AH12(-0.28,-6.152) AH13(-0.28,-5.502) AH14(-0.28,-4.851) AH29(-0.387,7.411) AH30(-0.387,8.061) AH31(-0.387,8.762) AH32(-0.387,9.413) AH33(-0.387,10.063) AH34(-0.387,10.713) AH35(-0.387,11.363) AH36(-0.387,12.014) AH37(-0.387,12.664) AH38(-0.387,13.314) AJ1(0.36,-13.314) AJ2(0.36,-12.664) AJ3(0.36,-12.014) AJ4(0.36,-11.363) AJ5(0.36,-10.713) AJ6(0.36,-10.063) AJ7(0.635,-9.403) AJ8(0.635,-8.753) AJ9(0.635,-8.103) AJ10(0.635,-7.452) AJ11(0.635,-6.802) AJ12(0.635,-6.152) AJ13(0.635,-5.502) AJ14(0.635,-4.851) AJ29(0.4,7.411) AJ30(0.4,8.061) AJ31(0.4,8.762) AJ32(0.4,9.413) AJ33(0.4,10.063) AJ34(0.4,10.713) AJ35(0.4,11.363) AJ36(0.4,12.014) AJ37(0.4,12.664) AJ38(0.4,13.314) AK1(1.249,-13.314) AK2(1.249,-12.664) AK3(1.249,-12.014) AK4(1.249,-11.363) AK5(1.249,-10.713) AK6(1.198,-10.063) AK29(1.188,7.411) AK30(1.188,8.061) AK31(1.188,8.762) AK32(1.188,9.413) AK33(1.188,10.063) AK34(1.188,10.713) AK35(1.188,11.363) AK36(1.188,12.014) AK37(1.188,12.664) AK38(1.188,13.314) AL1(1.985,-13.314) AL2(1.985,-12.664) AL3(1.985,-12.014) AL4(1.985,-11.363) AL5(1.985,-10.713) AL6(2.036,-10.063) AL7(1.549,-9.403) AL8(1.549,-8.753) AL9(1.549,-8.103) AL10(1.549,-7.452) AL11(1.549,-6.802) AL12(1.549,-6.152) AL13(1.549,-5.502) AL14(1.549,-4.851) AL29(1.975,7.411) AL30(1.975,8.061) AL31(1.975,8.762) AL32(1.975,9.413) AL33(1.975,10.063) AL34(1.975,10.713) AL35(1.975,11.363) AL36(1.975,12.014) AL37(1.975,12.664) AL38(1.975,13.314) AM1(2.874,-13.314) AM2(2.874,-12.664) AM3(2.874,-12.014) AM4(2.874,-11.363) AM5(2.874,-10.713) AM6(2.874,-10.063) AM7(2.464,-9.403) AM8(2.464,-8.753) AM9(2.464,-8.103) AM10(2.464,-7.452) AM11(2.464,-6.802) AM12(2.464,-6.152) AM13(2.464,-5.502) AM14(2.464,-4.851) AM29(2.763,7.411) AM30(2.763,8.061) AM31(2.763,8.762) AM32(2.763,9.413) AM33(2.763,10.063) AM34(2.763,10.713) AM35(2.763,11.363) AM36(2.763,12.014) AM37(2.763,12.664) AM38(2.763,13.314) AN1(3.763,-13.314) AN2(3.763,-12.664) AN3(3.763,-12.014) AN4(3.763,-11.363) AN5(3.763,-10.713) AN6(3.712,-10.063) AN7(3.378,-9.403) AN8(3.378,-8.753) AN9(3.378,-8.103) AN10(3.378,-7.452) AN11(3.378,-6.802) AN12(3.378,-6.152) AN13(3.378,-5.502) AN14(3.378,-4.851) AN29(3.55,7.411) AN30(3.55,8.061) AN31(3.55,8.762) AN32(3.55,9.413) AN33(3.55,10.063) AN34(3.55,10.713) AN35(3.55,11.363) AN36(3.55,12.014) AN37(3.55,12.664) AN38(3.55,13.314) AP1(4.5,-13.314) AP2(4.5,-12.664) AP3(4.5,-12.014) AP4(4.5,-11.363) AP5(4.5,-10.713) AP6(4.551,-10.063) AP7(4.292,-9.403) AP8(4.292,-8.753) AP9(4.292,-8.103) AP10(4.292,-7.452) AP11(4.292,-6.802) AP12(4.292,-6.152) AP13(4.292,-5.502) AP14(4.292,-4.851) AP29(4.337,7.411) AP30(4.337,8.061) AP31(4.337,8.762) AP32(4.337,9.413) AP33(4.337,10.063) AP34(4.337,10.713) AP35(4.337,11.363) AP36(4.337,12.014) AP37(4.337,12.664) AP38(4.337,13.314) AR1(5.389,-13.314) AR2(5.389,-12.664) AR3(5.389,-12.014) AR4(5.389,-11.363) AR5(5.389,-10.713) AR6(5.389,-10.063) AR7(5.207,-9.403) AR8(5.207,-8.753) AR9(5.207,-8.103) AR10(5.207,-7.452) AR11(5.207,-6.802) AR12(5.207,-6.152) AR13(5.207,-5.502) AR14(5.207,-4.851) AR29(5.125,7.411) AR30(5.125,8.061) AR31(5.125,8.762) AR32(5.125,9.413) AR33(5.125,10.063) AR34(5.125,10.713) AR35(5.125,11.363) AR36(5.125,12.014) AR37(5.125,12.664) AR38(5.125,13.314) AT1(6.278,-13.314) AT2(6.278,-12.664) AT3(6.278,-12.014) AT4(6.278,-11.363) AT5(6.278,-10.713) AT6(6.227,-10.063) AT7(6.121,-9.403) AT8(6.121,-8.753) AT9(6.121,-8.103) AT10(6.121,-7.452) AT11(6.121,-6.802) AT12(6.121,-6.152) AT13(6.121,-5.502) AT14(6.121,-4.851) AT29(5.912,7.411) AT30(5.912,8.061) AT31(5.912,8.762) AT32(5.912,9.413) AT33(5.912,10.063) AT34(5.912,10.713) AT35(5.912,11.363) AT36(5.912,12.014) AT37(5.912,12.664) AT38(5.912,13.314) AU1(7.014,-13.314) AU2(7.014,-12.664) AU3(7.014,-12.014) AU4(7.014,-11.363) AU5(7.014,-10.713) AU6(7.065,-10.063) AU7(7.036,-9.403) AU8(7.036,-8.753) AU9(7.036,-8.103) AU10(7.036,-7.452) AU11(7.036,-6.802) AU12(7.036,-6.152) AU13(7.036,-5.502) AU14(7.036,-4.851) AU29(6.7,7.411) AU30(6.7,8.061) AU31(6.7,8.762) AU32(6.7,9.413) AU33(6.7,10.063) AU34(6.7,10.713) AU35(6.7,11.363) AU36(6.7,12.014) AU37(6.7,12.664) AU38(6.7,13.314) AV29(7.487,7.411) AV30(7.487,8.061) AV31(7.487,8.762) AV32(7.487,9.413) AV33(7.487,10.063) AV34(7.487,10.713) AV35(7.487,11.363) AV36(7.487,12.014) AV37(7.487,12.664) AV38(7.487,13.314) AW1(7.903,-13.314) AW2(7.903,-12.664) AW3(7.903,-12.014) AW4(7.903,-11.363) AW5(7.903,-10.713) AW6(7.903,-10.063) AW7(7.95,-9.403) AW8(7.95,-8.753) AW9(7.95,-8.103) AW10(7.95,-7.452) AW11(7.95,-6.802) AW12(7.95,-6.152) AW13(7.95,-5.502) AW14(7.95,-4.851) AW29(8.274,7.411) AW30(8.274,8.061) AW31(8.274,8.762) AW32(8.274,9.413) AW33(8.274,10.063) AW34(8.274,10.713) AW35(8.274,11.363) AW36(8.274,12.014) AW37(8.274,12.664) AW38(8.274,13.314) AY1(8.792,-13.314) AY2(8.792,-12.664) AY3(8.792,-12.014) AY4(8.792,-11.363) AY5(8.792,-10.713) AY6(8.742,-10.063) AY7(8.864,-9.403) AY8(8.864,-8.753) AY9(8.864,-8.103) AY10(8.864,-7.452) AY11(8.864,-6.802) AY12(8.864,-6.152) AY13(8.864,-5.502) AY14(8.864,-4.851) AY29(9.062,7.411) AY30(9.062,8.061) AY31(9.062,8.762) AY32(9.062,9.413) AY33(9.062,10.063) AY34(9.062,10.713) AY35(9.062,11.363) AY36(9.062,12.014) AY37(9.062,12.664) AY38(9.062,13.314) B6(-19.664,-9.784) B8(-19.664,-8.996) B9(-19.664,-8.209) B10(-19.664,-7.421) B11(-19.664,-6.634) B12(-19.664,-5.847) B13(-19.664,-5.059) B14(-19.664,-4.272) B15(-19.664,-3.484) B16(-19.664,-2.697) B17(-19.664,-1.91) B18(-19.664,-1.122) B19(-19.664,-0.335) B20(-19.664,0.453) B21(-19.664,1.24) B22(-19.664,2.027) B23(-19.664,2.815) B24(-19.664,3.602) B25(-19.664,4.39) B26(-19.664,5.177) B27(-19.664,5.964) B28(-19.664,6.752) B29(-19.664,7.539) B30(-19.664,8.327) B31(-19.664,9.114) B33(-19.664,9.901) BA1(9.529,-13.314) BA2(9.529,-12.664) BA3(9.529,-12.014) BA4(9.529,-11.363) BA5(9.529,-10.713) BA6(9.58,-10.063) BA7(9.779,-9.403) BA8(9.779,-8.753) BA9(9.779,-8.103) BA10(9.779,-7.452) BA11(9.779,-6.802) BA12(9.779,-6.152) BA13(9.779,-5.502) BA14(9.779,-4.851) BA29(9.849,7.411) BA30(9.849,8.061) BA31(9.849,8.762) BA32(9.849,9.413) BA33(9.849,10.063) BA34(9.849,10.713) BA35(9.849,11.363) BA36(9.849,12.014) BA37(9.849,12.664) BA38(9.849,13.314) BB1(10.418,-13.314) BB2(10.418,-12.664) BB3(10.418,-12.014) BB4(10.418,-11.363) BB5(10.418,-10.713) BB6(10.418,-10.063) BB7(10.693,-9.403) BB8(10.693,-8.753) BB9(10.693,-8.103) BB10(10.693,-7.452) BB11(10.693,-6.802) BB12(10.693,-6.152) BB13(10.693,-5.502) BB14(10.693,-4.851) BB29(10.637,7.411) BB30(10.637,8.061) BB31(10.637,8.762) BB32(10.637,9.413) BB33(10.637,10.063) BB34(10.637,10.713) BB35(10.637,11.363) BB36(10.637,12.014) BB37(10.637,12.664) BB38(10.637,13.314) BC1(11.307,-13.314) BC2(11.307,-12.664) BC3(11.307,-12.014) BC4(11.307,-11.363) BC5(11.307,-10.713) BC6(11.256,-10.063) BC7(11.608,-9.403) BC8(11.608,-8.753) BC9(11.608,-8.103) BC10(11.608,-7.452) BC11(11.608,-6.802) BC12(11.608,-6.152) BC13(11.608,-5.502) BC14(11.608,-4.851) BC29(11.424,7.411) BC30(11.424,8.061) BC31(11.424,8.762) BC32(11.424,9.413) BC33(11.424,10.063) BC34(11.424,10.713) BC35(11.424,11.363) BC36(11.424,12.014) BC37(11.424,12.664) BC38(11.424,13.314) BD1(12.044,-13.314) BD2(12.044,-12.664) BD3(12.044,-12.014) BD4(12.044,-11.363) BD5(12.044,-10.713) BD6(12.094,-10.063) BD7(12.522,-9.403) BD8(12.522,-8.753) BD9(12.522,-8.103) BD10(12.522,-7.452) BD11(12.522,-6.802) BD12(12.522,-6.152) BD13(12.522,-5.502) BD14(12.522,-4.851) BD29(12.211,7.411) BD30(12.211,8.061) BD31(12.211,8.762) BD32(12.211,9.413) BD33(12.211,10.063) BD34(12.211,10.713) BD35(12.211,11.363) BD36(12.211,12.014) BD37(12.211,12.664) BD38(12.211,13.314) BE1(12.933,-13.314) BE2(12.933,-12.664) BE3(12.933,-12.014) BE4(12.933,-11.363) BE5(12.933,-10.713) BE6(12.933,-10.063) BE29(12.999,7.411) BE30(12.999,8.061) BE31(12.999,8.762) BE32(12.999,9.413) BE33(12.999,10.063) BE34(12.999,10.713) BE35(12.999,11.363) BE36(12.999,12.014) BE37(12.999,12.664) BE38(12.999,13.314) BF1(13.822,-13.314) BF2(13.822,-12.664) BF3(13.822,-12.014) BF4(13.822,-11.363) BF5(13.822,-10.713) BF6(13.771,-10.063) BF7(13.436,-9.403) BF8(13.436,-8.753) BF9(13.436,-8.103) BF10(13.436,-7.452) BF11(13.436,-6.802) BF12(13.436,-6.152) BF13(13.436,-5.502) BF14(13.436,-4.851) BF29(13.786,7.411) BF30(13.786,8.061) BF31(13.786,8.762) BF32(13.786,9.413) BF33(13.786,10.063) BF34(13.786,10.713) BF35(13.786,11.363) BF36(13.786,12.014) BF37(13.786,12.664) BF38(13.786,13.314) BG1(14.558,-13.314) BG2(14.558,-12.664) BG3(14.558,-12.014) BG4(14.558,-11.363) BG5(14.558,-10.713) BG6(14.609,-10.063) BG7(14.351,-9.403) BG8(14.351,-8.753) BG9(14.351,-8.103) BG10(14.351,-7.452) BG11(14.351,-6.802) BG12(14.351,-6.152) BG13(14.351,-5.502) BG14(14.351,-4.851) BG29(14.574,7.411) BG30(14.574,8.061) BG31(14.574,8.762) BG32(14.574,9.413) BG33(14.574,10.063) BG34(14.574,10.713) BG35(14.574,11.363) BG36(14.574,12.014) BG37(14.574,12.664) BG38(14.574,13.314) BH1(15.701,-13.314) BH2(15.447,-12.664) BH3(15.447,-12.014) BH4(15.447,-11.363) BH5(15.447,-10.713) BH6(15.447,-10.063) BH7(15.265,-9.403) BH8(15.265,-8.753) BH9(15.265,-8.103) BH10(15.265,-7.452) BH11(15.265,-6.802) BH12(15.265,-6.152) BH13(15.265,-5.502) BH14(15.227,-4.851) BH29(15.234,7.411) BH30(15.361,8.061) BH31(15.361,8.762) BH32(15.361,9.413) BH33(15.361,10.063) BH34(15.361,10.713) BH35(15.361,11.363) BH36(15.361,12.014) BH37(15.361,12.664) BH38(15.361,13.314) BJ7(16.18,-9.403) BJ8(16.18,-8.753) BJ9(16.18,-8.103) BJ10(16.18,-7.452) BJ11(16.18,-6.802) BJ12(16.091,-6.032) BJ13(15.812,-5.144) BJ14(15.762,-4.463) BJ15(15.762,-3.713) BJ16(15.762,-2.926) BJ17(15.762,-2.139) BJ18(15.762,-1.351) BJ19(15.762,-0.564) BJ20(15.762,0.224) BJ21(15.762,1.011) BJ22(15.762,1.798) BJ23(15.762,2.586) BJ24(15.762,3.373) BJ25(15.762,4.161) BJ26(15.762,4.948) BJ27(15.762,5.735) BJ28(15.762,6.523) BJ29(15.844,7.183) BJ30(16.015,8.039) BJ31(16.148,8.762) BJ32(16.148,9.413) BJ33(16.148,10.063) BJ34(16.148,10.713) BJ35(16.148,11.363) BJ36(16.148,12.014) BJ37(16.148,12.664) BJ38(16.098,13.314) BK2(16.285,-12.664) BK3(16.285,-12.014) BK4(16.285,-11.363) BK5(16.285,-10.713) BK6(16.285,-10.063) BK13(16.413,-5.415) BK14(16.413,-4.501) BK15(16.413,-3.713) BK16(16.413,-2.926) BK17(16.413,-2.139) BK18(16.413,-1.351) BK19(16.413,-0.564) BK20(16.413,0.224) BK21(16.413,1.011) BK22(16.413,1.798) BK23(16.413,2.586) BK24(16.413,3.373) BK25(16.413,4.161) BK26(16.413,4.948) BK27(16.413,5.735) BK28(16.413,6.523) BK29(16.421,7.518) BL3(17.073,-12.014) BL4(17.073,-11.363) BL5(17.073,-10.713) BL6(17.124,-10.063) BL7(17.069,-9.327) BL8(17.063,-8.438) BL9(17.063,-7.65) BL11(17.063,-6.863) BL12(17.063,-6.076) BL13(17.063,-5.288) BL14(17.063,-4.501) BL15(17.063,-3.713) BL16(17.063,-2.926) BL17(17.063,-2.139) BL18(17.063,-1.351) BL19(17.063,-0.564) BL20(17.063,0.224) BL21(17.063,1.011) BL22(17.063,1.798) BL23(17.063,2.586) BL24(17.063,3.373) BL25(17.063,4.161) BL26(17.063,4.948) BL27(17.063,5.735) BL28(17.063,6.523) BL29(17.063,7.31) BL30(16.936,8.112) BL31(16.936,8.762) BL32(16.936,9.413) BL33(16.936,10.063) BL34(16.936,10.713) BL35(16.936,11.363) BL36(16.936,12.014) BL37(16.936,12.664) BM3(17.815,-11.701) BM5(17.815,-10.789) BM6(17.916,-10.145) BM7(17.713,-9.225) BM8(17.713,-8.438) BM9(17.713,-7.65) BM11(17.713,-6.863) BM12(17.713,-6.076) BM13(17.713,-5.288) BM14(17.713,-4.501) BM15(17.713,-3.713) BM16(17.713,-2.926) BM17(17.713,-2.139) BM18(17.713,-1.351) BM19(17.713,-0.564) BM20(17.713,0.224) BM21(17.713,1.011) BM22(17.713,1.798) BM23(17.713,2.586) BM24(17.713,3.373) BM25(17.713,4.161) BM26(17.713,4.948) BM27(17.713,5.735) BM28(17.713,6.523) BM29(17.713,7.31) BM30(17.713,8.098) BM31(17.713,8.885) BM33(17.713,9.672) BM34(17.713,10.46) BM35(17.713,11.247) BM36(17.672,12.014) BN4(18.315,-11.209) BN5(18.479,-10.566) BN7(18.363,-9.225) BN8(18.363,-8.438) BN9(18.363,-7.65) BN11(18.363,-6.863) BN12(18.363,-6.076) BN13(18.363,-5.288) BN14(18.363,-4.501) BN15(18.363,-3.713) BN16(18.363,-2.926) BN17(18.363,-2.139) BN18(18.363,-1.351) BN19(18.363,-0.564) BN20(18.363,0.224) BN21(18.363,1.011) BN22(18.363,1.798) BN23(18.363,2.586) BN24(18.363,3.373) BN25(18.363,4.161) BN26(18.363,4.948) BN27(18.363,5.735) BN28(18.363,6.523) BN29(18.363,7.31) BN30(18.363,8.098) BN31(18.363,8.885) BN33(18.363,9.672) BN34(18.363,10.46) BN35(18.363,11.248) BP5(19.037,-10.94) BP6(18.974,-10.02) BP7(19.014,-9.225) BP8(19.014,-8.438) BP9(19.014,-7.65) BP11(19.014,-6.863) BP12(19.014,-6.076) BP13(19.014,-5.288) BP14(19.014,-4.501) BP15(19.014,-3.713) BP16(19.014,-2.926) BP17(19.014,-2.139) BP18(19.014,-1.351) BP19(19.014,-0.564) BP20(19.014,0.224) BP21(19.014,1.011) BP22(19.014,1.798) BP23(19.014,2.586) BP24(19.014,3.373) BP25(19.014,4.161) BP26(19.014,4.948) BP27(19.014,5.735) BP28(19.014,6.523) BP29(19.014,7.31) BP30(19.014,8.098) BP31(19.014,8.885) BP33(19.014,9.672) BP34(19.014,10.46) BR6(19.647,-10.122) BR7(19.664,-9.225) BR8(19.664,-8.438) BR9(19.664,-7.65) BR11(19.664,-6.863) BR12(19.664,-6.076) BR13(19.664,-5.288) BR14(19.664,-4.501) BR15(19.664,-3.713) BR16(19.664,-2.926) BR17(19.664,-2.139) BR18(19.664,-1.351) BR19(19.664,-0.564) BR20(19.664,0.224) BR21(19.664,1.011) BR22(19.664,1.798) BR23(19.664,2.586) BR24(19.664,3.373) BR25(19.664,4.161) BR26(19.664,4.948) BR27(19.664,5.735) BR28(19.664,6.523) BR29(19.664,7.31) BR30(19.664,8.098) BR31(19.664,8.885) BR33(19.664,9.672) BT8(20.314,-8.666) BT9(20.314,-7.65) BT11(20.314,-6.863) BT12(20.314,-6.076) BT13(20.314,-5.288) BT14(20.314,-4.501) BT15(20.314,-3.713) BT16(20.314,-2.926) BT17(20.314,-2.139) BT18(20.314,-1.351) BT19(20.314,-0.564) BT20(20.314,0.224) BT21(20.314,1.011) BT22(20.314,1.798) BT23(20.314,2.586) BT24(20.314,3.373) BT25(20.314,4.161) BT26(20.314,4.948) BT27(20.314,5.735) BT28(20.314,6.523) BT29(20.314,7.31) BT30(20.314,8.098) BT31(20.314,8.86) C5(-19.014,-10.571) C6(-19.014,-9.784) C8(-19.014,-8.996) C9(-19.014,-8.209) C10(-19.014,-7.421) C11(-19.014,-6.634) C12(-19.014,-5.847) C13(-19.014,-5.059) C14(-19.014,-4.272) C15(-19.014,-3.484) C16(-19.014,-2.697) C17(-19.014,-1.91) C18(-19.014,-1.122) C19(-19.014,-0.335) C20(-19.014,0.453) C21(-19.014,1.24) C22(-19.014,2.027) C23(-19.014,2.815) C24(-19.014,3.602) C25(-19.014,4.39) C26(-19.014,5.177) C27(-19.014,5.964) C28(-19.014,6.752) C29(-19.014,7.539) C30(-19.014,8.327) C31(-19.014,9.114) C33(-19.014,9.901) C34(-19.025,10.697) D5(-18.363,-10.571) D6(-18.363,-9.784) D8(-18.363,-8.996) D9(-18.363,-8.209) D10(-18.363,-7.421) D11(-18.363,-6.634) D12(-18.363,-5.847) D13(-18.363,-5.059) D14(-18.363,-4.272) D15(-18.363,-3.484) D16(-18.363,-2.697) D17(-18.363,-1.91) D18(-18.363,-1.122) D19(-18.363,-0.335) D20(-18.363,0.453) D21(-18.363,1.24) D22(-18.363,2.027) D23(-18.363,2.815) D24(-18.363,3.602) D25(-18.363,4.39) D26(-18.363,5.177) D27(-18.363,5.964) D28(-18.363,6.752) D29(-18.363,7.539) D30(-18.363,8.327) D31(-18.363,9.114) D33(-18.363,9.901) D34(-18.363,10.689) D35(-18.453,11.341) E4(-17.739,-11.363) E5(-17.713,-10.571) E6(-17.713,-9.784) E8(-17.713,-8.996) E9(-17.713,-8.209) E10(-17.713,-7.421) E11(-17.713,-6.634) E12(-17.713,-5.847) E13(-17.713,-5.059) E14(-17.713,-4.272) E15(-17.713,-3.484) E16(-17.713,-2.697) E17(-17.713,-1.91) E18(-17.713,-1.122) E19(-17.713,-0.335) E20(-17.713,0.453) E21(-17.713,1.24) E22(-17.713,2.027) E23(-17.713,2.815) E24(-17.713,3.602) E25(-17.713,4.39) E26(-17.713,5.177) E27(-17.713,5.964) E28(-17.713,6.752) E29(-17.713,7.539) E30(-17.713,8.327) E31(-17.713,9.114) E33(-17.713,9.901) E34(-17.713,10.689) E35(-17.71,11.363) E36(-17.71,12.014) F3(-17.155,-12.014) F4(-17.053,-11.363) F5(-17.041,-10.571) F6(-17.041,-9.784) F8(-17.063,-8.996) F9(-17.063,-8.209) F10(-17.063,-7.421) F11(-17.063,-6.634) F12(-17.063,-5.847) F13(-17.063,-5.059) F14(-17.063,-4.272) F15(-17.063,-3.484) F16(-17.063,-2.697) F17(-17.063,-1.91) F18(-17.063,-1.122) F19(-17.063,-0.335) F20(-17.063,0.453) F21(-17.063,1.24) F22(-17.063,2.027) F23(-17.063,2.815) F24(-17.063,3.602) F25(-17.063,4.39) F26(-17.063,5.177) F27(-17.063,5.964) F28(-17.063,6.752) F29(-17.063,7.539) F30(-17.063,8.327) F31(-17.063,9.114) F33(-17.063,9.901) F34(-16.922,10.713) F35(-16.922,11.363) F36(-16.922,12.014) F37(-16.922,12.664) G2(-16.367,-12.664) G3(-16.367,-12.014) G4(-16.367,-11.363) G5(-16.367,-10.713) G6(-16.367,-10.063) G8(-16.413,-8.996) G9(-16.413,-8.209) G10(-16.413,-7.421) G11(-16.413,-6.634) G12(-16.413,-5.847) G13(-16.413,-5.059) G14(-16.413,-4.272) G15(-16.413,-3.484) G16(-16.413,-2.697) G17(-16.413,-1.91) G18(-16.413,-1.122) G19(-16.413,-0.335) G20(-16.413,0.453) G21(-16.413,1.24) G22(-16.413,2.027) G23(-16.413,2.815) G24(-16.413,3.602) G25(-16.413,4.39) G26(-16.413,5.177) G27(-16.413,5.964) G28(-16.413,6.752) G29(-16.413,7.539) G30(-16.413,8.327) H1(-15.871,-13.314) H11(-15.762,-6.634) H12(-15.762,-5.847) H13(-15.712,-5.059) H14(-15.712,-4.272) H15(-15.712,-3.484) H16(-15.712,-2.697) H17(-15.712,-1.91) H18(-15.712,-1.122) H19(-15.712,-0.335) H20(-15.712,0.453) H21(-15.712,1.24) H22(-15.712,2.027) H23(-15.712,2.815) H24(-15.712,3.602) H25(-15.712,4.39) H26(-15.712,5.177) H27(-15.712,5.964) H28(-15.712,6.752) H29(-15.762,7.539) H30(-15.762,8.289) H32(-16.135,9.413) H33(-16.135,10.063) H34(-16.135,10.713) H35(-16.135,11.363) H36(-16.135,12.014) H37(-16.135,12.664) J2(-15.566,-12.664) J3(-15.566,-12.014) J4(-15.566,-11.363) J5(-15.566,-10.713) J6(-15.566,-10.063) J7(-15.695,-9.421) J8(-15.598,-8.773) J9(-15.621,-8.103) J10(-15.686,-7.421) J14(-15.061,-4.272) J15(-15.061,-3.484) J16(-15.061,-2.697) J17(-15.061,-1.91) J18(-15.061,-1.122) J19(-15.061,-0.335) J20(-15.061,0.453) J21(-15.061,1.24) J22(-15.061,2.027) J23(-15.061,2.815) J24(-15.061,3.602) J25(-15.061,4.39) J26(-15.061,5.177) J27(-15.061,5.964) J28(-15.061,6.752) J30(-15.146,7.747) J31(-15.31,8.762) J32(-15.348,9.413) J33(-15.348,10.063) J34(-15.348,10.713) J35(-15.348,11.363) J36(-15.348,12.014) J37(-15.348,12.664) J38(-15.602,13.314) K1(-14.728,-13.314) K2(-14.728,-12.664) K3(-14.728,-12.014) K4(-14.728,-11.363) K5(-14.728,-10.713) K6(-14.728,-10.063) K7(-14.758,-9.403) K8(-14.834,-8.753) K9(-14.834,-8.103) K10(-14.834,-7.452) K11(-14.834,-6.802) K12(-14.834,-6.152) K13(-15.138,-5.436) K14(-14.656,-4.851) K29(-14.56,7.411) K30(-14.56,8.061) K31(-14.56,8.762) K32(-14.56,9.413) K33(-14.56,10.063) K34(-14.56,10.713) K35(-14.56,11.363) K36(-14.56,12.014) K37(-14.56,12.664) K38(-14.56,13.314) L1(-13.839,-13.314) L2(-13.839,-12.664) L3(-13.839,-12.014) L4(-13.839,-11.363) L5(-13.839,-10.713) L6(-13.89,-10.063) L7(-13.919,-9.403) L8(-13.97,-8.753) L9(-13.996,-8.103) L10(-13.996,-7.452) L11(-13.996,-6.802) L12(-13.996,-6.152) L13(-13.996,-5.502) L14(-13.996,-4.851) L29(-13.773,7.411) L30(-13.773,8.061) L31(-13.773,8.762) L32(-13.773,9.413) L33(-13.773,10.063) L34(-13.773,10.713) L35(-13.773,11.363) L36(-13.773,12.014) L37(-13.773,12.664) L38(-13.773,13.314) M1(-13.102,-13.314) M2(-13.102,-12.664) M3(-13.102,-12.014) M4(-13.102,-11.363) M5(-13.102,-10.713) M6(-13.052,-10.063) M7(-13.081,-9.403) M8(-13.081,-8.753) M9(-13.081,-8.103) M10(-13.081,-7.452) M11(-13.081,-6.802) M12(-13.081,-6.152) M13(-13.081,-5.502) M14(-13.081,-4.851) M29(-12.985,7.411) M30(-12.985,8.061) M31(-12.985,8.762) M32(-12.985,9.413) M33(-12.985,10.063) M34(-12.985,10.713) M35(-12.985,11.363) M36(-12.985,12.014) M37(-12.985,12.664) M38(-12.985,13.314) N1(-12.213,-13.314) N2(-12.213,-12.664) N3(-12.213,-12.014) N4(-12.213,-11.363) N5(-12.213,-10.713) N6(-12.213,-10.063) N7(-12.167,-9.403) N8(-12.167,-8.753) N9(-12.167,-8.103) N10(-12.167,-7.452) N11(-12.167,-6.802) N12(-12.167,-6.152) N13(-12.167,-5.502) N14(-12.167,-4.851) N29(-12.198,7.411) N30(-12.198,8.061) N31(-12.198,8.762) N32(-12.198,9.413) N33(-12.198,10.063) N34(-12.198,10.713) N35(-12.198,11.363) N36(-12.198,12.014) N37(-12.198,12.664) N38(-12.198,13.314) P1(-11.324,-13.314) P2(-11.324,-12.664) P3(-11.324,-12.014) P4(-11.324,-11.363) P5(-11.324,-10.713) P6(-11.375,-10.063) P7(-11.252,-9.403) P8(-11.252,-8.753) P9(-11.252,-8.103) P10(-11.252,-7.452) P11(-11.252,-6.802) P12(-11.252,-6.152) P13(-11.252,-5.502) P14(-11.252,-4.851) P29(-11.411,7.411) P30(-11.411,8.061) P31(-11.411,8.762) P32(-11.411,9.413) P33(-11.411,10.063) P34(-11.411,10.713) P35(-11.411,11.363) P36(-11.411,12.014) P37(-11.411,12.664) P38(-11.411,13.314) R1(-10.588,-13.314) R2(-10.588,-12.664) R3(-10.588,-12.014) R4(-10.588,-11.363) R5(-10.588,-10.713) R6(-10.537,-10.063) R7(-10.338,-9.403) R8(-10.338,-8.753) R9(-10.338,-8.103) R10(-10.338,-7.452) R11(-10.338,-6.802) R12(-10.338,-6.152) R13(-10.338,-5.502) R14(-10.338,-4.851) R29(-10.623,7.411) R30(-10.623,8.061) R31(-10.623,8.762) R32(-10.623,9.413) R33(-10.623,10.063) R34(-10.623,10.713) R35(-10.623,11.363) R36(-10.623,12.014) R37(-10.623,12.664) R38(-10.623,13.314) T1(-9.699,-13.314) T2(-9.699,-12.664) T3(-9.699,-12.014) T4(-9.699,-11.363) T5(-9.699,-10.713) T6(-9.699,-10.063) T7(-9.424,-9.403) T8(-9.424,-8.753) T9(-9.424,-8.103) T10(-9.424,-7.452) T11(-9.424,-6.802) T12(-9.424,-6.152) T13(-9.424,-5.502) T14(-9.424,-4.851) T29(-9.836,7.411) T30(-9.836,8.061) T31(-9.836,8.762) T32(-9.836,9.413) T33(-9.836,10.063) T34(-9.836,10.713) T35(-9.836,11.363) T36(-9.836,12.014) T37(-9.836,12.664) T38(-9.836,13.314) U1(-8.81,-13.314) U2(-8.81,-12.664) U3(-8.81,-12.014) U4(-8.81,-11.363) U5(-8.81,-10.713) U6(-8.861,-10.063) U29(-9.048,7.411) U30(-9.048,8.061) U31(-9.048,8.762) U32(-9.048,9.413) U33(-9.048,10.063) U34(-9.048,10.713) U35(-9.048,11.363) U36(-9.048,12.014) U37(-9.048,12.664) U38(-9.048,13.314) V1(-8.073,-13.314) V2(-8.073,-12.664) V3(-8.073,-12.014) V4(-8.073,-11.363) V5(-8.073,-10.713) V6(-8.022,-10.063) V7(-8.509,-9.403) V8(-8.509,-8.753) V9(-8.509,-8.103) V10(-8.509,-7.452) V11(-8.509,-6.802) V12(-8.509,-6.152) V13(-8.509,-5.502) V14(-8.509,-4.851) V29(-8.261,7.411) V30(-8.261,8.061) V31(-8.261,8.762) V32(-8.261,9.413) V33(-8.261,10.063) V34(-8.261,10.713) V35(-8.261,11.363) V36(-8.261,12.014) V37(-8.261,12.664) V38(-8.261,13.314) W1(-7.184,-13.314) W2(-7.184,-12.664) W3(-7.184,-12.014) W4(-7.184,-11.363) W5(-7.184,-10.713) W6(-7.184,-10.063) W7(-7.595,-9.403) W8(-7.595,-8.753) W9(-7.595,-8.103) W10(-7.595,-7.452) W11(-7.595,-6.802) W12(-7.595,-6.152) W13(-7.595,-5.502) W14(-7.595,-4.851) W29(-7.474,7.411) W30(-7.474,8.061) W31(-7.474,8.762) W32(-7.474,9.413) W33(-7.474,10.063) W34(-7.474,10.713) W35(-7.474,11.363) W36(-7.474,12.014) W37(-7.474,12.664) W38(-7.474,13.314) Y7(-6.68,-9.403) Y8(-6.68,-8.753) Y9(-6.68,-8.103) Y10(-6.68,-7.452) Y11(-6.68,-6.802) Y12(-6.68,-6.152) Y13(-6.68,-5.502) Y14(-6.68,-4.851) Y29(-6.686,7.411) Y30(-6.686,8.061) Y31(-6.686,8.762) Y32(-6.686,9.413) Y33(-6.686,10.063) Y34(-6.686,10.713) Y35(-6.686,11.363) Y36(-6.686,12.014) Y37(-6.686,12.664) Y38(-6.686,13.314)
BGA2228-NVIDIA-N18E-G3
  round 0.305 smd: A2(-17.85,-17.15) A3(-17.85,-16.45) A4(-17.85,-15.75) A5(-17.85,-15.05) A6(-17.85,-14.35) A8(-17.85,-12.95) A9(-17.85,-12.25) A11(-17.85,-10.85) A12(-17.85,-10.15) A14(-17.85,-8.75) A15(-17.85,-8.05) A17(-17.85,-6.65) A18(-17.85,-5.95) A20(-17.85,-4.55) A21(-17.85,-3.85) A23(-17.85,-2.45) A24(-17.85,-1.75) A26(-17.85,-0.35) A27(-17.85,0.35) A29(-17.85,1.75) A30(-17.85,2.45) A32(-17.85,3.85) A33(-17.85,4.55) A35(-17.85,5.95) A36(-17.85,6.65) A38(-17.85,8.05) A39(-17.85,8.75) A41(-17.85,10.15) A42(-17.85,10.85) A44(-17.85,12.25) A45(-17.85,12.95) A47(-17.85,14.35) A48(-17.85,15.05) A49(-17.85,15.75) A50(-17.85,16.45) A51(-17.85,17.15) AA1(-3.85,-17.85) AA2(-3.85,-17.15) AA3(-3.85,-16.45) AA4(-3.85,-15.75) AA5(-3.85,-15.05) AA6(-3.85,-14.35) AA7(-3.85,-13.65) AA8(-3.85,-12.95) AA9(-3.85,-12.25) AA10(-3.85,-11.55) AA11(-3.85,-10.85) AA13(-3.85,-9.45) AA14(-3.85,-8.75) AA15(-3.85,-8.05) AA16(-3.85,-7.35) AA17(-3.85,-6.65) AA18(-3.85,-5.95) AA19(-3.85,-5.25) AA20(-3.85,-4.55) AA21(-3.85,-3.85) AA22(-3.85,-3.15) AA23(-3.85,-2.45) AA24(-3.85,-1.75) AA25(-3.85,-1.05) AA26(-3.85,-0.35) AA27(-3.85,0.35) AA28(-3.85,1.05) AA29(-3.85,1.75) AA30(-3.85,2.45) AA31(-3.85,3.15) AA32(-3.85,3.85) AA33(-3.85,4.55) AA34(-3.85,5.25) AA35(-3.85,5.95) AA36(-3.85,6.65) AA37(-3.85,7.35) AA38(-3.85,8.05) AA39(-3.85,8.75) AA40(-3.85,9.45) AA42(-3.85,10.85) AA43(-3.85,11.55) AA44(-3.85,12.25) AA45(-3.85,12.95) AA46(-3.85,13.65) AA47(-3.85,14.35) AA48(-3.85,15.05) AA49(-3.85,15.75) AA50(-3.85,16.45) AA51(-3.85,17.15) AA52(-3.85,17.85) AB2(-3.15,-17.15) AB4(-3.15,-15.75) AB6(-3.15,-14.35) AB8(-3.15,-12.95) AB10(-3.15,-11.55) AB13(-3.15,-9.45) AB14(-3.15,-8.75) AB15(-3.15,-8.05) AB16(-3.15,-7.35) AB17(-3.15,-6.65) AB18(-3.15,-5.95) AB19(-3.15,-5.25) AB20(-3.15,-4.55) AB21(-3.15,-3.85) AB22(-3.15,-3.15) AB23(-3.15,-2.45) AB24(-3.15,-1.75) AB25(-3.15,-1.05) AB26(-3.15,-0.35) AB27(-3.15,0.35) AB28(-3.15,1.05) AB29(-3.15,1.75) AB30(-3.15,2.45) AB31(-3.15,3.15) AB32(-3.15,3.85) AB33(-3.15,4.55) AB34(-3.15,5.25) AB35(-3.15,5.95) AB36(-3.15,6.65) AB37(-3.15,7.35) AB38(-3.15,8.05) AB39(-3.15,8.75) AB40(-3.15,9.45) AB43(-3.15,11.55) AB45(-3.15,12.95) AB47(-3.15,14.35) AB49(-3.15,15.75) AB51(-3.15,17.15) AC1(-2.45,-17.85) AC2(-2.45,-17.15) AC3(-2.45,-16.45) AC4(-2.45,-15.75) AC5(-2.45,-15.05) AC6(-2.45,-14.35) AC7(-2.45,-13.65) AC8(-2.45,-12.95) AC9(-2.45,-12.25) AC10(-2.45,-11.55) AC11(-2.45,-10.85) AC13(-2.45,-9.45) AC14(-2.45,-8.75) AC15(-2.45,-8.05) AC16(-2.45,-7.35) AC17(-2.45,-6.65) AC18(-2.45,-5.95) AC19(-2.45,-5.25) AC20(-2.45,-4.55) AC21(-2.45,-3.85) AC22(-2.45,-3.15) AC23(-2.45,-2.45) AC24(-2.45,-1.75) AC25(-2.45,-1.05) AC26(-2.45,-0.35) AC27(-2.45,0.35) AC28(-2.45,1.05) AC29(-2.45,1.75) AC30(-2.45,2.45) AC31(-2.45,3.15) AC32(-2.45,3.85) AC33(-2.45,4.55) AC34(-2.45,5.25) AC35(-2.45,5.95) AC36(-2.45,6.65) AC37(-2.45,7.35) AC38(-2.45,8.05) AC39(-2.45,8.75) AC40(-2.45,9.45) AC42(-2.45,10.85) AC43(-2.45,11.55) AC44(-2.45,12.25) AC45(-2.45,12.95) AC46(-2.45,13.65) AC47(-2.45,14.35) AC48(-2.45,15.05) AC49(-2.45,15.75) AC50(-2.45,16.45) AC51(-2.45,17.15) AC52(-2.45,17.85) AD1(-1.75,-17.85) AD2(-1.75,-17.15) AD3(-1.75,-16.45) AD4(-1.75,-15.75) AD5(-1.75,-15.05) AD6(-1.75,-14.35) AD7(-1.75,-13.65) AD8(-1.75,-12.95) AD9(-1.75,-12.25) AD10(-1.75,-11.55) AD11(-1.75,-10.85) AD13(-1.75,-9.45) AD14(-1.75,-8.75) AD15(-1.75,-8.05) AD16(-1.75,-7.35) AD17(-1.75,-6.65) AD18(-1.75,-5.95) AD19(-1.75,-5.25) AD20(-1.75,-4.55) AD21(-1.75,-3.85) AD22(-1.75,-3.15) AD23(-1.75,-2.45) AD24(-1.75,-1.75) AD25(-1.75,-1.05) AD26(-1.75,-0.35) AD27(-1.75,0.35) AD28(-1.75,1.05) AD29(-1.75,1.75) AD30(-1.75,2.45) AD31(-1.75,3.15) AD32(-1.75,3.85) AD33(-1.75,4.55) AD34(-1.75,5.25) AD35(-1.75,5.95) AD36(-1.75,6.65) AD37(-1.75,7.35) AD38(-1.75,8.05) AD39(-1.75,8.75) AD40(-1.75,9.45) AD42(-1.75,10.85) AD43(-1.75,11.55) AD44(-1.75,12.25) AD45(-1.75,12.95) AD46(-1.75,13.65) AD47(-1.75,14.35) AD48(-1.75,15.05) AD49(-1.75,15.75) AD50(-1.75,16.45) AD51(-1.75,17.15) AD52(-1.75,17.85) AE2(-1.05,-17.15) AE4(-1.05,-15.75) AE6(-1.05,-14.35) AE8(-1.05,-12.95) AE10(-1.05,-11.55) AE13(-1.05,-9.45) AE14(-1.05,-8.75) AE15(-1.05,-8.05) AE16(-1.05,-7.35) AE17(-1.05,-6.65) AE18(-1.05,-5.95) AE19(-1.05,-5.25) AE20(-1.05,-4.55) AE21(-1.05,-3.85) AE22(-1.05,-3.15) AE23(-1.05,-2.45) AE24(-1.05,-1.75) AE25(-1.05,-1.05) AE26(-1.05,-0.35) AE27(-1.05,0.35) AE28(-1.05,1.05) AE29(-1.05,1.75) AE30(-1.05,2.45) AE31(-1.05,3.15) AE32(-1.05,3.85) AE33(-1.05,4.55) AE34(-1.05,5.25) AE35(-1.05,5.95) AE36(-1.05,6.65) AE37(-1.05,7.35) AE38(-1.05,8.05) AE39(-1.05,8.75) AE40(-1.05,9.45) AE43(-1.05,11.55) AE45(-1.05,12.95) AE47(-1.05,14.35) AE49(-1.05,15.75) AE51(-1.05,17.15) AF1(-0.35,-17.85) AF2(-0.35,-17.15) AF3(-0.35,-16.45) AF4(-0.35,-15.75) AF5(-0.35,-15.05) AF6(-0.35,-14.35) AF7(-0.35,-13.65) AF8(-0.35,-12.95) AF9(-0.35,-12.25) AF10(-0.35,-11.55) AF11(-0.35,-10.85) AF13(-0.35,-9.45) AF14(-0.35,-8.75) AF15(-0.35,-8.05) AF16(-0.35,-7.35) AF17(-0.35,-6.65) AF18(-0.35,-5.95) AF19(-0.35,-5.25) AF20(-0.35,-4.55) AF21(-0.35,-3.85) AF22(-0.35,-3.15) AF23(-0.35,-2.45) AF24(-0.35,-1.75) AF25(-0.35,-1.05) AF26(-0.35,-0.35) AF27(-0.35,0.35) AF28(-0.35,1.05) AF29(-0.35,1.75) AF30(-0.35,2.45) AF31(-0.35,3.15) AF32(-0.35,3.85) AF33(-0.35,4.55) AF34(-0.35,5.25) AF35(-0.35,5.95) AF36(-0.35,6.65) AF37(-0.35,7.35) AF38(-0.35,8.05) AF39(-0.35,8.75) AF40(-0.35,9.45) AF42(-0.35,10.85) AF43(-0.35,11.55) AF44(-0.35,12.25) AF45(-0.35,12.95) AF46(-0.35,13.65) AF47(-0.35,14.35) AF48(-0.35,15.05) AF49(-0.35,15.75) AF50(-0.35,16.45) AF51(-0.35,17.15) AF52(-0.35,17.85) AG1(0.35,-17.85) AG2(0.35,-17.15) AG3(0.35,-16.45) AG4(0.35,-15.75) AG5(0.35,-15.05) AG6(0.35,-14.35) AG7(0.35,-13.65) AG8(0.35,-12.95) AG9(0.35,-12.25) AG10(0.35,-11.55) AG11(0.35,-10.85) AG13(0.35,-9.45) AG14(0.35,-8.75) AG15(0.35,-8.05) AG16(0.35,-7.35) AG17(0.35,-6.65) AG18(0.35,-5.95) AG19(0.35,-5.25) AG20(0.35,-4.55) AG21(0.35,-3.85) AG22(0.35,-3.15) AG23(0.35,-2.45) AG24(0.35,-1.75) AG25(0.35,-1.05) AG26(0.35,-0.35) AG27(0.35,0.35) AG28(0.35,1.05) AG29(0.35,1.75) AG30(0.35,2.45) AG31(0.35,3.15) AG32(0.35,3.85) AG33(0.35,4.55) AG34(0.35,5.25) AG35(0.35,5.95) AG36(0.35,6.65) AG37(0.35,7.35) AG38(0.35,8.05) AG39(0.35,8.75) AG40(0.35,9.45) AG42(0.35,10.85) AG43(0.35,11.55) AG44(0.35,12.25) AG45(0.35,12.95) AG46(0.35,13.65) AG47(0.35,14.35) AG48(0.35,15.05) AG49(0.35,15.75) AG50(0.35,16.45) AG51(0.35,17.15) AG52(0.35,17.85) AH2(1.05,-17.15) AH4(1.05,-15.75) AH6(1.05,-14.35) AH8(1.05,-12.95) AH10(1.05,-11.55) AH13(1.05,-9.45) AH14(1.05,-8.75) AH15(1.05,-8.05) AH16(1.05,-7.35) AH17(1.05,-6.65) AH18(1.05,-5.95) AH19(1.05,-5.25) AH20(1.05,-4.55) AH21(1.05,-3.85) AH22(1.05,-3.15) AH23(1.05,-2.45) AH24(1.05,-1.75) AH25(1.05,-1.05) AH26(1.05,-0.35) AH27(1.05,0.35) AH28(1.05,1.05) AH29(1.05,1.75) AH30(1.05,2.45) AH31(1.05,3.15) AH32(1.05,3.85) AH33(1.05,4.55) AH34(1.05,5.25) AH35(1.05,5.95) AH36(1.05,6.65) AH37(1.05,7.35) AH38(1.05,8.05) AH39(1.05,8.75) AH40(1.05,9.45) AH43(1.05,11.55) AH45(1.05,12.95) AH47(1.05,14.35) AH49(1.05,15.75) AH51(1.05,17.15) AJ1(1.75,-17.85) AJ2(1.75,-17.15) AJ3(1.75,-16.45) AJ4(1.75,-15.75) AJ5(1.75,-15.05) AJ6(1.75,-14.35) AJ7(1.75,-13.65) AJ8(1.75,-12.95) AJ9(1.75,-12.25) AJ10(1.75,-11.55) AJ11(1.75,-10.85) AJ13(1.75,-9.45) AJ14(1.75,-8.75) AJ15(1.75,-8.05) AJ16(1.75,-7.35) AJ17(1.75,-6.65) AJ18(1.75,-5.95) AJ19(1.75,-5.25) AJ20(1.75,-4.55) AJ21(1.75,-3.85) AJ22(1.75,-3.15) AJ23(1.75,-2.45) AJ24(1.75,-1.75) AJ25(1.75,-1.05) AJ26(1.75,-0.35) AJ27(1.75,0.35) AJ28(1.75,1.05) AJ29(1.75,1.75) AJ30(1.75,2.45) AJ31(1.75,3.15) AJ32(1.75,3.85) AJ33(1.75,4.55) AJ34(1.75,5.25) AJ35(1.75,5.95) AJ36(1.75,6.65) AJ37(1.75,7.35) AJ38(1.75,8.05) AJ39(1.75,8.75) AJ40(1.75,9.45) AJ42(1.75,10.85) AJ43(1.75,11.55) AJ44(1.75,12.25) AJ45(1.75,12.95) AJ46(1.75,13.65) AJ47(1.75,14.35) AJ48(1.75,15.05) AJ49(1.75,15.75) AJ50(1.75,16.45) AJ51(1.75,17.15) AJ52(1.75,17.85) AK1(2.45,-17.85) AK2(2.45,-17.15) AK3(2.45,-16.45) AK4(2.45,-15.75) AK5(2.45,-15.05) AK6(2.45,-14.35) AK7(2.45,-13.65) AK8(2.45,-12.95) AK9(2.45,-12.25) AK10(2.45,-11.55) AK11(2.45,-10.85) AK13(2.45,-9.45) AK14(2.45,-8.75) AK15(2.45,-8.05) AK16(2.45,-7.35) AK17(2.45,-6.65) AK18(2.45,-5.95) AK19(2.45,-5.25) AK20(2.45,-4.55) AK21(2.45,-3.85) AK22(2.45,-3.15) AK23(2.45,-2.45) AK24(2.45,-1.75) AK25(2.45,-1.05) AK26(2.45,-0.35) AK27(2.45,0.35) AK28(2.45,1.05) AK29(2.45,1.75) AK30(2.45,2.45) AK31(2.45,3.15) AK32(2.45,3.85) AK33(2.45,4.55) AK34(2.45,5.25) AK35(2.45,5.95) AK36(2.45,6.65) AK37(2.45,7.35) AK38(2.45,8.05) AK39(2.45,8.75) AK40(2.45,9.45) AK42(2.45,10.85) AK43(2.45,11.55) AK44(2.45,12.25) AK45(2.45,12.95) AK46(2.45,13.65) AK47(2.45,14.35) AK48(2.45,15.05) AK49(2.45,15.75) AK50(2.45,16.45) AK51(2.45,17.15) AK52(2.45,17.85) AL2(3.15,-17.15) AL4(3.15,-15.75) AL6(3.15,-14.35) AL8(3.15,-12.95) AL10(3.15,-11.55) AL13(3.15,-9.45) AL14(3.15,-8.75) AL15(3.15,-8.05) AL16(3.15,-7.35) AL17(3.15,-6.65) AL18(3.15,-5.95) AL19(3.15,-5.25) AL20(3.15,-4.55) AL21(3.15,-3.85) AL22(3.15,-3.15) AL23(3.15,-2.45) AL24(3.15,-1.75) AL25(3.15,-1.05) AL26(3.15,-0.35) AL27(3.15,0.35) AL28(3.15,1.05) AL29(3.15,1.75) AL30(3.15,2.45) AL31(3.15,3.15) AL32(3.15,3.85) AL33(3.15,4.55) AL34(3.15,5.25) AL35(3.15,5.95) AL36(3.15,6.65) AL37(3.15,7.35) AL38(3.15,8.05) AL39(3.15,8.75) AL40(3.15,9.45) AL43(3.15,11.55) AL45(3.15,12.95) AL47(3.15,14.35) AL49(3.15,15.75) AL51(3.15,17.15) AM1(3.85,-17.85) AM2(3.85,-17.15) AM3(3.85,-16.45) AM4(3.85,-15.75) AM5(3.85,-15.05) AM6(3.85,-14.35) AM7(3.85,-13.65) AM8(3.85,-12.95) AM9(3.85,-12.25) AM10(3.85,-11.55) AM11(3.85,-10.85) AM13(3.85,-9.45) AM14(3.85,-8.75) AM15(3.85,-8.05) AM16(3.85,-7.35) AM17(3.85,-6.65) AM18(3.85,-5.95) AM19(3.85,-5.25) AM20(3.85,-4.55) AM21(3.85,-3.85) AM22(3.85,-3.15) AM23(3.85,-2.45) AM24(3.85,-1.75) AM25(3.85,-1.05) AM26(3.85,-0.35) AM27(3.85,0.35) AM28(3.85,1.05) AM29(3.85,1.75) AM30(3.85,2.45) AM31(3.85,3.15) AM32(3.85,3.85) AM33(3.85,4.55) AM34(3.85,5.25) AM35(3.85,5.95) AM36(3.85,6.65) AM37(3.85,7.35) AM38(3.85,8.05) AM39(3.85,8.75) AM40(3.85,9.45) AM42(3.85,10.85) AM43(3.85,11.55) AM44(3.85,12.25) AM45(3.85,12.95) AM46(3.85,13.65) AM47(3.85,14.35) AM48(3.85,15.05) AM49(3.85,15.75) AM50(3.85,16.45) AM51(3.85,17.15) AM52(3.85,17.85) AN1(4.55,-17.85) AN2(4.55,-17.15) AN3(4.55,-16.45) AN4(4.55,-15.75) AN5(4.55,-15.05) AN6(4.55,-14.35) AN7(4.55,-13.65) AN8(4.55,-12.95) AN9(4.55,-12.25) AN10(4.55,-11.55) AN11(4.55,-10.85) AN13(4.55,-9.45) AN14(4.55,-8.75) AN15(4.55,-8.05) AN16(4.55,-7.35) AN17(4.55,-6.65) AN18(4.55,-5.95) AN19(4.55,-5.25) AN20(4.55,-4.55) AN21(4.55,-3.85) AN22(4.55,-3.15) AN23(4.55,-2.45) AN24(4.55,-1.75) AN25(4.55,-1.05) AN26(4.55,-0.35) AN27(4.55,0.35) AN28(4.55,1.05) AN29(4.55,1.75) AN30(4.55,2.45) AN31(4.55,3.15) AN32(4.55,3.85) AN33(4.55,4.55) AN34(4.55,5.25) AN35(4.55,5.95) AN36(4.55,6.65) AN37(4.55,7.35) AN38(4.55,8.05) AN39(4.55,8.75) AN40(4.55,9.45) AN42(4.55,10.85) AN43(4.55,11.55) AN44(4.55,12.25) AN45(4.55,12.95) AN46(4.55,13.65) AN47(4.55,14.35) AN48(4.55,15.05) AN49(4.55,15.75) AN50(4.55,16.45) AN51(4.55,17.15) AN52(4.55,17.85) AP2(5.25,-17.15) AP4(5.25,-15.75) AP6(5.25,-14.35) AP8(5.25,-12.95) AP10(5.25,-11.55) AP13(5.25,-9.45) AP14(5.25,-8.75) AP15(5.25,-8.05) AP16(5.25,-7.35) AP17(5.25,-6.65) AP18(5.25,-5.95) AP19(5.25,-5.25) AP20(5.25,-4.55) AP21(5.25,-3.85) AP22(5.25,-3.15) AP23(5.25,-2.45) AP24(5.25,-1.75) AP25(5.25,-1.05) AP26(5.25,-0.35) AP27(5.25,0.35) AP28(5.25,1.05) AP29(5.25,1.75) AP30(5.25,2.45) AP31(5.25,3.15) AP32(5.25,3.85) AP33(5.25,4.55) AP34(5.25,5.25) AP35(5.25,5.95) AP36(5.25,6.65) AP37(5.25,7.35) AP38(5.25,8.05) AP39(5.25,8.75) AP40(5.25,9.45) AP43(5.25,11.55) AP45(5.25,12.95) AP47(5.25,14.35) AP49(5.25,15.75) AP51(5.25,17.15) AR1(5.95,-17.85) AR2(5.95,-17.15) AR3(5.95,-16.45) AR4(5.95,-15.75) AR5(5.95,-15.05) AR6(5.95,-14.35) AR7(5.95,-13.65) AR8(5.95,-12.95) AR9(5.95,-12.25) AR10(5.95,-11.55) AR11(5.95,-10.85) AR13(5.95,-9.45) AR14(5.95,-8.75) AR15(5.95,-8.05) AR16(5.95,-7.35) AR17(5.95,-6.65) AR18(5.95,-5.95) AR19(5.95,-5.25) AR20(5.95,-4.55) AR21(5.95,-3.85) AR22(5.95,-3.15) AR23(5.95,-2.45) AR24(5.95,-1.75) AR25(5.95,-1.05) AR26(5.95,-0.35) AR27(5.95,0.35) AR28(5.95,1.05) AR29(5.95,1.75) AR30(5.95,2.45) AR31(5.95,3.15) AR32(5.95,3.85) AR33(5.95,4.55) AR34(5.95,5.25) AR35(5.95,5.95) AR36(5.95,6.65) AR37(5.95,7.35) AR38(5.95,8.05) AR39(5.95,8.75) AR40(5.95,9.45) AR42(5.95,10.85) AR43(5.95,11.55) AR44(5.95,12.25) AR45(5.95,12.95) AR46(5.95,13.65) AR47(5.95,14.35) AR48(5.95,15.05) AR49(5.95,15.75) AR50(5.95,16.45) AR51(5.95,17.15) AR52(5.95,17.85) AT1(6.65,-17.85) AT2(6.65,-17.15) AT3(6.65,-16.45) AT4(6.65,-15.75) AT5(6.65,-15.05) AT6(6.65,-14.35) AT7(6.65,-13.65) AT8(6.65,-12.95) AT9(6.65,-12.25) AT10(6.65,-11.55) AT11(6.65,-10.85) AT13(6.65,-9.45) AT14(6.65,-8.75) AT15(6.65,-8.05) AT16(6.65,-7.35) AT17(6.65,-6.65) AT18(6.65,-5.95) AT19(6.65,-5.25) AT20(6.65,-4.55) AT21(6.65,-3.85) AT22(6.65,-3.15) AT23(6.65,-2.45) AT24(6.65,-1.75) AT25(6.65,-1.05) AT26(6.65,-0.35) AT27(6.65,0.35) AT28(6.65,1.05) AT29(6.65,1.75) AT30(6.65,2.45) AT31(6.65,3.15) AT32(6.65,3.85) AT33(6.65,4.55) AT34(6.65,5.25) AT35(6.65,5.95) AT36(6.65,6.65) AT37(6.65,7.35) AT38(6.65,8.05) AT39(6.65,8.75) AT40(6.65,9.45) AT42(6.65,10.85) AT43(6.65,11.55) AT44(6.65,12.25) AT45(6.65,12.95) AT46(6.65,13.65) AT47(6.65,14.35) AT48(6.65,15.05) AT49(6.65,15.75) AT50(6.65,16.45) AT51(6.65,17.15) AT52(6.65,17.85) AU2(7.35,-17.15) AU4(7.35,-15.75) AU6(7.35,-14.35) AU8(7.35,-12.95) AU10(7.35,-11.55) AU13(7.35,-9.45) AU14(7.35,-8.75) AU15(7.35,-8.05) AU16(7.35,-7.35) AU17(7.35,-6.65) AU18(7.35,-5.95) AU19(7.35,-5.25) AU20(7.35,-4.55) AU21(7.35,-3.85) AU22(7.35,-3.15) AU23(7.35,-2.45) AU24(7.35,-1.75) AU25(7.35,-1.05) AU26(7.35,-0.35) AU27(7.35,0.35) AU28(7.35,1.05) AU29(7.35,1.75) AU30(7.35,2.45) AU31(7.35,3.15) AU32(7.35,3.85) AU33(7.35,4.55) AU34(7.35,5.25) AU35(7.35,5.95) AU36(7.35,6.65) AU37(7.35,7.35) AU38(7.35,8.05) AU39(7.35,8.75) AU40(7.35,9.45) AU43(7.35,11.55) AU45(7.35,12.95) AU47(7.35,14.35) AU49(7.35,15.75) AU51(7.35,17.15) AV1(8.05,-17.85) AV2(8.05,-17.15) AV3(8.05,-16.45) AV4(8.05,-15.75) AV5(8.05,-15.05) AV6(8.05,-14.35) AV7(8.05,-13.65) AV8(8.05,-12.95) AV9(8.05,-12.25) AV10(8.05,-11.55) AV11(8.05,-10.85) AV13(8.05,-9.45) AV14(8.05,-8.75) AV15(8.05,-8.05) AV16(8.05,-7.35) AV17(8.05,-6.65) AV18(8.05,-5.95) AV19(8.05,-5.25) AV20(8.05,-4.55) AV21(8.05,-3.85) AV22(8.05,-3.15) AV23(8.05,-2.45) AV24(8.05,-1.75) AV25(8.05,-1.05) AV26(8.05,-0.35) AV27(8.05,0.35) AV28(8.05,1.05) AV29(8.05,1.75) AV30(8.05,2.45) AV31(8.05,3.15) AV32(8.05,3.85) AV33(8.05,4.55) AV34(8.05,5.25) AV35(8.05,5.95) AV36(8.05,6.65) AV37(8.05,7.35) AV38(8.05,8.05) AV39(8.05,8.75) AV40(8.05,9.45) AV42(8.05,10.85) AV43(8.05,11.55) AV44(8.05,12.25) AV45(8.05,12.95) AV46(8.05,13.65) AV47(8.05,14.35) AV48(8.05,15.05) AV49(8.05,15.75) AV50(8.05,16.45) AV51(8.05,17.15) AV52(8.05,17.85) AW1(8.75,-17.85) AW2(8.75,-17.15) AW3(8.75,-16.45) AW4(8.75,-15.75) AW5(8.75,-15.05) AW6(8.75,-14.35) AW7(8.75,-13.65) AW8(8.75,-12.95) AW9(8.75,-12.25) AW10(8.75,-11.55) AW11(8.75,-10.85) AW13(8.75,-9.45) AW14(8.75,-8.75) AW15(8.75,-8.05) AW16(8.75,-7.35) AW17(8.75,-6.65) AW18(8.75,-5.95) AW19(8.75,-5.25) AW20(8.75,-4.55) AW21(8.75,-3.85) AW22(8.75,-3.15) AW23(8.75,-2.45) AW24(8.75,-1.75) AW25(8.75,-1.05) AW26(8.75,-0.35) AW27(8.75,0.35) AW28(8.75,1.05) AW29(8.75,1.75) AW30(8.75,2.45) AW31(8.75,3.15) AW32(8.75,3.85) AW33(8.75,4.55) AW34(8.75,5.25) AW35(8.75,5.95) AW36(8.75,6.65) AW37(8.75,7.35) AW38(8.75,8.05) AW39(8.75,8.75) AW40(8.75,9.45) AW42(8.75,10.85) AW43(8.75,11.55) AW44(8.75,12.25) AW45(8.75,12.95) AW46(8.75,13.65) AW47(8.75,14.35) AW48(8.75,15.05) AW49(8.75,15.75) AW50(8.75,16.45) AW51(8.75,17.15) AW52(8.75,17.85) AY2(9.45,-17.15) AY4(9.45,-15.75) AY6(9.45,-14.35) AY8(9.45,-12.95) AY10(9.45,-11.55) AY13(9.45,-9.45) AY14(9.45,-8.75) AY15(9.45,-8.05) AY16(9.45,-7.35) AY17(9.45,-6.65) AY18(9.45,-5.95) AY19(9.45,-5.25) AY20(9.45,-4.55) AY21(9.45,-3.85) AY22(9.45,-3.15) AY23(9.45,-2.45) AY24(9.45,-1.75) AY25(9.45,-1.05) AY26(9.45,-0.35) AY27(9.45,0.35) AY28(9.45,1.05) AY29(9.45,1.75) AY30(9.45,2.45) AY31(9.45,3.15) AY32(9.45,3.85) AY33(9.45,4.55) AY34(9.45,5.25) AY35(9.45,5.95) AY36(9.45,6.65) AY37(9.45,7.35) AY38(9.45,8.05) AY39(9.45,8.75) AY40(9.45,9.45) AY43(9.45,11.55) AY45(9.45,12.95) AY47(9.45,14.35) AY49(9.45,15.75) AY51(9.45,17.15) B1(-17.15,-17.85) B2(-17.15,-17.15) B3(-17.15,-16.45) B4(-17.15,-15.75) B5(-17.15,-15.05) B6(-17.15,-14.35) B7(-17.15,-13.65) B8(-17.15,-12.95) B9(-17.15,-12.25) B10(-17.15,-11.55) B11(-17.15,-10.85) B12(-17.15,-10.15) B13(-17.15,-9.45) B14(-17.15,-8.75) B15(-17.15,-8.05) B16(-17.15,-7.35) B17(-17.15,-6.65) B18(-17.15,-5.95) B19(-17.15,-5.25) B20(-17.15,-4.55) B21(-17.15,-3.85) B22(-17.15,-3.15) B23(-17.15,-2.45) B24(-17.15,-1.75) B25(-17.15,-1.05) B26(-17.15,-0.35) B27(-17.15,0.35) B28(-17.15,1.05) B29(-17.15,1.75) B30(-17.15,2.45) B31(-17.15,3.15) B32(-17.15,3.85) B33(-17.15,4.55) B34(-17.15,5.25) B35(-17.15,5.95) B36(-17.15,6.65) B37(-17.15,7.35) B38(-17.15,8.05) B39(-17.15,8.75) B40(-17.15,9.45) B41(-17.15,10.15) B42(-17.15,10.85) B43(-17.15,11.55) B44(-17.15,12.25) B45(-17.15,12.95) B46(-17.15,13.65) B47(-17.15,14.35) B48(-17.15,15.05) B49(-17.15,15.75) B50(-17.15,16.45) B51(-17.15,17.15) B52(-17.15,17.85) BA1(10.15,-17.85) BA2(10.15,-17.15) BA3(10.15,-16.45) BA4(10.15,-15.75) BA5(10.15,-15.05) BA6(10.15,-14.35) BA7(10.15,-13.65) BA8(10.15,-12.95) BA9(10.15,-12.25) BA10(10.15,-11.55) BA43(10.15,11.55) BA44(10.15,12.25) BA45(10.15,12.95) BA46(10.15,13.65) BA47(10.15,14.35) BA48(10.15,15.05) BA49(10.15,15.75) BA50(10.15,16.45) BA51(10.15,17.15) BA52(10.15,17.85) BB1(10.85,-17.85) BB2(10.85,-17.15) BB3(10.85,-16.45) BB4(10.85,-15.75) BB5(10.85,-15.05) BB6(10.85,-14.35) BB7(10.85,-13.65) BB8(10.85,-12.95) BB14(10.85,-8.75) BB15(10.85,-8.05) BB17(10.85,-6.65) BB18(10.85,-5.95) BB20(10.85,-4.55) BB21(10.85,-3.85) BB23(10.85,-2.45) BB24(10.85,-1.75) BB26(10.85,-0.35) BB27(10.85,0.35) BB29(10.85,1.75) BB30(10.85,2.45) BB32(10.85,3.85) BB33(10.85,4.55) BB35(10.85,5.95) BB36(10.85,6.65) BB38(10.85,8.05) BB39(10.85,8.75) BB45(10.85,12.95) BB46(10.85,13.65) BB47(10.85,14.35) BB48(10.85,15.05) BB49(10.85,15.75) BB50(10.85,16.45) BB51(10.85,17.15) BB52(10.85,17.85) BC2(11.55,-17.15) BC4(11.55,-15.75) BC6(11.55,-14.35) BC8(11.55,-12.95) BC12(11.55,-10.15) BC13(11.55,-9.45) BC14(11.55,-8.75) BC15(11.55,-8.05) BC16(11.55,-7.35) BC17(11.55,-6.65) BC18(11.55,-5.95) BC19(11.55,-5.25) BC20(11.55,-4.55) BC21(11.55,-3.85) BC22(11.55,-3.15) BC23(11.55,-2.45) BC24(11.55,-1.75) BC25(11.55,-1.05) BC26(11.55,-0.35) BC27(11.55,0.35) BC28(11.55,1.05) BC29(11.55,1.75) BC30(11.55,2.45) BC31(11.55,3.15) BC32(11.55,3.85) BC33(11.55,4.55) BC34(11.55,5.25) BC35(11.55,5.95) BC36(11.55,6.65) BC37(11.55,7.35) BC38(11.55,8.05) BC39(11.55,8.75) BC40(11.55,9.45) BC41(11.55,10.15) BC45(11.55,12.95) BC47(11.55,14.35) BC49(11.55,15.75) BC51(11.55,17.15) BD1(12.25,-17.85) BD2(12.25,-17.15) BD3(12.25,-16.45) BD4(12.25,-15.75) BD5(12.25,-15.05) BD6(12.25,-14.35) BD7(12.25,-13.65) BD12(12.25,-10.15) BD14(12.25,-8.75) BD15(12.25,-8.05) BD17(12.25,-6.65) BD18(12.25,-5.95) BD20(12.25,-4.55) BD21(12.25,-3.85) BD23(12.25,-2.45) BD24(12.25,-1.75) BD26(12.25,-0.35) BD27(12.25,0.35) BD29(12.25,1.75) BD30(12.25,2.45) BD32(12.25,3.85) BD33(12.25,4.55) BD35(12.25,5.95) BD36(12.25,6.65) BD38(12.25,8.05) BD39(12.25,8.75) BD41(12.25,10.15) BD46(12.25,13.65) BD47(12.25,14.35) BD48(12.25,15.05) BD49(12.25,15.75) BD50(12.25,16.45) BD51(12.25,17.15) BD52(12.25,17.85) BE1(12.95,-17.85) BE2(12.95,-17.15) BE3(12.95,-16.45) BE4(12.95,-15.75) BE5(12.95,-15.05) BE6(12.95,-14.35) BE7(12.95,-13.65) BE10(12.95,-11.55) BE11(12.95,-10.85) BE12(12.95,-10.15) BE13(12.95,-9.45) BE14(12.95,-8.75) BE15(12.95,-8.05) BE16(12.95,-7.35) BE17(12.95,-6.65) BE18(12.95,-5.95) BE19(12.95,-5.25) BE20(12.95,-4.55) BE21(12.95,-3.85) BE22(12.95,-3.15) BE23(12.95,-2.45) BE24(12.95,-1.75) BE25(12.95,-1.05) BE26(12.95,-0.35) BE27(12.95,0.35) BE28(12.95,1.05) BE29(12.95,1.75) BE30(12.95,2.45) BE31(12.95,3.15) BE32(12.95,3.85) BE33(12.95,4.55) BE34(12.95,5.25) BE35(12.95,5.95) BE36(12.95,6.65) BE37(12.95,7.35) BE38(12.95,8.05) BE39(12.95,8.75) BE40(12.95,9.45) BE41(12.95,10.15) BE42(12.95,10.85) BE43(12.95,11.55) BE46(12.95,13.65) BE47(12.95,14.35) BE48(12.95,15.05) BE49(12.95,15.75) BE50(12.95,16.45) BE51(12.95,17.15) BE52(12.95,17.85) BF2(13.65,-17.15) BF4(13.65,-15.75) BF6(13.65,-14.35) BF8(13.65,-12.95) BF9(13.65,-12.25) BF11(13.65,-10.85) BF12(13.65,-10.15) BF14(13.65,-8.75) BF15(13.65,-8.05) BF17(13.65,-6.65) BF18(13.65,-5.95) BF20(13.65,-4.55) BF21(13.65,-3.85) BF23(13.65,-2.45) BF24(13.65,-1.75) BF26(13.65,-0.35) BF27(13.65,0.35) BF29(13.65,1.75) BF30(13.65,2.45) BF32(13.65,3.85) BF33(13.65,4.55) BF35(13.65,5.95) BF36(13.65,6.65) BF38(13.65,8.05) BF39(13.65,8.75) BF41(13.65,10.15) BF42(13.65,10.85) BF44(13.65,12.25) BF45(13.65,12.95) BF47(13.65,14.35) BF49(13.65,15.75) BF51(13.65,17.15) BG1(14.35,-17.85) BG2(14.35,-17.15) BG3(14.35,-16.45) BG4(14.35,-15.75) BG5(14.35,-15.05) BG6(14.35,-14.35) BG7(14.35,-13.65) BG8(14.35,-12.95) BG9(14.35,-12.25) BG10(14.35,-11.55) BG11(14.35,-10.85) BG12(14.35,-10.15) BG13(14.35,-9.45) BG14(14.35,-8.75) BG15(14.35,-8.05) BG16(14.35,-7.35) BG17(14.35,-6.65) BG18(14.35,-5.95) BG19(14.35,-5.25) BG20(14.35,-4.55) BG21(14.35,-3.85) BG22(14.35,-3.15) BG23(14.35,-2.45) BG24(14.35,-1.75) BG25(14.35,-1.05) BG26(14.35,-0.35) BG27(14.35,0.35) BG28(14.35,1.05) BG29(14.35,1.75) BG30(14.35,2.45) BG31(14.35,3.15) BG32(14.35,3.85) BG33(14.35,4.55) BG34(14.35,5.25) BG35(14.35,5.95) BG36(14.35,6.65) BG37(14.35,7.35) BG38(14.35,8.05) BG39(14.35,8.75) BG40(14.35,9.45) BG41(14.35,10.15) BG42(14.35,10.85) BG43(14.35,11.55) BG44(14.35,12.25) BG45(14.35,12.95) BG46(14.35,13.65) BG47(14.35,14.35) BG48(14.35,15.05) BG49(14.35,15.75) BG50(14.35,16.45) BG51(14.35,17.15) BG52(14.35,17.85) BH1(15.05,-17.85) BH2(15.05,-17.15) BH3(15.05,-16.45) BH4(15.05,-15.75) BH5(15.05,-15.05) BH6(15.05,-14.35) BH8(15.05,-12.95) BH9(15.05,-12.25) BH11(15.05,-10.85) BH12(15.05,-10.15) BH14(15.05,-8.75) BH15(15.05,-8.05) BH17(15.05,-6.65) BH18(15.05,-5.95) BH20(15.05,-4.55) BH21(15.05,-3.85) BH23(15.05,-2.45) BH24(15.05,-1.75) BH26(15.05,-0.35) BH27(15.05,0.35) BH29(15.05,1.75) BH30(15.05,2.45) BH32(15.05,3.85) BH33(15.05,4.55) BH35(15.05,5.95) BH36(15.05,6.65) BH38(15.05,8.05) BH39(15.05,8.75) BH41(15.05,10.15) BH42(15.05,10.85) BH44(15.05,12.25) BH45(15.05,12.95) BH47(15.05,14.35) BH48(15.05,15.05) BH49(15.05,15.75) BH50(15.05,16.45) BH51(15.05,17.15) BH52(15.05,17.85) BJ1(15.75,-17.85) BJ2(15.75,-17.15) BJ3(15.75,-16.45) BJ4(15.75,-15.75) BJ5(15.75,-15.05) BJ6(15.75,-14.35) BJ7(15.75,-13.65) BJ8(15.75,-12.95) BJ9(15.75,-12.25) BJ10(15.75,-11.55) BJ11(15.75,-10.85) BJ12(15.75,-10.15) BJ13(15.75,-9.45) BJ14(15.75,-8.75) BJ15(15.75,-8.05) BJ16(15.75,-7.35) BJ17(15.75,-6.65) BJ18(15.75,-5.95) BJ19(15.75,-5.25) BJ20(15.75,-4.55) BJ21(15.75,-3.85) BJ22(15.75,-3.15) BJ23(15.75,-2.45) BJ24(15.75,-1.75) BJ25(15.75,-1.05) BJ26(15.75,-0.35) BJ27(15.75,0.35) BJ28(15.75,1.05) BJ29(15.75,1.75) BJ30(15.75,2.45) BJ31(15.75,3.15) BJ32(15.75,3.85) BJ33(15.75,4.55) BJ34(15.75,5.25) BJ35(15.75,5.95) BJ36(15.75,6.65) BJ37(15.75,7.35) BJ38(15.75,8.05) BJ39(15.75,8.75) BJ40(15.75,9.45) BJ41(15.75,10.15) BJ42(15.75,10.85) BJ43(15.75,11.55) BJ44(15.75,12.25) BJ45(15.75,12.95) BJ46(15.75,13.65) BJ47(15.75,14.35) BJ48(15.75,15.05) BJ49(15.75,15.75) BJ50(15.75,16.45) BJ51(15.75,17.15) BJ52(15.75,17.85) BK1(16.45,-17.85) BK2(16.45,-17.15) BK3(16.45,-16.45) BK4(16.45,-15.75) BK5(16.45,-15.05) BK6(16.45,-14.35) BK8(16.45,-12.95) BK9(16.45,-12.25) BK11(16.45,-10.85) BK12(16.45,-10.15) BK14(16.45,-8.75) BK15(16.45,-8.05) BK17(16.45,-6.65) BK18(16.45,-5.95) BK20(16.45,-4.55) BK21(16.45,-3.85) BK23(16.45,-2.45) BK24(16.45,-1.75) BK26(16.45,-0.35) BK27(16.45,0.35) BK29(16.45,1.75) BK30(16.45,2.45) BK32(16.45,3.85) BK33(16.45,4.55) BK35(16.45,5.95) BK36(16.45,6.65) BK38(16.45,8.05) BK39(16.45,8.75) BK41(16.45,10.15) BK42(16.45,10.85) BK44(16.45,12.25) BK45(16.45,12.95) BK47(16.45,14.35) BK48(16.45,15.05) BK49(16.45,15.75) BK50(16.45,16.45) BK51(16.45,17.15) BK52(16.45,17.85) BL1(17.15,-17.85) BL2(17.15,-17.15) BL3(17.15,-16.45) BL4(17.15,-15.75) BL5(17.15,-15.05) BL6(17.15,-14.35) BL7(17.15,-13.65) BL8(17.15,-12.95) BL9(17.15,-12.25) BL10(17.15,-11.55) BL11(17.15,-10.85) BL12(17.15,-10.15) BL13(17.15,-9.45) BL14(17.15,-8.75) BL15(17.15,-8.05) BL16(17.15,-7.35) BL17(17.15,-6.65) BL18(17.15,-5.95) BL19(17.15,-5.25) BL20(17.15,-4.55) BL21(17.15,-3.85) BL22(17.15,-3.15) BL23(17.15,-2.45) BL24(17.15,-1.75) BL25(17.15,-1.05) BL26(17.15,-0.35) BL27(17.15,0.35) BL28(17.15,1.05) BL29(17.15,1.75) BL30(17.15,2.45) BL31(17.15,3.15) BL32(17.15,3.85) BL33(17.15,4.55) BL34(17.15,5.25) BL35(17.15,5.95) BL36(17.15,6.65) BL37(17.15,7.35) BL38(17.15,8.05) BL39(17.15,8.75) BL40(17.15,9.45) BL41(17.15,10.15) BL42(17.15,10.85) BL43(17.15,11.55) BL44(17.15,12.25) BL45(17.15,12.95) BL46(17.15,13.65) BL47(17.15,14.35) BL48(17.15,15.05) BL49(17.15,15.75) BL50(17.15,16.45) BL51(17.15,17.15) BL52(17.15,17.85) BM2(17.85,-17.15) BM3(17.85,-16.45) BM4(17.85,-15.75) BM5(17.85,-15.05) BM6(17.85,-14.35) BM8(17.85,-12.95) BM9(17.85,-12.25) BM11(17.85,-10.85) BM12(17.85,-10.15) BM14(17.85,-8.75) BM15(17.85,-8.05) BM17(17.85,-6.65) BM18(17.85,-5.95) BM20(17.85,-4.55) BM21(17.85,-3.85) BM23(17.85,-2.45) BM24(17.85,-1.75) BM26(17.85,-0.35) BM27(17.85,0.35) BM29(17.85,1.75) BM30(17.85,2.45) BM32(17.85,3.85) BM33(17.85,4.55) BM35(17.85,5.95) BM36(17.85,6.65) BM38(17.85,8.05) BM39(17.85,8.75) BM41(17.85,10.15) BM42(17.85,10.85) BM44(17.85,12.25) BM45(17.85,12.95) BM47(17.85,14.35) BM48(17.85,15.05) BM49(17.85,15.75) BM50(17.85,16.45) BM51(17.85,17.15) C1(-16.45,-17.85) C2(-16.45,-17.15) C3(-16.45,-16.45) C4(-16.45,-15.75) C5(-16.45,-15.05) C6(-16.45,-14.35) C8(-16.45,-12.95) C9(-16.45,-12.25) C11(-16.45,-10.85) C12(-16.45,-10.15) C14(-16.45,-8.75) C15(-16.45,-8.05) C17(-16.45,-6.65) C18(-16.45,-5.95) C20(-16.45,-4.55) C21(-16.45,-3.85) C23(-16.45,-2.45) C24(-16.45,-1.75) C26(-16.45,-0.35) C27(-16.45,0.35) C29(-16.45,1.75) C30(-16.45,2.45) C32(-16.45,3.85) C33(-16.45,4.55) C35(-16.45,5.95) C36(-16.45,6.65) C38(-16.45,8.05) C39(-16.45,8.75) C41(-16.45,10.15) C42(-16.45,10.85) C44(-16.45,12.25) C45(-16.45,12.95) C47(-16.45,14.35) C48(-16.45,15.05) C49(-16.45,15.75) C50(-16.45,16.45) C51(-16.45,17.15) C52(-16.45,17.85) D1(-15.75,-17.85) D2(-15.75,-17.15) D3(-15.75,-16.45) D4(-15.75,-15.75) D5(-15.75,-15.05) D6(-15.75,-14.35) D7(-15.75,-13.65) D8(-15.75,-12.95) D9(-15.75,-12.25) D10(-15.75,-11.55) D11(-15.75,-10.85) D12(-15.75,-10.15) D13(-15.75,-9.45) D14(-15.75,-8.75) D15(-15.75,-8.05) D16(-15.75,-7.35) D17(-15.75,-6.65) D18(-15.75,-5.95) D19(-15.75,-5.25) D20(-15.75,-4.55) D21(-15.75,-3.85) D22(-15.75,-3.15) D23(-15.75,-2.45) D24(-15.75,-1.75) D25(-15.75,-1.05) D26(-15.75,-0.35) D27(-15.75,0.35) D28(-15.75,1.05) D29(-15.75,1.75) D30(-15.75,2.45) D31(-15.75,3.15) D32(-15.75,3.85) D33(-15.75,4.55) D34(-15.75,5.25) D35(-15.75,5.95) D36(-15.75,6.65) D37(-15.75,7.35) D38(-15.75,8.05) D39(-15.75,8.75) D40(-15.75,9.45) D41(-15.75,10.15) D42(-15.75,10.85) D43(-15.75,11.55) D44(-15.75,12.25) D45(-15.75,12.95) D46(-15.75,13.65) D47(-15.75,14.35) D48(-15.75,15.05) D49(-15.75,15.75) D50(-15.75,16.45) D51(-15.75,17.15) D52(-15.75,17.85) E1(-15.05,-17.85) E2(-15.05,-17.15) E3(-15.05,-16.45) E4(-15.05,-15.75) E5(-15.05,-15.05) E6(-15.05,-14.35) E8(-15.05,-12.95) E9(-15.05,-12.25) E11(-15.05,-10.85) E12(-15.05,-10.15) E14(-15.05,-8.75) E15(-15.05,-8.05) E17(-15.05,-6.65) E18(-15.05,-5.95) E20(-15.05,-4.55) E21(-15.05,-3.85) E23(-15.05,-2.45) E24(-15.05,-1.75) E26(-15.05,-0.35) E27(-15.05,0.35) E29(-15.05,1.75) E30(-15.05,2.45) E32(-15.05,3.85) E33(-15.05,4.55) E35(-15.05,5.95) E36(-15.05,6.65) E38(-15.05,8.05) E39(-15.05,8.75) E41(-15.05,10.15) E42(-15.05,10.85) E44(-15.05,12.25) E45(-15.05,12.95) E47(-15.05,14.35) E48(-15.05,15.05) E49(-15.05,15.75) E50(-15.05,16.45) E51(-15.05,17.15) E52(-15.05,17.85) F1(-14.35,-17.85) F2(-14.35,-17.15) F3(-14.35,-16.45) F4(-14.35,-15.75) F5(-14.35,-15.05) F6(-14.35,-14.35) F7(-14.35,-13.65) F8(-14.35,-12.95) F9(-14.35,-12.25) F10(-14.35,-11.55) F11(-14.35,-10.85) F12(-14.35,-10.15) F13(-14.35,-9.45) F14(-14.35,-8.75) F15(-14.35,-8.05) F16(-14.35,-7.35) F17(-14.35,-6.65) F18(-14.35,-5.95) F19(-14.35,-5.25) F20(-14.35,-4.55) F21(-14.35,-3.85) F22(-14.35,-3.15) F23(-14.35,-2.45) F24(-14.35,-1.75) F25(-14.35,-1.05) F26(-14.35,-0.35) F27(-14.35,0.35) F28(-14.35,1.05) F29(-14.35,1.75) F30(-14.35,2.45) F31(-14.35,3.15) F32(-14.35,3.85) F33(-14.35,4.55) F34(-14.35,5.25) F35(-14.35,5.95) F36(-14.35,6.65) F37(-14.35,7.35) F38(-14.35,8.05) F39(-14.35,8.75) F40(-14.35,9.45) F41(-14.35,10.15) F42(-14.35,10.85) F43(-14.35,11.55) F44(-14.35,12.25) F45(-14.35,12.95) F46(-14.35,13.65) F47(-14.35,14.35) F48(-14.35,15.05) F49(-14.35,15.75) F50(-14.35,16.45) F51(-14.35,17.15) F52(-14.35,17.85) G2(-13.65,-17.15) G4(-13.65,-15.75) G6(-13.65,-14.35) G8(-13.65,-12.95) G9(-13.65,-12.25) G11(-13.65,-10.85) G12(-13.65,-10.15) G14(-13.65,-8.75) G15(-13.65,-8.05) G17(-13.65,-6.65) G18(-13.65,-5.95) G20(-13.65,-4.55) G21(-13.65,-3.85) G23(-13.65,-2.45) G24(-13.65,-1.75) G26(-13.65,-0.35) G27(-13.65,0.35) G29(-13.65,1.75) G30(-13.65,2.45) G32(-13.65,3.85) G33(-13.65,4.55) G35(-13.65,5.95) G36(-13.65,6.65) G38(-13.65,8.05) G39(-13.65,8.75) G41(-13.65,10.15) G42(-13.65,10.85) G44(-13.65,12.25) G45(-13.65,12.95) G47(-13.65,14.35) G49(-13.65,15.75) G51(-13.65,17.15) H1(-12.95,-17.85) H2(-12.95,-17.15) H3(-12.95,-16.45) H4(-12.95,-15.75) H5(-12.95,-15.05) H6(-12.95,-14.35) H7(-12.95,-13.65) H10(-12.95,-11.55) H11(-12.95,-10.85) H12(-12.95,-10.15) H13(-12.95,-9.45) H14(-12.95,-8.75) H15(-12.95,-8.05) H16(-12.95,-7.35) H17(-12.95,-6.65) H18(-12.95,-5.95) H19(-12.95,-5.25) H20(-12.95,-4.55) H21(-12.95,-3.85) H22(-12.95,-3.15) H23(-12.95,-2.45) H24(-12.95,-1.75) H25(-12.95,-1.05) H26(-12.95,-0.35) H27(-12.95,0.35) H28(-12.95,1.05) H29(-12.95,1.75) H30(-12.95,2.45) H31(-12.95,3.15) H32(-12.95,3.85) H33(-12.95,4.55) H34(-12.95,5.25) H35(-12.95,5.95) H36(-12.95,6.65) H37(-12.95,7.35) H38(-12.95,8.05) H39(-12.95,8.75) H40(-12.95,9.45) H41(-12.95,10.15) H42(-12.95,10.85) H43(-12.95,11.55) H46(-12.95,13.65) H47(-12.95,14.35) H48(-12.95,15.05) H49(-12.95,15.75) H50(-12.95,16.45) H51(-12.95,17.15) H52(-12.95,17.85) J1(-12.25,-17.85) J2(-12.25,-17.15) J3(-12.25,-16.45) J4(-12.25,-15.75) J5(-12.25,-15.05) J6(-12.25,-14.35) J7(-12.25,-13.65) J12(-12.25,-10.15) J14(-12.25,-8.75) J15(-12.25,-8.05) J17(-12.25,-6.65) J18(-12.25,-5.95) J20(-12.25,-4.55) J21(-12.25,-3.85) J23(-12.25,-2.45) J24(-12.25,-1.75) J26(-12.25,-0.35) J27(-12.25,0.35) J29(-12.25,1.75) J30(-12.25,2.45) J32(-12.25,3.85) J33(-12.25,4.55) J35(-12.25,5.95) J36(-12.25,6.65) J38(-12.25,8.05) J39(-12.25,8.75) J41(-12.25,10.15) J46(-12.25,13.65) J47(-12.25,14.35) J48(-12.25,15.05) J49(-12.25,15.75) J50(-12.25,16.45) J51(-12.25,17.15) J52(-12.25,17.85) K2(-11.55,-17.15) K4(-11.55,-15.75) K6(-11.55,-14.35) K8(-11.55,-12.95) K12(-11.55,-10.15) K13(-11.55,-9.45) K14(-11.55,-8.75) K15(-11.55,-8.05) K16(-11.55,-7.35) K17(-11.55,-6.65) K18(-11.55,-5.95) K19(-11.55,-5.25) K20(-11.55,-4.55) K21(-11.55,-3.85) K22(-11.55,-3.15) K23(-11.55,-2.45) K24(-11.55,-1.75) K25(-11.55,-1.05) K26(-11.55,-0.35) K27(-11.55,0.35) K28(-11.55,1.05) K29(-11.55,1.75) K30(-11.55,2.45) K31(-11.55,3.15) K32(-11.55,3.85) K33(-11.55,4.55) K34(-11.55,5.25) K35(-11.55,5.95) K36(-11.55,6.65) K37(-11.55,7.35) K38(-11.55,8.05) K39(-11.55,8.75) K40(-11.55,9.45) K41(-11.55,10.15) K45(-11.55,12.95) K47(-11.55,14.35) K49(-11.55,15.75) K51(-11.55,17.15) L1(-10.85,-17.85) L2(-10.85,-17.15) L3(-10.85,-16.45) L4(-10.85,-15.75) L5(-10.85,-15.05) L6(-10.85,-14.35) L7(-10.85,-13.65) L8(-10.85,-12.95) L14(-10.85,-8.75) L15(-10.85,-8.05) L17(-10.85,-6.65) L18(-10.85,-5.95) L20(-10.85,-4.55) L21(-10.85,-3.85) L23(-10.85,-2.45) L24(-10.85,-1.75) L26(-10.85,-0.35) L27(-10.85,0.35) L29(-10.85,1.75) L30(-10.85,2.45) L32(-10.85,3.85) L33(-10.85,4.55) L35(-10.85,5.95) L36(-10.85,6.65) L38(-10.85,8.05) L39(-10.85,8.75) L45(-10.85,12.95) L46(-10.85,13.65) L47(-10.85,14.35) L48(-10.85,15.05) L49(-10.85,15.75) L50(-10.85,16.45) L51(-10.85,17.15) L52(-10.85,17.85) M1(-10.15,-17.85) M2(-10.15,-17.15) M3(-10.15,-16.45) M4(-10.15,-15.75) M5(-10.15,-15.05) M6(-10.15,-14.35) M7(-10.15,-13.65) M8(-10.15,-12.95) M9(-10.15,-12.25) M10(-10.15,-11.55) M43(-10.15,11.55) M44(-10.15,12.25) M45(-10.15,12.95) M46(-10.15,13.65) M47(-10.15,14.35) M48(-10.15,15.05) M49(-10.15,15.75) M50(-10.15,16.45) M51(-10.15,17.15) M52(-10.15,17.85) N2(-9.45,-17.15) N4(-9.45,-15.75) N6(-9.45,-14.35) N8(-9.45,-12.95) N10(-9.45,-11.55) N13(-9.45,-9.45) N14(-9.45,-8.75) N15(-9.45,-8.05) N16(-9.45,-7.35) N17(-9.45,-6.65) N18(-9.45,-5.95) N19(-9.45,-5.25) N20(-9.45,-4.55) N21(-9.45,-3.85) N22(-9.45,-3.15) N23(-9.45,-2.45) N24(-9.45,-1.75) N25(-9.45,-1.05) N26(-9.45,-0.35) N27(-9.45,0.35) N28(-9.45,1.05) N29(-9.45,1.75) N30(-9.45,2.45) N31(-9.45,3.15) N32(-9.45,3.85) N33(-9.45,4.55) N34(-9.45,5.25) N35(-9.45,5.95) N36(-9.45,6.65) N37(-9.45,7.35) N38(-9.45,8.05) N39(-9.45,8.75) N40(-9.45,9.45) N43(-9.45,11.55) N45(-9.45,12.95) N47(-9.45,14.35) N49(-9.45,15.75) N51(-9.45,17.15) P1(-8.75,-17.85) P2(-8.75,-17.15) P3(-8.75,-16.45) P4(-8.75,-15.75) P5(-8.75,-15.05) P6(-8.75,-14.35) P7(-8.75,-13.65) P8(-8.75,-12.95) P9(-8.75,-12.25) P10(-8.75,-11.55) P11(-8.75,-10.85) P13(-8.75,-9.45) P14(-8.75,-8.75) P15(-8.75,-8.05) P16(-8.75,-7.35) P17(-8.75,-6.65) P18(-8.75,-5.95) P19(-8.75,-5.25) P20(-8.75,-4.55) P21(-8.75,-3.85) P22(-8.75,-3.15) P23(-8.75,-2.45) P24(-8.75,-1.75) P25(-8.75,-1.05) P26(-8.75,-0.35) P27(-8.75,0.35) P28(-8.75,1.05) P29(-8.75,1.75) P30(-8.75,2.45) P31(-8.75,3.15) P32(-8.75,3.85) P33(-8.75,4.55) P34(-8.75,5.25) P35(-8.75,5.95) P36(-8.75,6.65) P37(-8.75,7.35) P38(-8.75,8.05) P39(-8.75,8.75) P40(-8.75,9.45) P42(-8.75,10.85) P43(-8.75,11.55) P44(-8.75,12.25) P45(-8.75,12.95) P46(-8.75,13.65) P47(-8.75,14.35) P48(-8.75,15.05) P49(-8.75,15.75) P50(-8.75,16.45) P51(-8.75,17.15) P52(-8.75,17.85) R1(-8.05,-17.85) R2(-8.05,-17.15) R3(-8.05,-16.45) R4(-8.05,-15.75) R5(-8.05,-15.05) R6(-8.05,-14.35) R7(-8.05,-13.65) R8(-8.05,-12.95) R9(-8.05,-12.25) R10(-8.05,-11.55) R11(-8.05,-10.85) R13(-8.05,-9.45) R14(-8.05,-8.75) R15(-8.05,-8.05) R16(-8.05,-7.35) R17(-8.05,-6.65) R18(-8.05,-5.95) R19(-8.05,-5.25) R20(-8.05,-4.55) R21(-8.05,-3.85) R22(-8.05,-3.15) R23(-8.05,-2.45) R24(-8.05,-1.75) R25(-8.05,-1.05) R26(-8.05,-0.35) R27(-8.05,0.35) R28(-8.05,1.05) R29(-8.05,1.75) R30(-8.05,2.45) R31(-8.05,3.15) R32(-8.05,3.85) R33(-8.05,4.55) R34(-8.05,5.25) R35(-8.05,5.95) R36(-8.05,6.65) R37(-8.05,7.35) R38(-8.05,8.05) R39(-8.05,8.75) R40(-8.05,9.45) R42(-8.05,10.85) R43(-8.05,11.55) R44(-8.05,12.25) R45(-8.05,12.95) R46(-8.05,13.65) R47(-8.05,14.35) R48(-8.05,15.05) R49(-8.05,15.75) R50(-8.05,16.45) R51(-8.05,17.15) R52(-8.05,17.85) T2(-7.35,-17.15) T4(-7.35,-15.75) T6(-7.35,-14.35) T8(-7.35,-12.95) T10(-7.35,-11.55) T13(-7.35,-9.45) T14(-7.35,-8.75) T15(-7.35,-8.05) T16(-7.35,-7.35) T17(-7.35,-6.65) T18(-7.35,-5.95) T19(-7.35,-5.25) T20(-7.35,-4.55) T21(-7.35,-3.85) T22(-7.35,-3.15) T23(-7.35,-2.45) T24(-7.35,-1.75) T25(-7.35,-1.05) T26(-7.35,-0.35) T27(-7.35,0.35) T28(-7.35,1.05) T29(-7.35,1.75) T30(-7.35,2.45) T31(-7.35,3.15) T32(-7.35,3.85) T33(-7.35,4.55) T34(-7.35,5.25) T35(-7.35,5.95) T36(-7.35,6.65) T37(-7.35,7.35) T38(-7.35,8.05) T39(-7.35,8.75) T40(-7.35,9.45) T43(-7.35,11.55) T45(-7.35,12.95) T47(-7.35,14.35) T49(-7.35,15.75) T51(-7.35,17.15) U1(-6.65,-17.85) U2(-6.65,-17.15) U3(-6.65,-16.45) U4(-6.65,-15.75) U5(-6.65,-15.05) U6(-6.65,-14.35) U7(-6.65,-13.65) U8(-6.65,-12.95) U9(-6.65,-12.25) U10(-6.65,-11.55) U11(-6.65,-10.85) U13(-6.65,-9.45) U14(-6.65,-8.75) U15(-6.65,-8.05) U16(-6.65,-7.35) U17(-6.65,-6.65) U18(-6.65,-5.95) U19(-6.65,-5.25) U20(-6.65,-4.55) U21(-6.65,-3.85) U22(-6.65,-3.15) U23(-6.65,-2.45) U24(-6.65,-1.75) U25(-6.65,-1.05) U26(-6.65,-0.35) U27(-6.65,0.35) U28(-6.65,1.05) U29(-6.65,1.75) U30(-6.65,2.45) U31(-6.65,3.15) U32(-6.65,3.85) U33(-6.65,4.55) U34(-6.65,5.25) U35(-6.65,5.95) U36(-6.65,6.65) U37(-6.65,7.35) U38(-6.65,8.05) U39(-6.65,8.75) U40(-6.65,9.45) U42(-6.65,10.85) U43(-6.65,11.55) U44(-6.65,12.25) U45(-6.65,12.95) U46(-6.65,13.65) U47(-6.65,14.35) U48(-6.65,15.05) U49(-6.65,15.75) U50(-6.65,16.45) U51(-6.65,17.15) U52(-6.65,17.85) V1(-5.95,-17.85) V2(-5.95,-17.15) V3(-5.95,-16.45) V4(-5.95,-15.75) V5(-5.95,-15.05) V6(-5.95,-14.35) V7(-5.95,-13.65) V8(-5.95,-12.95) V9(-5.95,-12.25) V10(-5.95,-11.55) V11(-5.95,-10.85) V13(-5.95,-9.45) V14(-5.95,-8.75) V15(-5.95,-8.05) V16(-5.95,-7.35) V17(-5.95,-6.65) V18(-5.95,-5.95) V19(-5.95,-5.25) V20(-5.95,-4.55) V21(-5.95,-3.85) V22(-5.95,-3.15) V23(-5.95,-2.45) V24(-5.95,-1.75) V25(-5.95,-1.05) V26(-5.95,-0.35) V27(-5.95,0.35) V28(-5.95,1.05) V29(-5.95,1.75) V30(-5.95,2.45) V31(-5.95,3.15) V32(-5.95,3.85) V33(-5.95,4.55) V34(-5.95,5.25) V35(-5.95,5.95) V36(-5.95,6.65) V37(-5.95,7.35) V38(-5.95,8.05) V39(-5.95,8.75) V40(-5.95,9.45) V42(-5.95,10.85) V43(-5.95,11.55) V44(-5.95,12.25) V45(-5.95,12.95) V46(-5.95,13.65) V47(-5.95,14.35) V48(-5.95,15.05) V49(-5.95,15.75) V50(-5.95,16.45) V51(-5.95,17.15) V52(-5.95,17.85) W2(-5.25,-17.15) W4(-5.25,-15.75) W6(-5.25,-14.35) W8(-5.25,-12.95) W10(-5.25,-11.55) W13(-5.25,-9.45) W14(-5.25,-8.75) W15(-5.25,-8.05) W16(-5.25,-7.35) W17(-5.25,-6.65) W18(-5.25,-5.95) W19(-5.25,-5.25) W20(-5.25,-4.55) W21(-5.25,-3.85) W22(-5.25,-3.15) W23(-5.25,-2.45) W24(-5.25,-1.75) W25(-5.25,-1.05) W26(-5.25,-0.35) W27(-5.25,0.35) W28(-5.25,1.05) W29(-5.25,1.75) W30(-5.25,2.45) W31(-5.25,3.15) W32(-5.25,3.85) W33(-5.25,4.55) W34(-5.25,5.25) W35(-5.25,5.95) W36(-5.25,6.65) W37(-5.25,7.35) W38(-5.25,8.05) W39(-5.25,8.75) W40(-5.25,9.45) W43(-5.25,11.55) W45(-5.25,12.95) W47(-5.25,14.35) W49(-5.25,15.75) W51(-5.25,17.15) Y1(-4.55,-17.85) Y2(-4.55,-17.15) Y3(-4.55,-16.45) Y4(-4.55,-15.75) Y5(-4.55,-15.05) Y6(-4.55,-14.35) Y7(-4.55,-13.65) Y8(-4.55,-12.95) Y9(-4.55,-12.25) Y10(-4.55,-11.55) Y11(-4.55,-10.85) Y13(-4.55,-9.45) Y14(-4.55,-8.75) Y15(-4.55,-8.05) Y16(-4.55,-7.35) Y17(-4.55,-6.65) Y18(-4.55,-5.95) Y19(-4.55,-5.25) Y20(-4.55,-4.55) Y21(-4.55,-3.85) Y22(-4.55,-3.15) Y23(-4.55,-2.45) Y24(-4.55,-1.75) Y25(-4.55,-1.05) Y26(-4.55,-0.35) Y27(-4.55,0.35) Y28(-4.55,1.05) Y29(-4.55,1.75) Y30(-4.55,2.45) Y31(-4.55,3.15) Y32(-4.55,3.85) Y33(-4.55,4.55) Y34(-4.55,5.25) Y35(-4.55,5.95) Y36(-4.55,6.65) Y37(-4.55,7.35) Y38(-4.55,8.05) Y39(-4.55,8.75) Y40(-4.55,9.45) Y42(-4.55,10.85) Y43(-4.55,11.55) Y44(-4.55,12.25) Y45(-4.55,12.95) Y46(-4.55,13.65) Y47(-4.55,14.35) Y48(-4.55,15.05) Y49(-4.55,15.75) Y50(-4.55,16.45) Y51(-4.55,17.15) Y52(-4.55,17.85)
