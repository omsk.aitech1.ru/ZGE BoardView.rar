# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_USB_MUX_ML1N: length 321.9
  TOP w0.14: v1(266.26,13.78) 266.08,13.96 266.08,14.54 265.94,14.68 U24.59 ; CG73.2 44.31,86.04 44.31,85.64 v1(44.2,85.53)
  IN1 w0.086: v1(44.2,85.53) 44.49,85.23 44.49,84.29 44.8,83.98 45.77,83.98 46.71,83.05 47.91,83.05 49.39,81.57 50.47,81.57 53.23,78.81 55.79,78.81 57.15,77.46 87.24,77.46 88.83,75.88 92.41,75.88 93.11,75.18 94.18,75.18 94.47,74.88 94.47,72.91 96.69,70.69 96.69,65.31 98.51,63.49 98.51,59.01 98.24,58.73 98.24,56.54 97.57,55.87 97.57,52.74 98.28,52.02 98.28,47.88 99.25,46.92 99.25,44.29 98.91,43.96 98.91,39.06 102.63,35.34 173.94,35.34 178.82,40.22 178.82,51.74 183.91,56.83 184.61,56.83 186.79,59.02 193.17,59.02 194.4,57.78 196.25,57.78 196.79,57.23 199.5,57.23 200.04,57.78 210.04,57.78 210.86,56.96 213.16,56.96 213.62,56.49 219.89,56.49 221.36,55.03 222.98,55.03 226.83,51.18 226.83,47.89 227.93,46.79 234.61,46.79 235.17,46.23 235.17,44.81 235.62,44.36 235.62,41.49 236.49,40.61 236.49,39.87 235.55,38.93 235.55,36.11 236.28,35.38 236.28,32.26 236.58,31.95 236.58,31.28 239.31,28.55 239.31,26.8 239.1,26.59 239.1,26.02 239.69,25.43 242.45,25.43 243.72,24.17 243.99,24.17 244.96,23.2 245.33,23.2 245.73,22.8 245.73,22.65 246.93,21.44 247.54,21.44 247.99,21 247.99,20.46 249.42,19.03 252.16,19.03 252.79,18.4 252.79,17.65 254,16.44 255.82,16.44 256.06,16.68 256.86,16.68 257.76,15.78 257.76,15.66 257.06,14.95 257.06,14.62 257.41,14.27 257.74,14.27 258.45,14.97 258.57,14.97 258.87,14.67 258.87,14.55 258.27,13.95 258.27,13.67 258.68,13.27 258.96,13.27 259.56,13.87 259.68,13.87 259.98,13.57 259.98,13.44 259.38,12.84 259.38,12.57 259.78,12.16 260.06,12.16 260.66,12.76 260.78,12.76 261.12,12.43 264.76,12.43 265.44,13.1 265.75,13.1 266.03,13.37 266.03,13.55 v1(266.26,13.78)
DP_USB_MUX_ML1P: length 321.9
  TOP w0.14: v1(265.6,13.78) 265.77,13.95 265.77,14.41 265.54,14.63 U24.58 ; v1(44.98,85.51) 44.82,85.51 44.63,85.7 44.63,86.19 44.77,86.33 45.04,86.33 CG74.2
  IN1 w0.086: v1(265.6,13.78) 265.84,13.55 265.84,13.45 265.68,13.29 265.36,13.29 264.69,12.61 261.19,12.61 260.86,12.95 260.58,12.95 259.98,12.35 259.86,12.35 259.56,12.64 259.56,12.77 260.16,13.37 260.16,13.64 259.76,14.05 259.48,14.05 258.88,13.45 258.76,13.45 258.46,13.75 258.46,13.87 259.06,14.47 259.06,14.75 258.65,15.16 258.37,15.16 257.66,14.46 257.49,14.46 257.24,14.7 257.24,14.88 257.95,15.58 257.95,15.86 256.94,16.87 255.98,16.87 255.75,16.63 254.08,16.63 252.98,17.73 252.98,18.48 252.24,19.22 249.5,19.22 248.18,20.54 248.18,21.07 247.62,21.63 247.01,21.63 245.92,22.72 245.92,22.88 245.41,23.38 245.04,23.38 244.07,24.35 243.8,24.35 242.53,25.62 239.76,25.62 239.29,26.1 239.29,26.51 239.5,26.72 239.5,28.63 236.77,31.35 236.77,32.03 236.47,32.34 236.47,35.46 235.74,36.19 235.74,38.85 236.68,39.79 236.68,40.69 235.81,41.57 235.81,44.44 235.36,44.89 235.36,46.31 234.69,46.98 228.01,46.98 227.02,47.97 227.02,51.26 223.06,55.22 221.44,55.22 219.97,56.68 213.7,56.68 213.24,57.14 210.94,57.14 210.12,57.96 199.97,57.96 199.42,57.42 196.87,57.42 196.33,57.96 194.48,57.96 193.24,59.2 186.71,59.2 184.53,57.02 183.83,57.02 178.63,51.82 178.63,40.3 173.86,35.53 102.71,35.53 99.1,39.13 99.1,43.88 99.43,44.21 99.43,47 98.47,47.96 98.47,52.1 97.75,52.81 97.75,55.79 98.42,56.46 98.42,58.65 98.7,58.93 98.7,63.56 96.88,65.39 96.88,70.77 94.66,72.99 94.66,74.96 94.26,75.36 93.19,75.36 92.49,76.06 88.9,76.06 87.32,77.65 57.22,77.65 55.87,79 53.3,79 50.55,81.75 49.46,81.75 47.98,83.23 46.79,83.23 45.85,84.17 44.88,84.17 44.68,84.37 44.68,85.22 v1(44.98,85.51)
DP_USB_MUX_ML2N: length 323.6
  TOP w0.14: CG71.2 42.29,86.03 42.29,85.63 v1(42.13,85.46) ; v1(268.73,16.63) 268.59,16.49 268.04,16.49 267.69,16.84 U24.3
  IN1 w0.086: v1(268.73,16.63) 268.47,16.37 267.92,16.37 267.69,16.14 266.96,16.14 266.76,15.94 266.76,15.33 266.65,15.22 266.25,15.22 266.17,15.3 266.17,15.94 265.97,16.14 265.39,16.14 265.2,15.94 265.2,15.23 265.11,15.14 264.69,15.14 264.6,15.23 264.6,15.94 264.4,16.14 263.83,16.14 263.63,15.94 263.63,15.2 263.54,15.11 263.12,15.11 263.04,15.2 263.04,15.94 262.84,16.14 262.26,16.14 262.07,15.94 262.07,15.2 261.98,15.11 261.56,15.11 261.47,15.2 261.47,15.94 261.28,16.14 260.81,16.14 259.56,17.39 259.56,17.72 259.15,18.13 257.96,18.13 257.31,18.77 256.29,18.77 255.01,20.06 254.4,20.06 253.08,21.38 253.08,22.22 252.05,23.24 248.55,23.24 247.75,24.04 247.03,24.04 245.39,25.68 244.35,25.68 242.48,27.55 241.62,27.55 241.29,27.88 241.29,28.69 238.52,31.46 238.52,34.23 238.84,34.55 238.84,36.51 237.34,38 237.34,38.6 238.02,39.27 238.02,41.25 237.2,42.07 237.2,44.12 237.4,44.32 237.4,45.38 236.68,46.1 236.68,48.4 233.52,51.56 228.6,51.56 223.56,56.59 221.94,56.59 220.54,57.99 214.27,57.99 213.8,58.46 211.62,58.46 210.79,59.28 201.34,59.28 200.35,60.28 198.4,60.28 197.97,59.84 194.58,59.84 193.91,60.52 191.56,60.52 191,61.08 185.73,61.08 183.38,58.73 183.07,58.73 180.9,56.56 180.9,56.25 180.13,55.47 179.9,55.47 177.2,52.77 177.2,51.02 176.65,50.47 176.65,40.2 173.3,36.85 103.33,36.85 100.41,39.77 100.41,43.31 100.91,43.81 100.91,47.75 100.67,48 100.67,51.9 100.1,52.46 100.1,65.67 100.68,66.25 100.68,68.01 98.65,70.04 98.65,71.1 95.97,73.77 95.97,75.51 94.72,76.76 93.67,76.76 93.05,77.38 89.44,77.38 87.87,78.96 57.9,78.96 53.24,83.62 50.2,83.62 47.61,86.21 42.74,86.21 42.53,86 42.53,85.63 42.36,85.46 v1(42.13,85.46)
DP_USB_MUX_ML2P: length 323.6
  TOP w0.14: CG72.2 42.85,86.27 42.61,86.02 42.61,85.6 42.75,85.46 v1(43.03,85.46) ; v1(268.75,15.97) 268.55,16.17 267.91,16.17 267.65,16.44 U24.2
  IN1 w0.086: v1(268.75,15.97) 268.53,16.19 268,16.19 267.77,15.95 267.03,15.95 266.95,15.86 266.95,15.25 266.73,15.03 266.17,15.03 265.98,15.22 265.98,15.86 265.89,15.95 265.47,15.95 265.38,15.86 265.38,15.15 265.19,14.95 264.61,14.95 264.41,15.15 264.41,15.86 264.33,15.95 263.91,15.95 263.82,15.86 263.82,15.12 263.62,14.93 263.04,14.93 262.85,15.12 262.85,15.86 262.76,15.95 262.34,15.95 262.25,15.86 262.25,15.12 262.06,14.93 261.48,14.93 261.28,15.12 261.28,15.86 261.2,15.95 260.73,15.95 259.37,17.31 259.37,17.64 259.07,17.94 257.88,17.94 257.23,18.58 256.22,18.58 254.93,19.87 254.32,19.87 252.89,21.3 252.89,22.14 251.97,23.05 248.47,23.05 247.67,23.85 246.95,23.85 245.32,25.49 244.27,25.49 242.4,27.36 241.55,27.36 241.11,27.8 241.11,28.61 238.34,31.38 238.34,34.31 238.65,34.62 238.65,36.43 237.15,37.93 237.15,38.67 237.83,39.35 237.83,41.17 237.01,41.99 237.01,44.2 237.22,44.4 237.22,45.3 236.49,46.02 236.49,48.32 233.44,51.38 228.52,51.38 223.49,56.41 221.86,56.41 220.46,57.8 214.19,57.8 213.72,58.27 211.54,58.27 210.71,59.1 201.26,59.1 200.27,60.09 198.48,60.09 198.05,59.66 194.51,59.66 193.83,60.33 191.48,60.33 190.92,60.89 185.81,60.89 183.46,58.54 183.15,58.54 181.09,56.49 181.09,56.18 180.2,55.29 179.98,55.29 177.38,52.69 177.38,50.94 176.84,50.39 176.84,40.12 173.38,36.66 103.25,36.66 100.22,39.69 100.22,43.39 100.73,43.89 100.73,47.67 100.48,47.92 100.48,51.82 99.92,52.39 99.92,65.75 100.49,66.33 100.49,67.93 98.46,69.96 98.46,71.02 95.78,73.69 95.78,75.43 94.64,76.57 93.59,76.57 92.97,77.2 89.36,77.2 87.79,78.77 57.82,78.77 53.16,83.43 50.12,83.43 47.53,86.02 42.82,86.02 42.72,85.92 42.72,85.77 v1(43.03,85.46)
DP_USB_MUX_ML3N: length 321.2
  TOP w0.14: v1(40.13,85.59) 40.24,85.7 40.24,86.2 CG69.2 ; U24.6 267.7,18.04 268.11,17.63 268.3,17.63 v1(268.37,17.69)
  IN1 w0.086: v1(268.37,17.69) 268.15,17.48 267.72,17.48 267.58,17.34 266.55,17.34 266.02,16.81 261.19,16.81 260.29,17.71 260.29,18.25 259.17,19.37 258.06,19.37 257.19,20.23 255.77,20.23 254.83,21.17 254.83,22.27 253.07,24.03 248.78,24.03 247.59,25.22 246.86,25.22 245.71,26.37 244.64,26.37 243.77,27.24 243.77,28.12 243.12,28.77 242.14,28.77 239.98,30.93 239.98,34.35 239.5,34.83 239.5,36.04 239.99,36.53 239.99,39.96 239.43,40.51 239.43,41.58 238.8,42.21 238.8,44.95 237.37,46.39 237.37,48.81 233.96,52.22 228.87,52.22 223.84,57.25 222.22,57.25 220.83,58.65 214.57,58.65 214.09,59.12 211.92,59.12 211.09,59.95 201.75,59.95 200.6,61.09 197.97,61.09 197.45,60.57 195.05,60.57 194.44,61.18 192.07,61.18 190.82,62.42 186.15,62.42 183.1,59.38 182.48,59.38 180.22,57.11 178.52,57.11 176.54,55.14 176.54,51.61 175.99,51.06 175.99,40.48 173.02,37.51 104.42,37.51 103.17,38.76 103.17,39.26 101.57,40.86 101.57,43.65 102.8,44.89 102.8,46.83 101.39,48.24 101.39,52.11 100.76,52.74 100.76,65.38 101.35,65.97 101.35,68.37 100.05,69.67 100.05,71.83 98.53,73.35 98.53,75.18 97.33,76.38 96.06,76.38 94.08,78.36 93.29,78.36 92.97,78.05 89.7,78.05 88.14,79.61 58.17,79.61 53.49,84.29 50.51,84.29 47.92,86.88 41.18,86.88 40.5,86.2 40.5,85.96 v1(40.13,85.59)
DP_USB_MUX_ML3P: length 321.2
  TOP w0.14: CG70.2 40.87,86.36 40.55,86.04 40.55,85.71 40.67,85.59 v1(41.03,85.59) ; U24.5 267.65,17.64 268.19,17.09 v1(268.19,17.06)
  IN1 w0.086: v1(268.19,17.06) 267.96,17.29 267.8,17.29 267.66,17.15 266.63,17.15 266.1,16.62 261.11,16.62 260.1,17.63 260.1,18.18 259.1,19.18 257.98,19.18 257.12,20.05 255.69,20.05 254.64,21.1 254.64,22.19 252.99,23.84 248.7,23.84 247.52,25.03 246.78,25.03 245.63,26.18 244.56,26.18 243.58,27.16 243.58,28.05 243.04,28.58 242.06,28.58 239.79,30.85 239.79,34.27 239.31,34.75 239.31,36.12 239.8,36.61 239.8,39.88 239.24,40.44 239.24,41.5 238.62,42.13 238.62,44.87 237.18,46.31 237.18,48.73 233.88,52.04 228.8,52.04 223.77,57.07 222.14,57.07 220.75,58.46 214.49,58.46 214.01,58.93 211.84,58.93 211.02,59.76 201.67,59.76 200.53,60.9 198.05,60.9 197.53,60.38 194.97,60.38 194.36,60.99 191.99,60.99 190.75,62.24 186.22,62.24 183.18,59.19 182.56,59.19 180.29,56.93 178.59,56.93 176.73,55.06 176.73,51.53 176.18,50.98 176.18,40.4 173.1,37.32 104.35,37.32 102.98,38.69 102.98,39.18 101.38,40.78 101.38,43.73 102.61,44.96 102.61,46.75 101.2,48.16 101.2,52.03 100.57,52.66 100.57,65.46 101.16,66.05 101.16,68.29 99.86,69.59 99.86,71.75 98.34,73.27 98.34,75.1 97.25,76.19 95.98,76.19 94,78.17 93.36,78.17 93.05,77.86 89.63,77.86 88.06,79.42 58.09,79.42 53.41,84.11 50.44,84.11 47.85,86.7 41.26,86.7 40.68,86.12 40.68,85.93 v1(41.03,85.59)
DP_USB_MUX_OP_MODE0: length 3.3
  TOP w0.14: R563.1 257.84,15.49 R557.2 258.39,16.42 258.49,16.32 258.93,16.32 259.44,16.84 U24.43
DP_USB_MUX_OP_MODE1: length 2.8
  TOP w0.14: U24.42 259.35,17.24 258.95,16.83 v1(258.77,16.83)
  BOTTOM w0.14: R1092.2 259.39,16.83 v1(258.77,16.83) 258.17,16.83 R1093.1
DP_USB_MUX_POWER_EN: length 23.4
  TOP w0.14: v1(266.16,18.36) 266.24,18.44 U24.7 ; R630.1 256.23,9.57 v1(256.56,9.9) ; R622.2 266.84,10.57 267.3,11.04 v1(267.3,11.37)
  IN2 w0.089: v1(256.56,9.9) 258.2,9.9 258.7,10.39 259.6,10.39 259.91,10.09 265.27,10.09 266.55,11.37 v1(267.3,11.37)
  BOTTOM w0.14: v1(266.16,18.36) 266.32,18.36 R1082.1 267.73,16.94 267.73,16.42 267.32,16.01 267.32,15.31 268.36,14.28 268.36,13.11 267.3,12.06 v1(267.3,11.37)
DP_USB_MUX_PU_PWR: length 24.3
  TOP w0.508: v1(256.38,15.46) R563.2 ; R624.2 266.23,11.35 R622.1 R601.2 266.12,12.35 265.86,12.61 v1(265.65,12.61)
  BOTTOM w0.508: R1007.2 260.36,22.14 R1022.2 259.31,21.39 258.81,20.9 257.98,20.9 257.31,20.23 R1069.2 R1093.2 257.31,15.78 256.99,15.46 v1(256.38,15.46) 258.08,13.76 260.37,13.76 261.26,12.87 v1(263.54,12.87) 265.4,12.87 v1(265.65,12.61)
DP_USB_MUX_PULL1: length 3.6
  TOP w0.14: R595.1 259.36,13.99 259.47,13.99 259.76,14.28 259.76,15.13 259.37,15.52 259.37,15.9 259.51,16.04 U24.45
DP_USB_MUX_PULL2: length 3.6
  TOP w0.14: R571.1 259.13,14.27 259.35,14.27 259.48,14.39 259.48,15.01 259.09,15.4 259.09,16.09 259.43,16.44 U24.44
DP_USB_MUX_RX1N: length 3.8
  TOP w0.14: U24.16 266.34,23 266.28,23.06 266.28,23.63 266.67,24.02 267.25,24.02 267.8,24.57 267.8,24.73 C373.2
DP_USB_MUX_RX1P: length 3.8
  TOP w0.14: U24.17 265.94,23.02 266.01,23.08 266.01,23.74 266.56,24.29 267.14,24.29 267.53,24.68 267.53,24.77 C372.2
DP_USB_MUX_RX2N: length 3
  TOP w0.14: C378.2 261.67,24.7 261.67,24.5 262.15,24.02 262.15,23.49 262.28,23.36 262.28,23.05 262.34,22.98 U24.26
DP_USB_MUX_RX2P: length 3.1
  TOP w0.14: C377.2 261.4,24.66 261.4,24.39 261.88,23.91 261.88,23.38 262.01,23.25 262.01,23.07 261.94,23 U24.27
DP_USB_MUX_SBU1: length 2.4
  TOP w0.14: U24.34 259.4,20.44 259.21,20.63 258.51,20.63 258.34,20.8 258.14,20.8 C429.1
DP_USB_MUX_SBU2: length 2.4
  TOP w0.14: U24.33 259.41,20.84 259.35,20.9 258.62,20.9 258.45,21.06 258.28,21.06 C425.1
DP_USB_MUX_SCL: length 2.2
  TOP w0.14: R485.1 259.17,19.47 259.41,19.24 U24.37
DP_USB_MUX_SDA: length 2.7
  TOP w0.14: U24.38 259.41,18.84 259.06,19.19 258.34,19.19 257.84,18.69 R507.1
DP_USB_MUX_SSRXN: length 2.8
  TOP w0.14: C480.1 261.36,13 261.52,13.17 261.52,13.52 262.02,14.02 262.02,14.64 261.94,14.72 U24.49
DP_USB_MUX_SSRXP: length 2.8
  TOP w0.14: C481.1 261.93,13 261.77,13.17 261.77,13.42 262.26,13.92 262.26,14.61 262.34,14.69 U24.50
DP_USB_MUX_SSTXN: length 2.6
  TOP w0.14: U24.52 263.14,14.64 263.2,14.58 263.2,13.84 263.51,13.53 263.51,13.14 263.37,13 C482.1
DP_USB_MUX_SSTXP: length 2.7
  TOP w0.14: C483.1 264.06,13 263.75,13.31 263.75,13.63 263.44,13.94 263.44,14.57 263.54,14.67 U24.53
DP_USB_MUX_TEST_EN: length 1.3
  TOP w0.14: TP51.1 258.75,18.04 U24.40
DP_USB_MUX_TEST_R: length 2.6
  TOP w0.14: U24.28 261.54,23.05 261.44,23.16 v1(261.44,23.49)
  BOTTOM w0.14: v1(261.44,23.49) TP114.1
DP_USB_MUX_TX1N: length 3.1
  TOP w0.14: U24.20 264.74,23.16 264.81,23.23 264.81,23.81 265.45,24.45 265.45,24.72 C374.2
DP_USB_MUX_TX1P: length 3.1
  TOP w0.14: U24.19 265.14,23.13 265.08,23.2 265.08,23.7 265.72,24.34 265.72,24.68 C375.2
DP_USB_MUX_TX2N: length 3.1
  TOP w0.14: C380.2 263.89,25.05 263.67,24.83 263.67,24.43 263.33,24.09 263.33,23.57 263.48,23.43 263.48,23.07 263.54,23 U24.23
DP_USB_MUX_TX2P: length 3.1
  TOP w0.14: C379.2 263.18,25.05 263.4,24.83 263.4,24.54 263.07,24.2 263.07,23.46 263.21,23.32 263.21,23.08 263.14,23.01 U24.24
DP_USB_MUX_VDDIO: length 3.1
  TOP w0.203: v1(258.87,18.76) 259.19,18.44 U24.39 ; U24.11 268.29,20.04 268.71,19.61 v1(268.71,19.51)
  vias: v1(264.25,19.6)
DP_USB_MUX_VIN:
  vias: v1(268.66,23.75) v1(268.62,23.08) v1(269.44,24.04)
DP_USB_MUX_VX:
  vias: v1(269.06,21.06)
DP_USB_MUX_XTAL_I: length 8
  TOP w0.14: U24.30 260.74,22.77 C395.2 260,25.08 R414.1 260,25.41 259.04,26.37 258.6,26.37 258.36,26.61 258.36,27.75 258.73,28.13 Y3.1
DP_USB_MUX_XTAL_O: length 3.6
  TOP w0.14: R426.1 259.13,23.53 260.29,22.37 260.29,21.78 260.15,21.64 U24.31
DP_USB_MUX_XTAL_O_R: length 4.7
  TOP w0.14: R426.2 258.21,25.31 C383.2 R414.2 259.22,25.45 258.82,25.85 258.39,25.85 257.66,26.57 Y3.3
DP_USB_MXU_DCDC_GND: length 1.9
  TOP w0.203: v1(268.95,20.29) 268.8,20.44 U24.12
  vias: v1(271,25.31) v1(271,24.6) v1(271,23.92) v1(271.67,24.93)
DPEQ0_A1_DP: length 6
  TOP w0.14: v1(92.42,149.85) v1(92.9,149.37) 93.01,149.27 94.02,149.27 94.37,148.92 94.37,148.03 94.62,147.78 R27.2 95.12,147.78 R28.2
  BOTTOM w0.14: U39.14 v1(92.42,149.85)
DPEQ0_A1_EDP: length 3.1
  TOP w0.14: R113.2 R114.2 177.31,89.13 v1(177.07,89.37)
  BOTTOM w0.14: v1(177.07,89.37) 177.13,89.43 U41.14
DPEQ0_A1_TBT: length 2.7
  TOP w0.14: U10.14 v1(240.18,47.61)
  BOTTOM w0.14: R800.2 239.8,47.98 v1(240.18,47.61) 240.51,47.28 R806.2
DPEQ1_DP: length 4.5
  BOTTOM w0.14: R662.2 97.94,156.27 R665.2 96.61,154.94 96.61,154.03 v1(96.44,153.85) 95.89,153.85 95.74,153.7 U39.2
DPEQ1_EDP: length 3
  BOTTOM w0.14: U41.2 180.77,93.5 181,93.27 R708.2 182.28,94.05 R706.2
DPEQ1_TBT: length 3
  TOP w0.14: U10.2 244.22,51.33 v1(244.24,51.35)
  BOTTOM w0.14: v1(244.24,51.35) 244.24,50.98 R792.2 242.85,50.71 R788.2
DPSNK_RBIAS_1: length 1.7
  TOP w0.127: v2(258.85,47.54) 258.81,47.58 258.81,48.17 U7.Y18
  BOTTOM w0.14: v2(258.85,47.54) 258.84,47.54 R809.1
DPWROK_R: length 8.9
  TOP w0.14: U14.AW41 223.32,26.92 v1(223.69,27.29)
  BOTTOM w0.14: R965.2 230.32,25.09 R960.2 228.83,25.77 v1(228.78,25.73) 228.5,25.44 226.87,25.44 226.05,26.25 224.45,26.25 223.69,27.02 v1(223.69,27.29)
DRMOS_IMON1: length 50.8
  TOP w0.14: v1(45.84,49.38) 45.62,49.16 45.6,49.16 PR283.1 ; PU21.38 87.85,55.81 88.1,55.57 v1(88.41,55.57)
  IN4 w0.14: v1(88.41,55.57) 88.41,55.81 87.79,56.43 84.64,56.43 83.81,55.6 81.65,55.6 80.97,56.29 80.12,56.29 79.78,56.63 75.19,56.63 73.63,55.07 70.7,55.07 70.49,55.29 69.34,55.29 68.59,56.04 65.55,56.04 64.62,55.11 58.21,55.11 57.46,54.36 54.09,54.36 53.63,53.89 50.81,53.89 50.3,53.38 47.77,53.38 45.84,51.46 v1(45.84,49.38)
DRMOS_IMON2: length 41.7
  TOP w0.203: v1(79.11,55.67) 78.4,55.67 78.2,55.87 PU20.38 ; v1(45.93,48.14) 45.74,47.95 PR288.1
  IN2 w0.203: v1(79.11,55.67) 79.06,55.67 78.61,56.13 75.13,56.13 74.29,55.29 71.7,55.29 71.37,54.96 70.83,54.96 70.53,55.26 68.58,55.26 67.75,56.1 65.27,56.1 64.19,55.02 63.73,55.02 62.69,53.98 57.84,53.98 56.48,52.62 55.68,52.62 53.39,50.33 49.85,50.33 48.81,51.38 47.47,51.38 46.35,50.26 46.35,48.56 v1(45.93,48.14)
DRMOS_IMON3: length 36.2
  TOP w0.14: PU19.38 68.55,56.02 69.03,55.54 69.59,55.54 v1(69.82,55.77) ; PR300.1 45.36,47.08 45.74,47.46 v1(45.94,47.46)
  IN4 w0.14: v1(69.82,55.77) 69.11,56.48 65.4,56.48 64.67,55.76 61.96,55.76 61.66,56.05 60.71,56.05 60.08,55.42 58.18,55.42 57.36,54.6 53.99,54.6 53.53,54.13 50.36,54.13 49.58,54.92 48.89,54.92 48.38,54.41 47.08,54.41 45.23,52.55 45.23,49.19 45.58,48.84 46.16,48.84 46.39,48.61 46.39,47.91 v1(45.94,47.46)
DRMOS_IMON4: length 26
  TOP w0.14: v1(45.99,46.52) 45.68,46.52 45.37,46.22 PR307.1 ; v1(59.89,55.85) 59.68,55.64 59.27,55.64 58.9,56.02 PU18.38
  IN4 w0.14: v1(59.89,55.85) 59.76,55.72 58.13,55.72 57.3,54.88 53.77,54.88 53.26,54.38 50.46,54.38 49.68,55.16 48.79,55.16 48.28,54.65 46.98,54.65 44.91,52.58 44.91,49.17 45.36,48.72 45.36,46.9 45.74,46.52 v1(45.99,46.52)
DRMOS_IMON5: length 17.2
  TOP w0.14: PR309.1 45.33,45.36 45.5,45.52 45.91,45.52 45.97,45.58 v1(45.98,45.58) ; v1(50.41,55.47) 50.41,55.48 50.22,55.67 49.6,55.67 49.24,56.02 PU17.38
  IN4 w0.14: v1(45.98,45.58) 45.97,45.58 45.67,45.89 45.61,45.89 45.08,46.42 45.08,48.66 44.67,49.07 44.67,52.85 46.86,55.03 48.02,55.03 48.46,55.47 v1(50.41,55.47)
DRMOS_IMON6: length 16.2
  TOP w0.14: PU16.38 39.59,56.02 40.07,55.54 41.29,55.54 v1(41.55,55.29) ; PR313.1 45.38,44.62 45.95,44.62 v1(45.99,44.66)
  IN4 w0.14: v1(45.99,44.66) 45.7,44.95 45.54,44.95 44.72,45.76 44.72,48.67 43.52,49.88 43.52,50.62 43.85,50.95 43.85,52.1 42.21,53.74 42.21,54.63 v1(41.55,55.29)
DRMOS_IMON7: length 28.9
  TOP w0.14: PR316.2 45.35,43.73 v1(45.87,43.73) ; PU15.38 29.94,56.02 30.42,55.54 31.64,55.54 v1(31.77,55.41)
  IN4 w0.14: v1(45.87,43.73) 45.43,44.17 42.99,44.17 41.72,42.9 38.83,42.9 38.56,42.63 36.46,42.63 33.19,45.9 33.19,48.1 34.31,49.22 34.31,49.82 33.95,50.18 33.95,52.59 32.43,54.12 32.43,54.75 v1(31.77,55.41)
DRMOS_IMON8: length 37.4
  TOP w0.14: PU14.38 20.29,56.02 20.84,55.46 21.07,55.46 21.38,55.16 21.66,55.16 21.82,55.01 22.22,55.01 v1(22.68,54.55) ; v1(45.76,42.76) 45.71,42.71 45.3,42.71 PR318.2
  IN4 w0.14: v1(45.76,42.76) 44.6,43.93 43.09,43.93 41.82,42.65 38.93,42.65 38.66,42.38 36.36,42.38 32.95,45.8 32.95,47.37 31.79,48.53 31.79,53.69 30.52,54.96 23.56,54.96 23.16,54.55 v1(22.68,54.55)
DRMOS_REFIN: length 106.6
  TOP w0.102: 80.31,55.65 PR205.2
  TOP w0.14: PR279.2 47.36,49.6 47.49,49.73 PR278.2 47.77,49.24 v1(47.59,49.06) ; PR279.2 47.13,49.88 47.01,50 PC198.1 ; PR279.2 47.13,49.37 47.03,49.26 PC203.2 ; v1(89.05,55.79) 89.57,56.32 PR206.2 ; 80.31,55.65 80.66,55.65 v1(80.71,55.59) ; PR207.1 23.41,54.68 23.6,54.49 v1(23.6,53.94) ; PC215.2 PC213.2 PC212.2 PC210.2 PC208.2 PC206.2 PR290.1 PC203.2 ; v1(51.83,55.54) 51.83,56.15 PR202.2 ; PR287.1 47.58,48.41 47.21,48.78 PC203.2 ; PR201.2 42.18,56.15 v1(42.18,55.54) ; PR204.2 71.06,55.62 v1(71.11,55.57) ; v1(32.53,55.54) 32.53,56.15 PR200.1 ; v1(61.41,55.54) PR203.2
  IN1 w0.086: v1(71.11,55.57) 71.59,55.1 79.74,55.1 80.23,55.59 v1(80.71,55.59)
  IN2 w0.089: v1(89.05,55.79) 88.64,56.2 87.75,56.2 87.52,55.97 84.8,55.97 84.25,55.41 80.89,55.41 v1(80.71,55.59)
  BOTTOM w0.14: 42.26,53.79 42.26,55.46 v1(42.18,55.54) ; 42.26,53.79 40.91,53.79 40.37,53.25 37.82,53.25 37.66,53.41 36.01,53.41 35.65,53.76 33.98,53.76 33.39,53.17 32.49,53.17 32.28,53.38 ; 42.26,53.79 42.92,53.13 47.07,53.13 ; PC203.2 47.31,48.78 v1(47.59,49.06) ; PC203.2 PR290.1 PC206.2 PC208.2 PC210.2 PC212.2 PC213.2 PC215.2 ; PC203.2 47.03,53.09 47.07,53.13 ; 51.83,53.38 v1(51.83,55.54) ; 51.83,53.38 48.3,53.38 48.05,53.13 47.07,53.13 ; 51.83,53.38 51.96,53.51 53.15,53.51 53.4,53.25 57.27,53.25 57.96,53.94 57.96,54.73 58.57,55.34 61.2,55.34 v1(61.41,55.54) 61.69,55.26 61.69,54.17 62.04,53.81 62.52,53.81 63.92,53.81 64.35,53.39 66.43,53.39 66.83,53.79 70.93,53.79 71.24,54.1 71.24,55.45 v1(71.11,55.57) ; v1(23.6,53.94) 23.6,53.66 24.09,53.17 32.07,53.17 32.28,53.38 ; v1(32.53,55.54) 32.28,55.29 32.28,53.38
DRVON: length 97
  TOP w0.203: v1(114.45,156.07) 114.55,155.97 PR89.1 ; PR66.1 168.61,162.55 v1(168.8,162.75) ; PR64.1 137.18,163.11 v1(137.37,163.31) ; PU2.17 175.63,162.67 175.43,162.47 v1(175.43,161.68) 175.72,161.68 176.5,160.9 PC65.1 ; PR65.1 v1(157.99,162.63)
  TOP w0.254: v1(147.99,162.19) 147.56,162.62 PR63.1
  IN1 w0.203: v1(114.45,156.07) 114.45,156.58 115.16,157.29 124.94,157.29 126.51,158.87 126.51,163.21 128.49,165.19 136.82,165.19 137.03,164.98 137.03,163.66 v1(137.37,163.31) 137.79,163.73 137.79,165.11 138.41,165.73 141.95,165.73 143.5,164.18 145.71,164.18 147.16,162.73 147.16,162.42 147.39,162.19 v1(147.99,162.19) 149.49,162.19 152.86,165.57 152.86,166.5 153.6,167.24 157.08,167.24 157.42,166.89 157.42,163.2 v1(157.99,162.63) 158.57,163.2 158.57,166.64 159.56,167.63 163.96,167.63 164.41,168.08 167.74,168.08 168.24,167.58 168.24,165.68 167.67,165.1 167.67,163.61 168.53,162.75 v1(168.8,162.75) 171.15,162.75 172.05,161.84 172.05,161.2 172.43,160.82 174.57,160.82 v1(175.43,161.68)
EAPD: length 73.1
  TOP w0.14: R475.1 11.7,20.39 D52.1 12.24,21.12 v1(12.46,21.35)
  IN3 w0.089: v1(36.72,30.29) 37.76,30.29 38.4,29.65 39.19,29.65 40.11,28.72 41.24,28.72 41.91,28.05 42.74,28.05 43.1,27.69 44.13,27.69 44.76,27.06 44.76,24.54 42.91,22.69 40.12,22.69 36.93,19.5 20.67,19.5 18.33,17.16 17.27,17.16 15.34,15.23 14.5,15.23 12.1,12.83 10.58,12.83 9.95,13.46 9.95,15.56 10.03,15.64 10.03,18.04 10.15,18.17 10.15,18.61 11.65,20.11 11.65,20.77 12.24,21.35 v1(12.46,21.35)
  BOTTOM w0.14: v1(36.72,30.29) 36.63,30.38 36.63,31.07 36.36,31.34 36.36,33.12 35.58,33.9 35.58,35.17 35.14,35.6 34.06,35.6 32.94,34.48 R886.1
EC_FPBACK#: length 226
  TOP w0.14: Q7.2 v1(178.18,121.09) ; v1(89.97,32.43) 89.97,31.93 91.05,30.85 91.05,30.39 90.54,29.89 87.14,29.89 86.67,29.42 U18.86
  IN3 w0.089: v1(178.18,121.09) 179.68,119.6 179.68,107.83 177.87,106.03 177.87,102.72 178.63,101.97 178.63,96.32 179.86,95.09 179.86,88.86 177.92,86.92 177.92,86.45 175.06,83.59 175.06,69 179.69,64.38 179.69,62.88 180.02,62.55 180.02,60.78 180.72,60.09 180.72,54.85 180.31,54.44 v1(180.31,52.57)
  IN4 w0.086: v1(180.31,52.57) 177.86,52.57 172.82,57.61 171.59,57.61 161.97,67.22 118.01,67.22 115.62,64.84 111.3,64.84 111.09,64.62 103.69,64.62 102.53,63.47 102.53,57.74 102.91,57.36 103.85,57.36 104.27,56.94 104.27,56.56 103.78,56.06 102.79,56.06 102.03,55.3 102.03,51.17 100.34,49.48 100.34,44.47 99.62,43.75 99.62,41.41 98.43,40.21 96.87,40.21 95.93,39.28 91.92,39.28 91.51,39.69 89.9,39.69 87.77,41.82 87.17,41.82 v1(86.76,41.42)
  BOTTOM w0.14: v1(89.97,32.43) 89.97,32.77 90.7,33.49 91.89,33.49 92.17,33.77 92.17,35.86 91.07,36.96 90.75,36.96 89.39,38.32 v1(88.03,38.32) 87.19,38.32 86.36,39.15 86.36,39.49 86.73,39.87 86.73,40.3 86.45,40.58 86.45,41.11 v1(86.76,41.42)
EC_GPI2: length 5.9
  TOP w0.14: R446.1 90.38,21.78 89.46,21.78 89.45,21.77 89.22,22 R440.1 88.93,22.47 86.68,22.47 86.48,22.27 85.95,22.27 85.9,22.22 U18.68
EC_PECI: length 199.9
  TOP w0.14: R266.1 75.53,38.57 75.53,39.41 v1(75.39,39.54) ; R47.2 166.08,130.98 166.82,130.24 167.65,130.24 v1(168.04,130.63)
  IN3 w0.089: v1(168.04,130.63) 167.93,130.52 167.93,121.64 167.67,121.38 167.67,119.98 167.78,119.87 167.78,111.12 168.31,110.59 169.76,110.59 170.78,109.57 170.78,107.51 171.45,106.84 171.45,94.79 170.55,93.88 170.55,91.46 171.18,90.83 171.18,87.3 170.27,86.39 170.27,85.55 169.68,84.96 169.68,80.92 170.48,80.12 170.48,66.7 172.33,64.84 172.33,62.48 v1(173.38,61.43)
  IN4 w0.086: v1(75.39,39.54) 76.52,40.67 80.75,40.67 82.33,42.26 82.33,43.5 83.25,44.41 83.25,46.94 85.56,49.25 85.56,50.81 87.32,52.57 89.55,52.57 94.64,57.66 94.64,58.46 96.13,59.96 96.13,62.92 98.26,65.04 99.09,65.04 102.8,68.75 109.93,68.75 110.21,68.47 114.23,68.47 117.03,71.27 162.98,71.27 172.82,61.43 v1(173.38,61.43)
EC_PECR_R: length 3.1
  TOP w0.14: R266.2 75.24,37.22 v1(75.24,37.12) 75.15,37.04 75.15,36.32 75.43,36.03 U18.117
EC_PWROK: length 198.4
  TOP w0.14: U18.33 71.03,19.68 70.65,20.07 v1(70.5,20.07)
  IN4 w0.086: v1(235.48,18.66) 235.48,18.63 234.22,17.38 230,17.38 227.8,19.58 224.25,19.58 223.87,19.96 219.57,19.96 219.19,19.58 209.83,19.58 209.28,19.03 201.41,19.03 200.56,19.88 197.09,19.88 195.72,21.26 193.6,21.26 192.35,22.51 192.35,24.38 189.45,27.27 189.45,30.43 188.59,31.29 188.44,31.29 186.87,32.86 186.87,33 184.51,35.36 180.83,35.36 175.43,29.97 172.33,29.97 171.95,29.59 152.64,29.59 151.98,28.92 148.97,28.92 148.42,29.47 111.89,29.47 110.07,27.65 102.44,27.65 101.31,28.78 96.88,28.78 96.81,28.85 95.82,28.85 95.44,29.23 93.47,29.23 92.41,28.16 86,28.16 84.85,27.02 81.78,27.02 81.58,26.81 81.58,26.37 81.27,26.06 80.9,26.06 79.45,24.61 79.45,24.15 77.78,22.48 77.21,22.48 76.26,21.53 76.26,20.76 75.57,20.07 v1(70.5,20.07)
  BOTTOM w0.14: v1(234.84,21.26) 235.13,21.26 235.4,21.54 235.4,22.15 235.14,22.41 R1006.2 234.8,22.41 234.79,22.42 234.54,22.42 233.82,23.14 U42.1 ; v1(234.84,21.26) 234.84,21.1 235.92,20.02 235.92,19.1 v1(235.48,18.66) 236.1,18.04 R1073.2 ; v1(234.84,21.26) 233.05,21.26 R1024.2 231.5,20.73 R1023.2
EC_PWROK_R: length 25.3
  TOP w0.14: U14.AY42 224.27,26.94 224.28,26.95 v1(224.28,27.02)
  IN1 w0.086: v1(224.28,27.02) 224.28,26.86 224.92,26.22 226.18,26.22 226.78,25.61 228.08,25.61 229.17,24.53 229.17,22.41 230.16,21.42 234.55,21.42 235.29,20.67 235.29,19.45 v1(235.43,19.32)
  BOTTOM w0.14: R1068.2 231.4,19.16 231.97,19.73 v1(232.31,19.73) 232.94,19.09 233.7,19.09 234.08,19.47 235.27,19.47 v1(235.43,19.32) 235.43,19.28 235.01,18.87 235.01,18.3 R1073.1 236.12,17.19 R1108.1
EC_RST#: length 3.6
  TOP w0.102: U14.BF38 222.08,23.27 222.08,22.33 221.89,22.14 v1(221.79,22.14)
  BOTTOM w0.14: TP110.1 222.14,22.98 222.14,22.39 221.89,22.14 v1(221.79,22.14)
ECAGND: length 8.8
  TOP w0.14: U18.75 85.88,25.02 86.18,24.72 C392.2 86.8,24.72 86.96,24.88 86.96,25.24 v1(86.99,25.26) 86.99,25.34 87.34,25.7 87.69,25.7 L13.2 ; C422.1 v1(88.59,21.99)
  IN1 w0.086: v1(88.59,21.99) 88.3,22.28 88.3,23.93 86.99,25.24 v1(86.99,25.26)
EDP_AUX#_C: length 41.9
  BOTTOM w0.14: U41.25 173.47,92.7 173.39,92.62 173.16,92.62 172.8,92.25 172.24,92.25 172.1,92.39 172.1,92.87 171.78,93.2 171.54,93.2 R707.2 170.3,93.17 169.5,93.17 169.14,93.53 169.14,93.79 171.91,96.56 171.91,99.68 174.03,101.8 177.27,101.8 177.47,102 178.63,102 180.41,103.79 180.41,105.23 R700.1 180.38,106.22 180.38,107.39 R695.2 180.39,108.35 180.39,111.34 177.07,114.66 175.57,114.66 175.48,114.75 CN10.6 174.19,114.75 174.1,114.66 173.85,114.66 173.71,114.8 173.71,115 173.26,115.45 172.75,115.45 C639.2
EDP_AUX_C: length 41.9
  BOTTOM w0.14: C640.2 172.58,114.99 172.72,115.13 173.13,115.13 173.39,114.87 173.39,114.67 173.71,114.34 174.11,114.34 174.2,114.25 CN10.5 175.39,114.25 175.48,114.34 176.94,114.34 180.07,111.21 180.07,108.38 R696.2 180.07,107.38 180.07,106.21 R701.1 180.09,105.19 180.09,103.92 178.5,102.32 177.34,102.32 177.14,102.12 173.9,102.12 171.59,99.81 171.59,96.69 168.83,93.93 168.83,93.4 169.37,92.85 170.46,92.85 R709.2 171.45,92.88 171.65,92.88 171.79,92.74 171.79,92.26 172.11,91.94 172.93,91.94 173.3,92.3 U41.24
EDP_DISP_UTIL: length 5.3
  TOP w0.114: U3.A33 119.29,128.55 118.42,129.41 118.42,129.95 118.13,130.24 117.27,130.24
  TOP w0.14: 117.27,130.24 116.74,130.24 115.95,129.45 TP3.1
EDP_HPD_CPU: length 157.2
  TOP w0.102: v1(206.56,30.02) 206.36,30.02 U14.AN6
  TOP w0.14: v1(170.83,127.19) 170.83,127.61 170.36,128.08 R60.1
  IN2 w0.089: v1(208.55,21.23) 210.18,21.23 210.76,21.81 210.76,23 209.42,24.35 209.42,25.29 209.64,25.52 209.64,27.91 207.9,29.66 206.92,29.66 v1(206.56,30.02) 205.98,30.6 205.22,30.6 203.64,32.17 202.87,32.17 202.44,32.6 201.95,32.6 197.03,37.53 197.03,38.17 196.02,39.19 196.02,39.67 194.95,40.73 194.62,40.73 193.06,42.3 193.06,45.51 193.01,45.56 193.01,46.27 v1(193.16,46.42)
  IN3 w0.089: v1(170.83,127.19) 173.81,130.17 178.97,130.17 179.75,129.39 179.75,126.23 179.98,126 179.98,125.04 180.96,124.05 180.96,121.46 180.05,120.55 180.05,115.54 180.9,114.68 180.9,113.06 180.23,112.39 180.23,106.76 178.26,104.78 178.26,103.51 179.27,102.49 179.27,96.66 180.42,95.51 180.42,88.87 178.31,86.76 178.31,86.3 175.44,83.44 175.44,69.18 180.07,64.56 180.07,63.04 180.4,62.71 180.4,60.94 181.1,60.24 181.1,54.7 180.69,54.29 180.69,53.68 181.4,52.97 181.4,52.41 183.94,49.88 186.37,49.88 186.74,49.51 186.74,46.81 187.27,46.27 189.55,46.27 190.59,47.3 192.27,47.3 193.15,46.42 v1(193.16,46.42)
  BOTTOM w0.14: v1(208.55,21.23) 208.55,20.73 208.04,20.22 208.04,19.59 R1054.2 205.75,19.08 205.4,18.73 205.4,18.06 205.63,17.82 R1089.1
EDP_HPD_GPU: length 335
  TOP w0.14: R59.1 169.72,124.04 v1(169.97,123.79) 170.63,123.13 v1(171.07,123.13) ; v1(24.1,92.37) 23.77,92.04 CG67.1 23.32,92.04 RG33.2
  IN3 w0.089: v1(177.13,59.63) 177.33,59.82 177.33,60.85 176.64,61.54 176.64,63.49 172.63,67.5 172.63,81.2 172.26,81.58 172.26,84.59 174.16,86.5 174.16,93.57 173.6,94.13 173.6,100.27 174.47,101.13 v1(174.72,101.13) 174.7,101.15 174.7,102.35 174.47,102.58 173.71,103.34 173.71,120.81 171.39,123.13 v1(171.07,123.13)
  IN4 w0.086: v1(24.1,92.37) 23.74,92.73 19.98,92.73 19.52,92.27 19.52,91.78 19.91,91.39 19.91,89.4 17.68,87.17 17.68,86.64 14.54,83.5 14.54,79.45 15.54,78.45 15.54,78.15 14.73,77.34 14.73,69.45 13.78,68.49 13.78,65.86 14.78,64.86 14.78,61 18.63,57.15 20.79,57.15 20.81,57.17 22.72,57.17 22.96,56.93 22.96,55.44 22.68,55.16 22.52,55.16 22.3,54.94 21.65,54.94 21.48,54.77 21.48,54.33 22.4,53.41 23.82,53.41 24.87,54.46 30.32,54.46 31.24,53.55 31.24,48.58 30.01,47.35 29.35,47.35 29.01,47.02 29.01,46.3 29.94,45.37 30.32,45.37 32.23,43.46 32.23,42.44 34.87,39.8 38.38,39.8 39.16,40.58 42.78,40.58 43.85,41.65 47.32,41.65 47.67,42 47.67,42.7 46.57,43.79 46.57,47.4 46.88,47.71 46.88,48.93 46.48,49.33 46.48,51.4 47.97,52.89 50.5,52.89 51.01,53.4 53.74,53.4 53.89,53.26 57.18,53.26 58.53,54.62 59.94,54.62 60.52,54.03 64.32,54.03 64.81,54.52 69.74,54.52 70.8,53.46 72.08,53.46 73.2,54.58 73.83,54.58 75.4,56.14 79.5,56.14 80.53,55.11 84.02,55.11 84.85,55.94 86.72,55.94 87.51,55.14 89.9,55.14 90.15,55.4 90.15,58.42 91.48,59.75 91.48,63.57 92.29,64.38 93.49,64.38 94.1,63.77 95.84,63.77 97.92,65.85 98.76,65.85 102.56,69.65 110.18,69.65 110.54,69.28 113.89,69.28 116.74,72.13 163.26,72.13 173.09,62.3 173.85,62.3 174.48,61.67 174.93,61.67 175.69,60.91 176.24,60.91 177.13,60.01 v1(177.13,59.63)
  BOTTOM w0.14: v1(174.72,101.13) 174.74,101.16 175.83,101.16 176.27,100.72 R702.2
EDP_HPD_R: length 7.6
  TOP w0.14: R54.1 171.31,129.15 171.87,129.71 171.87,130.16 v1(172.03,130.32)
  BOTTOM w0.14: CN10.30 173.82,126.75 172.26,128.31 172.26,130.09 v1(172.03,130.32)
EDP_HPD_RR: length 6
  TOP w0.14: R54.2 169.36,129.15 168.3,128.08 ; 168.3,128.08 R60.2 169.91,127.46 169.91,127.11 169.55,126.74 169.55,126.44 169.72,126.26 R59.2 ; 168.3,128.08 C55.1
EDP_RCOMP: length 2.9
  TOP w0.203: v1(122.09,131.89) 122.09,131.33 121.57,130.81 U3.D37
  BOTTOM w0.254: v1(122.09,131.89) 122.09,132.2 R687.2
EDP_TXN0_C: length 2.7
  BOTTOM w0.14: C628.2 172.81,116.91 173.21,116.91 173.96,116.16 174.13,116.16 174.22,116.25 CN10.9
EDP_TXN1_C: length 2.7
  BOTTOM w0.14: CN10.12 174.22,117.75 174.13,117.67 173.93,117.67 173.16,118.44 172.81,118.44 C619.2
EDP_TXN2_C: length 2.8
  BOTTOM w0.14: C610.2 172.81,119.96 173.15,119.96 173.51,119.6 173.51,119.46 173.81,119.16 174.13,119.16 174.22,119.25 CN10.15
EDP_TXN3_C: length 2.8
  BOTTOM w0.14: CN10.18 174.22,120.75 174.13,120.66 173.86,120.66 173.56,120.96 173.56,121.13 173.21,121.49 172.81,121.49 C601.2
EDP_TXP0_C: length 2.7
  BOTTOM w0.14: C635.2 172.81,116.6 173.08,116.6 173.83,115.84 174.11,115.84 174.2,115.75 CN10.8
EDP_TXP1_C: length 2.7
  BOTTOM w0.14: CN10.11 174.25,117.25 174.15,117.35 173.8,117.35 173.03,118.12 172.81,118.12 C626.2
EDP_TXP2_C: length 2.8
  BOTTOM w0.14: C616.2 172.81,119.64 173.02,119.64 173.2,119.47 173.2,119.33 173.68,118.84 174.13,118.84 174.22,118.75 CN10.14
EDP_TXP3_C: length 2.8
  BOTTOM w0.14: C606.2 172.81,121.17 173.08,121.17 173.25,121 173.25,120.83 173.73,120.34 174.16,120.34 174.25,120.25 CN10.17
EDP_VDD_EN: length 7.5
  BOTTOM w0.14: R698.2 R699.2 177.65,106.74 177.66,106.74 R697.2 177.33,107.23 177.19,107.09 177.19,104.37 176.44,103.62 U40.4
EN: length 3.5
  TOP w0.14: v1(46.04,18.83) 46.04,19.51 C435.1 46.58,19.13 46.58,18.36 R515.2
  BOTTOM w0.14: U43.7 45.99,19.82 45.99,18.87 v1(46.04,18.83)
EN_U3: length 9.7
  TOP w0.14: U30.11 274.87,9.58 v1(274.58,9.29)
  BOTTOM w0.14: v1(274.58,9.29) 275.37,10.07 278.35,10.07 278.96,9.47 281.09,9.47 281.7,8.86 281.82,8.86 R1144.1
EQ_SEL_A0: length 15.7
  TOP w0.14: R1.2 61.59,164.54 R6.1 59.84,165.23 v1(59.84,165.75)
  IN2 w0.089: v1(51.35,168.37) 51.35,167.02 52.93,165.45 57.85,165.45 58.64,166.23 59.35,166.23 v1(59.84,165.75)
  BOTTOM w0.14: U34.5 51.62,166.95 51.5,167.07 51.5,168.22 v1(51.35,168.37)
ESPI_EC_IO0: length 16.4
  TOP w0.14: U14.BB39 222.7,26.14 v1(222.91,26.14)
  IN1 w0.086: v1(222.91,26.14) 223.49,25.56 223.49,23.15 225.29,21.35 227.64,21.35 229.4,19.59 230.37,19.59 231.64,18.32 v1(232.04,18.32)
  BOTTOM w0.14: R1079.1 231.02,18.32 v1(232.04,18.32)
ESPI_EC_IO1: length 19
  TOP w0.14: v1(221.76,27.44) 221.41,27.08 U14.AW37
  IN1 w0.086: v1(221.76,27.44) 222.14,27.44 222.73,26.85 223.2,26.85 223.9,26.16 223.9,24.44 226.38,21.96 227.89,21.96 229.65,20.2 231.55,20.2 232.82,18.93 233.3,18.93 233.55,18.68 v1(233.55,18.41)
  BOTTOM w0.14: v1(233.55,18.41) 233.55,17.62 233.27,17.34 R1107.1
ESPI_EC_IO2: length 20.6
  TOP w0.102: U14.AV37 221.15,28.14 v1(220.92,28.36)
  IN1 w0.086: v1(220.92,28.36) 221.43,27.85 222.09,27.85 222.78,27.16 223.24,27.16 224.12,26.27 224.12,24.63 224.61,24.14 226.96,24.14 228.14,22.96 228.14,22.14 229.78,20.51 231.65,20.51 232.94,19.22 233.42,19.22 234.21,18.43 v1(234.21,18.33)
  BOTTOM w0.14: R1087.1 234.24,17.77 234.21,17.8 v1(234.21,18.33)
ESPI_EC_IO3: length 18.6
  TOP w0.14: U14.BA38 222.13,26.61 v1(222.13,26.88)
  IN1 w0.086: v1(232.89,18.43) 232.6,18.72 231.65,18.72 230.48,19.9 229.52,19.9 227.77,21.65 226.24,21.65 223.69,24.2 223.69,25.93 223.08,26.55 222.46,26.55 v1(222.13,26.88)
  BOTTOM w0.14: R1078.1 231.87,17.39 232.73,17.39 233.06,17.72 233.06,18.25 v1(232.89,18.43)
EXT_SMI#: length 9.6
  TOP w0.14: TP28.1 233.69,41.01 233.1,40.43 232.72,40.43 232.35,40.06 231.14,40.06 R242.2 230.64,38.72 R258.2 230.38,38.59 229.79,39.18 227.33,39.18 U14.T48
F_SPKL+: length 6
  IN4 w0.762: 50.29,20.77 50.29,20.64 51.58,19.34 52.71,19.34 53.06,18.99 54.15,18.99 54.51,18.63 55.29,18.63
  vias: v1(49,21.83) v1(49.85,21.71) v1(50.51,21.68) v1(55.8,18) v1(55.87,17.34)
F_SPKL-: length 9.1
  IN1 w0.762: 49.4,22.93 49.12,22.65 49.12,20.74 50.77,19.09 55.24,19.09
  vias: v1(49.71,23.96) v1(50.38,23.97) v1(56.69,17.31) v1(56.71,18)
F_SPKR+: length 19.7
  IN3 w0.762: 48.2,28.39 47.31,27.5 47.31,21.53 49.6,19.24 54.25,19.24 54.98,19.98 57.93,19.98 58.36,19.55
  vias: v1(49.22,28.67) v1(49.8,28.36) v1(58.33,18.03) v1(58.34,17.36)
F_SPKR-: length 18.8
  IN3 w0.762: 48.94,25.34 48.94,21.58 50.13,20.39 52.77,20.39 53.31,20.93 53.31,21.96 53.89,22.55 55.75,22.55 56.56,21.73 58.82,21.73 58.95,21.61 59.38,21.18 59.38,21.17 59.58,20.97 59.58,19.63 59.89,19.32
  vias: v1(49.19,27.07) v1(49.85,26.99) v1(59.64,18) v1(59.65,17.32)
FAN1_PWM: length 177.8
  TOP w0.14: v1(76.26,29.63) 76.26,27.86 75.72,27.32 75.72,26.44 76.25,25.91 76.25,25.02 76.73,24.54 76.73,24.08 75.91,23.26 75.19,23.26 74.96,23.49 74.25,23.49 73.79,23.03 72.46,23.03 71.8,22.37 71.8,21.89 71.19,21.28 70.4,21.28 70.15,21.02 U18.32
  IN4 w0.086: v1(184.55,54.19) 183.63,54.19 180.65,57.17 175.83,57.17 173.67,59.33 172.35,59.33 162.59,69.09 117.42,69.09 114.98,66.65 109.45,66.65 109.18,66.93 103.55,66.93 100.43,63.81 100.43,52.88 98.19,50.64 98.19,49.71 97.67,49.19 96.57,49.19 96.35,49.41 95.63,49.41 94.43,50.61 93.29,50.61 92.47,49.79 90.56,49.79 89.82,50.54 87.86,50.54 87.37,50.05 87.37,48.49 85.22,46.34 85.22,44.69 85.39,44.52 85.39,43.49 85.56,43.33 85.56,43.02 85.39,42.85 85.39,42.69 v1(84.85,42.16)
  BOTTOM w0.14: v1(184.55,54.19) 184.95,54.19 187.45,56.68 188.08,56.68 189.83,58.44 190.47,58.44 190.65,58.61 190.65,61.63 191.33,62.32 192.88,62.32 193.76,61.44 Q67.1 ; v1(84.85,42.16) 83.99,42.16 83.38,41.54 83.38,41.07 82.47,40.16 82.47,38.73 82.77,38.43 82.77,36.08 79.98,33.29 79.98,32.15 77.46,29.63 v1(76.26,29.63)
FAN1_PWM_Q: length 26.5
  IN3 w0.089: v1(201.62,61.15) 202.43,61.15 204.04,59.54 204.04,55.86 203.39,55.2 202.57,55.2 201.25,56.52 196.73,56.52 v1(194.82,58.43)
  BOTTOM w0.14: v1(201.62,61.15) 199.89,61.15 199.61,60.87 CN12.3 ; R728.2 195.93,60.56 195.94,60.55 C701.1 193.96,60.02 193.67,59.73 Q67.3 193.84,59.27 194.35,59.27 194.82,58.81 v1(194.82,58.43)
FAN1_RPM: length 184
  TOP w0.14: v1(75.2,22.39) 75.58,22.39 76.63,21.34 U18.47
  IN4 w0.086: v1(85.67,44.87) 85.56,44.98 85.56,46.2 87.61,48.25 90.62,48.25 91.52,49.15 92.31,49.15 93.43,50.27 94.29,50.27 95.49,49.07 96.21,49.07 96.43,48.85 97.81,48.85 98.53,49.57 98.53,50.3 98.82,50.59 99.75,50.59 100.77,51.61 100.77,63.66 103.11,66.01 110.51,66.01 110.82,66.31 115.12,66.31 117.41,68.6 162.59,68.6 172.21,58.99 173.4,58.99 175.55,56.83 180.51,56.83 184.16,53.18 v1(184.5,53.18)
  BOTTOM w0.14: v1(75.2,22.39) 74.49,22.39 73.88,23.01 73.88,23.01 73.86,23.03 73.37,23.03 73.2,23.21 73.2,23.64 72.08,24.76 71.42,24.76 70.66,25.51 70.66,32.91 71.26,33.51 73.35,33.51 73.73,33.13 73.73,32.45 73.04,31.76 73.04,31.17 73.53,30.67 75.89,30.67 76.8,31.58 77.41,31.58 78.31,32.49 78.31,33.14 81.26,36.09 81.26,37.65 81,37.91 81,38.29 81.4,38.7 81.4,40.61 82.31,41.52 82.31,43.96 83.14,44.78 85.58,44.78 v1(85.67,44.87) ; R748.2 194.57,57.2 Q68.1 192.77,57.24 190.45,57.24 R743.2 189.47,57.06 188.66,56.25 187.57,56.25 v1(184.5,53.18)
FAN2_PWM: length 74.9
  TOP w0.14: v1(64.61,20.06) 65.88,20.06 66.64,20.81 68,20.81 68.62,21.42 U18.31 ; v1(13.28,48.99) 13.28,48.33 Q25.1
  IN3 w0.089: v1(64.61,20.06) 64.08,20.59 63.24,20.59 62.85,20.98 61.38,20.98 59.48,22.88 59.35,23.01 57.09,23.01 56.03,24.07 56.03,24.71 55.47,25.28 53.5,25.28 53.04,25.73 51.82,25.73 51.23,26.33 51.23,27.06 50.86,27.43 50.86,28.89 50.03,29.71 47.13,29.71 46.42,30.42 45.39,30.42 44.52,31.29 44.04,31.29 43.44,31.89 41.24,31.89 39.96,33.17 39.07,33.17 38.56,33.68 38.08,33.68 37.68,34.08 36.96,34.08 34.58,36.46 31.47,36.46 30.12,35.11 29.78,35.11 29.58,35.3 24.31,35.3 22.77,36.85 22.21,36.85 21.77,37.29 21.41,37.29 18.35,40.35 18.35,43.11 18.09,43.37 18.09,43.93 17.22,44.8 16.89,44.8 15.2,46.49 15.2,47.13 14.47,47.85 13.93,47.85 13.28,48.51 v1(13.28,48.99)
FAN2_PWM_Q: length 17.6
  TOP w0.14: Q25.3 12.49,50.64 12.87,51.02 12.87,52.29 12.54,52.62 v1(11.75,52.62)
  BOTTOM w0.14: CN11.3 11.02,62.51 10.53,62.02 10.53,53.84 v1(11.75,52.62) 11.82,52.55 C696.1 R734.2
FAN2_RPM: length 93.5
  TOP w0.14: v1(63.38,20.18) 63.38,19.77 63.82,19.32 66.77,19.32 67.25,18.84 69.26,18.84 69.61,18.48 69.61,18.33 70.03,17.91 76.43,17.91 77.03,18.51 U18.48 ; Q24.1 12.27,51.79 12.13,51.93 v1(11.07,51.93) 10.31,52.7 8.87,52.7 R156.2
  IN3 w0.089: v1(11.07,51.93) 12.52,51.93 12.64,51.81 12.64,48.66 13.79,47.51 14.33,47.51 14.85,46.99 14.85,46.35 16.74,44.45 17.08,44.45 17.74,43.79 17.74,43.23 18.01,42.97 18.01,40.2 21.27,36.94 21.63,36.94 22.07,36.5 22.63,36.5 24.17,34.96 29.42,34.96 29.62,34.76 30.26,34.76 31.61,36.11 34.44,36.11 36.82,33.74 37.54,33.74 37.94,33.34 38.42,33.34 38.93,32.83 39.82,32.83 41.22,31.42 42.75,31.42 43.22,30.95 44.38,30.95 45.25,30.07 46.28,30.07 46.99,29.37 49.89,29.37 50.51,28.74 50.51,27.29 50.84,26.96 50.84,26.23 51.68,25.39 52.9,25.39 53.36,24.93 55.33,24.93 55.69,24.57 55.69,23.92 56.95,22.67 59.21,22.67 59.33,22.54 59.33,22.54 61.24,20.63 62.71,20.63 63.17,20.18 v1(63.38,20.18)
  BOTTOM w0.14: v1(11.07,51.93) 10.82,52.18 R731.2
FB_4PH_A: length 5.9
  TOP w0.203: PU2.5 172.88,167.31 171.84,168.35 PC25.1 170.65,168.35 170.64,168.37 PC22.1 170.16,168.44 PR29.1 PR28.1
FB_CAL_PD_VDDQ: length 2.3
  TOP w0.102: UG1.R44 67.39,119.39 67.39,119.41 v2(67.41,119.43)
  BOTTOM w0.127: RG111.2 66.89,119 66.98,119 v2(67.41,119.43)
FB_CAL_PU_GND: length 1.1
  TOP w0.102: v2(66.72,119.42) UG1.P44
  BOTTOM w0.127: v2(66.72,119.42) 66.5,119.2 RG110.2
FB_CAL_TERM_GND: length 2.9
  TOP w0.102: UG1.R45 67.42,118.72 v2(67.42,118.69)
  BOTTOM w0.127: RG112.2 67.1,117.62 67.54,117.62 67.77,117.85 67.77,118.34 v2(67.42,118.69)
FB_VREF_PROBE: length 1.3
  TOP w0.102: UG1.P45 67.74,119.75 v2(67.37,120.11)
  BOTTOM w0.406: v2(67.37,120.11) 67.33,120.16 RG107.2
FBA_CMD0: length 37.5
  TOP w0.135: 74.67,117.3 73.27,115.89 72.54,115.89 72.34,115.69 72.09,115.69 UG1.Y51 ; VRAM6.H3 93.15,124.81 v2(93.14,124.81)
  TOP w0.165: 74.67,117.3 74.67,120.81 82.41,128.55 86.45,131.02 87.44,131.23 91.28,131.23 92.48,130.03 92.71,130.03 94.3,128.44 v2(94.46,128.04)
  IN1 w0.102: v2(94.46,128.04) 94.28,127.86 94.28,124.58 94.11,124.41 93.53,124.41 v2(93.14,124.81)
FBA_CMD1: length 33.1
  TOP w0.14: VRAM6.J3 v2(92.39,125.56) VRAM6.K3
  TOP w0.165: UG1.Y52 73.34,115.55 74.94,117.15 74.94,120.11 83.12,128.29 86.68,130.4 87.86,130.66 91.08,130.66 92.6,129.14 92.6,128.13 v2(92.85,127.88)
  IN1 w0.102: v2(92.39,125.56) 92.75,125.92 92.75,127.79 v2(92.85,127.88)
FBA_CMD2: length 32.7
  TOP w0.102: 83.4,126.17 83.33,126.1
  TOP w0.135: UG1.Y49 70.9,115.2 73.4,115.2 75.2,117.01
  TOP w0.165: 83.4,126.17 83.4,127.44 84.2,128.24 87.05,129.88 88.08,130.09 90.05,130.09 90.69,129.45 90.69,129.33 91.69,128.33 v2(91.69,128.01) 91.71,127.98 92.04,127.98 92.73,127.28 92.73,126.72 VRAM6.J1 ; 83.33,126.1 75.2,117.98 75.2,117.01
  BOTTOM w0.165: v2(91.69,128.01) 91.69,128.46 RG102.1
FBA_CMD3: length 34.1
  TOP w0.14: VRAM6.J4 v2(92.39,124.06) VRAM6.K4
  TOP w0.165: UG1.AA52 73.42,114.85 84.38,125.81 84.38,127.49 85.93,128.44 87.54,129.42 87.96,129.42 88.07,129.53 89.7,129.53 v2(90.86,128.37)
  IN1 w0.102: v2(92.39,124.06) 92.75,124.42 92.75,125.03 92.91,125.19 93.38,125.19 93.52,125.33 93.52,127.91 92.98,128.44 90.93,128.44 v2(90.86,128.37)
FBA_CMD4: length 30.2
  TOP w0.11: UG1.AA51 72.18,114.85 72.49,114.54 72.74,114.54 72.76,114.56 72.88,114.56
  TOP w0.135: v2(91.64,124.81) VRAM6.L3
  TOP w0.165: 72.88,114.56 73.7,114.56 75.22,116.08 75.43,116.08 84.95,125.6 84.95,126.98 85.69,127.72 86.91,128.42 v2(89.43,128.42)
  IN1 w0.102: v2(89.43,128.42) 89.91,127.94 90.77,127.94 91.12,127.59 91.62,127.59 91.92,127.29 91.92,126.67 92.01,126.59 92.01,125.17 v2(91.64,124.81)
FBA_CMD5: length 24.4
  TOP w0.11: UG1.AA50 71.46,114.85 71.81,114.5 72.15,114.5 72.33,114.32 73.97,114.32
  TOP w0.165: VRAM6.M4 90.14,124.06 90.14,122.99 89.98,122.82 85.35,122.82 85.18,122.99 83.11,122.99 76.51,116.39 76.51,116.39 75.64,115.52 75.18,115.52 73.97,114.32
FBA_CMD6: length 26.4
  TOP w0.14: VRAM6.J5 92.46,123.37 92.33,123.37 VRAM6.K5
  TOP w0.165: UG1.AC50 71.34,113.45 71.69,113.8 72.14,113.8 72.39,114.06 74.09,114.06 75.01,114.98 75.87,114.98 83.45,122.56 91.32,122.56 91.37,122.61 91.89,122.61 92.14,122.85 92.14,123.18 92.33,123.37
FBA_CMD7: length 28.8
  TOP w0.14: v2(91.3,123.02) 91.4,123.11 91.4,123.56 VRAM6.L5 ; v2(93.72,123.13) 93.59,123.13 93.44,123.28 93.44,123.61 VRAM6.H5
  TOP w0.165: UG1.AC51 72.16,113.45 72.5,113.79 74.2,113.79 74.84,114.43 76.1,114.43 83.95,122.29 91.43,122.29 91.48,122.34 92.13,122.34 92.59,122.8 v2(92.7,122.8)
  IN2 w0.089: v2(91.3,123.02) 91.51,122.8 v2(92.7,122.8) 92.74,122.77 93.38,122.77 93.72,123.11 v2(93.72,123.13)
FBA_CMD8: length 27.5
  TOP w0.165: UG1.AC52 72.66,113.46 74.24,113.46 74.67,113.88 76.32,113.88 84.46,122.02 91.54,122.02 91.59,122.07 92.4,122.07 92.64,122.32 93.88,122.32 94.28,122.73 94.28,123.15 94.63,123.5 94.63,124.07 VRAM6.G4
FBA_CMD9: length 30.2
  TOP w0.165: VRAM6.G11 94.64,119.56 94.64,121.1 94.35,121.39 92.56,121.39 92.15,121.8 91.7,121.8 91.65,121.76 84.97,121.76 76.55,113.34 74.68,113.34 74.44,113.1 70.9,113.1 UG1.AC49
FBA_CMD10: length 30.7
  TOP w0.14: v2(94.14,120.4) 94.08,120.4 93.91,120.24 93.91,120.06 94.04,119.93 VRAM6.G10 ; v2(90.17,120.66) 90.52,120.31 VRAM6.M10
  TOP w0.165: v2(91.93,121.4) 91.85,121.49 85.47,121.49 76.77,112.79 75.11,112.79 75.07,112.75 UG1.AD52
  IN2 w0.089: v2(90.17,120.66) 90.17,121.19 90.37,121.4 90.65,121.4 90.92,121.13 91.36,121.13 91.66,121.43 91.91,121.43 v2(91.93,121.4) 92.1,121.23 93.31,121.23 v2(94.14,120.4)
  BOTTOM w0.165: v2(91.93,121.4) 91.59,121.4 RG105.2
FBA_CMD11: length 28.2
  TOP w0.14: VRAM6.H10 93.52,120.47 93.28,120.7 92.64,120.7 92.47,120.88 92.28,120.68 91.49,120.68 91.27,120.46 VRAM6.L10
  TOP w0.165: UG1.AD51 72.14,112.75 72.49,112.4 74.94,112.4 75.05,112.3 77.05,112.3 85.98,121.22 91.02,121.22 91.25,120.99 92.35,120.99 92.47,120.88
FBA_CMD12: length 24.8
  TOP w0.11: 74.34,111.97 74.15,112.16 72.38,112.16 72.15,112.4 71.83,112.4 71.48,112.75 UG1.AD50
  TOP w0.165: 74.34,111.97 77.7,111.97 85.66,119.92 85.66,120.08 85.78,120.2 85.78,120.63 86.1,120.96 89.5,120.96 89.76,120.69 89.76,120.5 90.14,120.12 90.14,119.56 VRAM6.M11
FBA_CMD13: length 25.9
  TOP w0.11: UG1.AF50 71.41,111.35 71.78,111.73 72.07,111.73 72.29,111.95 74,111.95 74.38,111.57
  TOP w0.135: VRAM6.L12 91.27,118.47 v2(91.6,118.8)
  TOP w0.165: 74.38,111.57 78.13,111.57 82.7,116.13 91.22,116.13 v2(91.61,116.52)
  IN2 w0.114: v2(91.6,118.8) 91.28,118.48 91.28,116.85 v2(91.61,116.52)
FBA_CMD14: length 27.8
  TOP w0.14: VRAM6.J11 92.77,119.37 92.6,119.54 v2(92.4,119.54) 92.18,119.54 92.02,119.38 VRAM6.K11
  TOP w0.165: v2(90.96,115.05) 90.57,115.43 88.76,115.43 88.51,115.18 85.36,115.18 85.13,115.41 83,115.41 78.76,111.17 76.48,111.17 76.4,111.24 74.18,111.24 73.7,111.71 72.48,111.71 72.12,111.35 UG1.AF51
  IN2 w0.089: v2(90.96,115.05) 92.02,116.11 92.02,119.16 v2(92.4,119.54)
FBA_CMD15: length 26.2
  TOP w0.14: VRAM6.K12 v2(92.39,118.06) 92.76,118.43 VRAM6.J12
  TOP w0.165: UG1.AF52 73.63,111.35 74.01,110.97 76.29,110.97 76.36,110.9 79.51,110.9 83.35,114.74 88.69,114.74 88.87,114.56 91.97,114.56 v2(92.43,115.02)
  IN2 w0.089: v2(92.39,118.06) 92.78,117.67 92.78,115.37 v2(92.43,115.02)
FBA_CMD16: length 33.4
  TOP w0.11: UG1.AN50 71.6,106.1 72.14,106.1 72.4,105.84 73.03,105.84 73.11,105.92
  TOP w0.165: VRAM8.L3 v2(93.14,102.81) ; 73.11,105.92 74.46,105.92 75.72,104.66 75.72,102.92 77.9,100.74 81.32,100.74 82.19,99.87 84.1,97.96 89.4,97.96 89.52,97.84 91.95,97.84 92.3,98.19 93.57,98.19 94.33,98.95 v2(94.33,99.2)
  IN2 w0.114: v2(94.33,99.2) 94.33,100.27 94.28,100.32 94.28,102.21 94.05,102.44 93.71,102.44 93.34,102.81 v2(93.14,102.81)
FBA_CMD17: length 31
  TOP w0.14: VRAM8.J3 v2(92.38,102.07) 92.75,102.43 VRAM8.K3
  TOP w0.165: UG1.AN51 72.17,106.45 72.51,106.11 72.89,106.11 72.96,106.18 74.67,106.18 74.94,105.91 74.94,105.91 76.19,104.66 76.19,103.22 78.12,101.29 81.55,101.29 84.33,98.51 89.63,98.51 89.75,98.39 91.92,98.39 92.09,98.57 93.3,98.57 93.76,99.03 93.76,99.25 93.3,99.72 v2(93.3,100.41)
  IN2 w0.114: v2(92.38,102.07) 92.77,101.68 92.77,101.12 93.3,100.59 v2(93.3,100.41)
FBA_CMD18: length 26.3
  TOP w0.165: UG1.AN52 74.78,106.45 76.51,104.72 76.51,103.67 78.28,101.9 81.71,101.9 84.56,99.05 87.15,99.05 87.43,99.33 90.95,99.33 91.46,98.82 91.78,98.82 v2(91.97,99.02) 92.14,99.18 92.14,100.81 VRAM8.J1
  BOTTOM w0.165: RG142.1 91.6,99.02 v2(91.97,99.02)
FBA_CMD19: length 29.6
  TOP w0.14: VRAM8.J4 92.02,103.18 v2(92.39,103.56) 92.77,103.18 VRAM8.K4
  TOP w0.165: UG1.AM49 70.73,107.15 71.08,106.8 74.81,106.8 76.87,104.74 76.87,104.09 78.51,102.45 81.94,102.45 83.35,101.03 84.65,99.74 91.49,99.74 v2(91.64,99.89)
  IN2 w0.114: v2(91.64,99.89) 91.64,100.03 92.01,100.4 92.01,103.17 v2(92.39,103.56)
FBA_CMD20: length 24.6
  TOP w0.165: VRAM8.H3 v2(91.64,102.81) ; v2(90.89,100.56) 90.89,100.54 90.47,100.12 85.54,100.12 82.66,102.99 78.74,102.99 77.34,104.38 77.34,104.64 74.92,107.07 72.73,107.07 UG1.AM52
  IN2 w0.114: v2(90.89,100.56) 91.28,100.94 91.28,102.26 91.64,102.62 v2(91.64,102.81)
FBA_CMD21: length 22.4
  TOP w0.11: UG1.AM51 72.16,107.15 72.49,107.47 72.84,107.47 72.98,107.33
  TOP w0.165: 72.98,107.33 75.03,107.33 77.7,104.66 77.84,104.66 78.86,103.64 85.05,103.64 85.8,104.39 87.01,104.39 87.32,104.7 90.31,104.7 90.89,104.12 90.89,103.55 90.52,103.18 VRAM8.G4
FBA_CMD22: length 24.7
  TOP w0.14: VRAM8.J5 92.02,104.08 92.18,104.25 v2(92.4,104.25) 92.6,104.25 92.77,104.08 VRAM8.K5
  TOP w0.165: UG1.AM50 71.43,107.15 71.78,107.49 72.09,107.49 72.32,107.72 73.07,107.72 73.19,107.6 75.14,107.6 77.69,105.04 78.31,105.04 79.16,104.19 84.78,104.19 85.35,104.77 86.99,104.77 87.19,104.96 90.43,104.96 90.58,104.82 91.06,104.82 v2(91.37,104.51)
  IN2 w0.089: v2(92.4,104.25) 92.4,104.39 92.29,104.51 v2(91.37,104.51)
FBA_CMD23: length 26.1
  TOP w0.14: VRAM8.L5 92.9,104.55 92.58,104.88 92.35,104.88 91.75,104.28 91.75,104.22 91.47,103.93 VRAM8.H5
  TOP w0.165: UG1.AK50 71.6,108.2 72.15,108.2 72.36,107.99 73.25,107.99 73.37,107.87 75.25,107.87 75.43,107.68 77.6,105.52 78.71,105.52 79.49,104.74 84.94,104.74 85.31,105.1 86.87,105.1 87,105.23 90.54,105.23 90.69,105.08 92.14,105.08 92.35,104.88
FBA_CMD24: length 25.4
  TOP w0.11: UG1.AK51 72.21,108.55 72.54,108.23 73.42,108.23
  TOP w0.165: 73.42,108.23 73.51,108.13 75.36,108.13 75.54,107.95 77.58,105.92 79.3,105.92 79.93,105.28 85.11,105.28 85.26,105.43 86.68,105.43 86.75,105.5 90.65,105.5 90.8,105.35 93.3,105.35 93.5,105.15 93.63,105.02 93.63,104.41 93.89,104.15 93.89,103.56 94.27,103.18 VRAM8.M4
FBA_CMD25: length 25.6
  TOP w0.165: UG1.AK52 72.71,108.49 75.38,108.49 77.57,106.3 79.69,106.3 80.16,105.83 91.06,105.83 91.27,105.62 93.43,105.62 94.8,106.99 94.8,107.36 94.64,107.51 94.64,108.06 94.35,108.35 VRAM8.M11
FBA_CMD26: length 31
  TOP w0.14: v2(94.39,107.19) 94.36,107.19 94.18,107.36 94.18,107.6 VRAM8.M10 ; VRAM8.G10 91.03,106.8 v2(91.1,106.77)
  TOP w0.165: UG1.AJ49 70.89,108.91 72.81,108.91 72.96,108.76 75.49,108.76 77.54,106.7 84.03,106.7 84.64,106.09 91.38,106.09 91.6,105.88 92.64,105.88 92.89,106.14 v2(92.89,106.48)
  IN2 w0.089: v2(91.1,106.77) 91.23,106.9 92.26,106.9 92.65,106.64 v2(92.89,106.48) 92.89,106.72 93.03,106.85 93.33,106.85 93.55,106.63 93.71,106.63 93.88,106.8 93.88,107.21 94,107.34 94.24,107.34 v2(94.39,107.19)
  BOTTOM w0.165: RG122.2 92.96,106.55 v2(92.89,106.48)
