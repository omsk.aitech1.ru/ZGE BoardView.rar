# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DEVSLP7: length 3.8
  TOP w0.102: U14.AP47 226.65,30.12 227.73,30.12 v1(227.83,30.22)
  BOTTOM w0.14: TP101.1 227.02,30.22 v1(227.83,30.22)
DEVSLP_N1: length 5.2
  TOP w0.14: v1(195.76,44.3) 195.73,44.26 194.3,44.26 194.07,44.5 R196.2 194.07,44.82 194.5,45.25 194.74,45.25 195.01,45.51 R187.1
  BOTTOM w0.14: v1(195.76,44.3) 195.88,44.19 195.9,44.19 196.34,43.75 CN15.38
DEVSLP_N2: length 4.6
  TOP w0.14: R520.1 199,18.24 v1(198.96,18.24) 197.93,19.28 R501.2
  BOTTOM w0.14: v1(198.96,18.24) 198.5,18.7 CN18.38
DG_RTD3_CIO_PWR_EN: length 8.1
  TOP w0.102: 265.72,57.86 265.51,57.64 265.51,57.08 265.8,56.8 U7.F1
  TOP w0.14: v1(266.85,59.2) 267.27,59.2 R126.1 267.41,58.99 266.42,58 265.87,58 265.72,57.86
  BOTTOM w0.14: R732.1 268.87,57.87 268.69,58.05 R739.2 268.37,58.64 267.81,59.2 v1(266.85,59.2)
DG_RTD3_USB_PWR_EN: length 3.5
  TOP w0.089: v2(266.61,54.67) U7.D4
  BOTTOM w0.14: v2(266.61,54.67) 267.43,55.49 267.43,56 267.18,56.25 R758.1 267.02,56.57 267.14,56.68 R746.2
DGPU_HOLD_RST#: length 324.9
  TOP w0.102: U14.BF29 217.27,23.36 217.34,23.29 217.34,22.55 217.52,22.36 v1(217.61,22.36)
  IN2 w0.089: v1(52.56,47.51) 52.56,48.34 51.88,49.01 50.67,49.01 49.96,49.72 49.66,49.72 49.38,49.44 48.27,49.44 48.07,49.65 47.25,49.65 47.05,49.45 47.05,48.17 46.78,47.9 46.78,46.57 46.19,45.98 45.4,45.98 44.9,45.48 44.9,42.36 44.29,41.74 43.95,41.74 43.36,41.15 43.36,41.14 43.27,41.05 38.84,41.05 38.48,41.41 38.48,43.11 37.55,44.05 32.92,44.05 32.54,43.67 32.36,43.67 31.46,44.56 31.46,46.69 30.78,47.37 29.76,47.37 29.68,47.46 27.85,47.46 27.32,47.99 27.32,51.62 25.49,53.45 24.71,53.45 24.47,53.2 22.66,53.2 22.04,53.83 21.6,53.83 21.27,54.16 21.27,54.92 19.51,56.68 18.94,56.68 18.94,56.69 18.4,56.69 17.37,57.72 17.37,58.96 16.42,59.9 16.42,59.92 16.27,60.07 16.27,60.56 15.25,61.57 15.25,70.66 15,70.91 15,77.71 15.54,78.25 15.54,78.55 14.52,79.57 14.52,83.21 14.74,83.43 14.74,83.7 16.79,85.75 20.26,85.75 22.84,83.17 22.84,82.02 24.33,80.53 27.86,80.53 28.31,80.08 29.26,80.08 29.74,80.56 31.82,80.56 32.71,79.67 37.16,79.67 37.52,80.03 39.97,80.03 41.31,81.36 44.16,81.36 45.45,82.66 49.1,82.66 50.42,81.34 v1(51.57,81.34)
  IN3 w0.089: v1(52.56,47.51) 54.22,45.85 54.22,43 54.55,42.67 54.55,42.04 54.25,41.75 54.25,40.7 53.91,40.37 53.91,38.81 54.62,38.1 63.81,38.1 64.42,37.49 66.55,37.49 67.74,36.3 68.47,36.3 68.77,36.6 68.77,36.75 69.2,37.18 70.9,37.18 72.47,35.61 75.2,35.61 75.41,35.41 79.21,35.41 79.8,34.82 82.29,34.82 83.24,35.77 85.33,35.77 85.82,36.26 87.81,36.26 89.27,34.81 91.92,34.81 92.75,33.98 95.7,33.98 96.24,33.44 96.87,33.44 97.16,33.73 98.17,33.73 99.3,34.86 111.33,34.86 112.02,34.17 165.84,34.17 166.33,34.66 177.2,34.66 178.62,36.08 185.11,36.08 190.38,30.81 190.38,27.67 193.27,24.79 193.27,23.82 193.98,23.1 195.68,23.1 196.43,22.34 196.43,22.08 198.03,20.48 205.76,20.48 206.15,20.09 215.7,20.09 216.04,20.43 216.1,20.43 216.84,21.17 216.84,21.66 217.54,22.36 v1(217.61,22.36)
  BOTTOM w0.102: 219.05,20.77 219.05,21.34 218.75,21.64 218,21.64 217.61,22.04 v1(217.61,22.36)
  BOTTOM w0.14: 219.05,20.77 R1031.1 219.05,19.57 R1062.2 ; v1(51.57,81.34) 51.1,80.87 v1(50.24,80.87) 49.97,80.87 49.56,81.28 UG7.1
DGPU_OPP#: length 20.5
  TOP w0.14: U18.71 86.03,23.42 86.41,23.79 87.11,23.79 87.95,24.63 88.85,24.63 89.2,24.98 89.67,24.98 89.86,24.79 89.86,24.47 90.41,23.92 90.73,23.92 C393.1 90.7,24.14 90.7,24.29 90.32,24.67 R410.2 91.4,25.88 91.4,26.52 91.39,26.52 91.39,26.53 91.26,26.67 91.26,26.91 91.26,26.92 91.26,30.04 91.46,30.24 91.46,31 90.6,31.86 v1(90.6,32.83) 90.6,33.35 Q32.2 89.16,33.7 89.14,33.69 R318.1
DGPU_OPP#_PROCHOT#: length 166.4
  TOP w0.14: v1(19.68,97.65) 19.68,100.73 20.11,101.16 20.11,102.16 RG15.2 20.99,103.04 QG3.3 ; R318.2 88.11,34.47 88.37,34.2 Q32.3 88.86,34.22 89.76,35.12 90.7,35.12 91.69,34.13 v1(91.69,34.03)
  IN2 w0.089: v1(94,67.48) 93.78,67.7 93.78,70.14 97.96,74.32 97.96,77.42 96.57,78.82 96.57,80.45 96.1,80.93 96.1,82.76 95.48,83.38 95.48,84.12 93.36,86.24 88.43,86.24 82.73,80.54 56.38,80.54 53.63,83.29 50.5,83.29 48.82,84.97 48.82,85.35 47.62,86.55 42.54,86.55 41.48,87.61 41.48,88.9 41.08,89.3 33.2,89.3 32.92,89.58 30.22,89.58 28.79,91.01 27.23,91.01 23.86,94.38 23.03,94.38 22.62,94.79 20.21,94.79 19.48,95.52 19.48,97.45 v1(19.68,97.65)
  IN3 w0.089: v1(94,67.48) 92.24,65.72 92.24,62.5 92.68,62.06 93.92,62.06 94.24,61.75 94.24,59.9 93.97,59.62 93.15,59.62 92.7,59.17 92.7,58.91 90.86,57.07 90.86,55.3 89.58,54.02 89.58,53.81 89.14,53.37 88.33,53.37 84.95,49.99 84.95,44.06 86.6,42.41 v1(86.82,42.41)
  BOTTOM w0.14: v1(91.69,34.03) 91.69,34.23 90.09,35.83 90.09,37.07 89.48,37.67 88.43,37.67 88.01,37.25 v1(87.3,37.25) 87.27,37.27 87.27,37.55 85.97,38.86 85.97,39.72 85.58,40.11 85.58,40.45 85.97,40.84 85.97,41.26 86.32,41.61 86.32,41.69 86.82,42.19 v1(86.82,42.41)
DGPU_OVT#: length 33.1
  TOP w0.14: v1(22.85,86.58) 22.85,85.97 23.41,85.41 RG46.1 22.95,84.8 RG51.2 21.77,85.41 QG9.3
  BOTTOM w0.14: DG6.1 44.98,82.4 QG21.3 43.61,83.78 43.61,86.63 40.63,89.6 34.96,89.6 34.28,88.92 27.86,88.92 27.25,88.32 24.16,88.32 22.85,87.01 v1(22.85,86.58)
DGPU_PWR_EN: length 294.3
  TOP w0.14: U14.BD29 217.38,24.84 217.38,25.43 v1(217.06,25.74)
  IN1 w0.086: v1(39.37,88.76) 37.55,88.76 36.42,87.62 36.42,86.2 36.15,85.93 36.15,84.76 36.96,83.94 41.42,83.94 42.62,82.74 43.46,82.74 43.69,82.98 44.07,82.98 44.32,82.73 45.66,82.73 46.12,82.26 47.63,82.26 48.7,81.19 48.7,80.42 48.18,79.9 v1(48.18,78.15) ; v1(92.29,75.32) 91.2,74.23 91.2,71.54 91.64,71.11 91.64,63.47 92.75,62.35 94.06,62.35 94.83,61.59 95.6,61.59 96.12,61.07 96.12,60.03 97.77,58.38 97.77,57.56 97.1,56.89 97.1,52.54 97.71,51.93 97.71,47.57 97.3,47.16 97.3,46.78 98.06,46.02 98.06,42.23 97.88,42.05 97.88,41.6 98.32,41.16 98.32,40.48 98.04,40.2 98.04,39.43 98.45,39.02 98.45,37.15 98.18,36.88 v1(98.18,36.86)
  IN2 w0.089: v1(48.18,78.15) 48.43,78.15 48.8,78.52 49.39,78.52 49.72,78.18 52.58,78.18 53.21,78.81 54.04,78.81 54.67,78.18 87.84,78.18 89.2,76.83 90.78,76.83 v1(92.29,75.32)
  IN3 w0.089: v1(217.06,25.74) 217.06,25.39 215.97,24.29 214.96,24.29 214.74,24.51 212.86,24.51 212.46,24.11 212.18,24.11 211.83,24.45 210.41,24.45 210.29,24.34 205.86,24.34 205.81,24.39 204.95,24.39 204.36,23.8 200.81,23.8 199.53,25.09 198.52,25.09 198.09,25.52 198.09,29.87 196.73,31.23 196.73,33.73 195.42,35.04 193.93,35.04 190.45,38.52 188.89,38.52 188.42,38.05 177.91,38.05 176.61,36.75 98.29,36.75 v1(98.18,36.86)
  BOTTOM w0.102: 217.15,20.77 217.15,20.89 217.25,21 217.25,21.71 217.12,21.84 217.12,22.99 217.68,23.54 217.68,24.03 217.12,24.58 217.12,25.68 v1(217.06,25.74)
  BOTTOM w0.14: R1065.2 217.86,19.52 217.6,19.77 R1034.1 217.6,20.16 217.15,20.61 217.15,20.77 ; UG10.2 49.7,79.44 49.32,79.06 49.32,78.63 49.19,78.5 48.75,78.5 48.68,78.43 48.46,78.43 v1(48.18,78.15) ; UG5.1 7.69,85.35 7.56,85.22 7.56,84.43 7.89,84.09 8.39,84.09 9.85,85.56 12.91,85.56 13.41,86.05 14.03,86.05 14.75,86.77 15.43,86.77 16.09,87.42 17.88,87.42 18.17,87.14 20.11,87.14 20.36,86.88 20.82,86.88 21.89,85.82 23.23,85.82 24.32,86.91 25.1,86.91 25.95,87.76 27.49,87.76 28.09,88.36 34.51,88.36 35.13,88.99 39.14,88.99 v1(39.37,88.76)
DGPU_PWROK: length 8.9
  TOP w0.14: QG16.6 38.34,79.46 38.7,79.82 38.7,80.53 39.44,81.27 QG15.1 39.94,81.44 40,81.38 RG67.2 40.61,81.71 41.91,83.01 42.59,83.01 43.4,82.2 QG13.2
DGPU_PWROK_Q: length 245.1
  TOP w0.14: v1(216.99,27.04) 216.99,27.1 216.82,27.27 216.1,27.27 U14.AW26 ; v1(38.77,81.44) 38.77,81.17 38.54,80.94 QG15.3
  IN2 w0.089: v1(200.55,53.61) 200.98,54.04 201.4,54.04 202.94,52.5 202.94,50.35 202.57,49.99 202.57,48.41 203.34,47.65 203.34,46.09 203.97,45.45 203.97,41.91 205.89,40 206.86,40 208.1,38.75 210.15,38.75 210.69,39.28 213.72,39.28 215.14,37.86 215.14,35.88 214.75,35.49 213.91,35.49 213.59,35.17 213.59,34.09 215,32.68 216.38,32.68 217.06,32 217.06,31.23 218.43,29.87 218.43,29.36 217.54,28.47 217.54,27.6 v1(216.99,27.04) ; v1(38.77,81.44) 38.8,81.44 41.5,84.14 48.81,84.14 50.41,82.54 53.34,82.54 55.87,80.01 83.21,80.01 84.58,81.38 86.96,81.38 87.39,80.94 87.39,80.35 89.7,78.05 92.68,78.05 93.16,78.53 96.37,78.53 97.56,77.34 v1(97.56,77.14)
  IN4 w0.086: v1(97.56,77.14) 97.91,76.78 97.91,76.15 99.09,74.97 99.09,72.93 99.76,72.26 104.96,72.26 105.54,71.68 112.65,71.68 115.35,74.38 164.63,74.38 175.31,63.7 175.31,62.74 176.36,61.69 176.46,61.69 177.87,60.29 178.38,60.29 179.43,59.23 180.01,59.23 180.43,58.82 180.43,58.14 183.05,55.52 184.95,55.52 186.29,54.18 186.29,52.34 186.8,51.83 188.54,51.83 189.11,51.26 195.05,51.26 195.88,52.09 197.83,52.09 198.28,52.54 198.8,52.54 199.37,53.1 200.04,53.1 v1(200.55,53.61)
  BOTTOM w0.102: v1(216.99,27.04) 217.03,27.09 217.25,27.09 217.55,26.78 217.55,25.46 217.63,25.38 217.63,24.71 218.45,23.88 218.45,22.51 219.68,21.29 219.68,20.77
  BOTTOM w0.14: 219.68,20.77 219.68,18.81 219.77,18.71 219.77,18 219.26,17.48 R1081.1 219.34,17.36 219.53,17.36 219.65,17.24 219.65,16.12 219.48,15.95 219.48,15.52 219.09,15.13 R1122.1
DGPU_THER_ALERT#: length 152
  TOP w0.14: v1(69.9,40.87) 70.35,40.42 R230.1 70.59,39.91 70.59,39.19 R259.1 ; QG5.3 27.26,95.99 v1(27.83,95.42)
  IN2 w0.089: v1(27.83,95.42) 27.83,95.04 29.39,93.48 34.42,93.48 v1(34.44,93.46) ; v1(69.9,40.87) 70.32,40.87 70.62,41.17 73.2,41.17 73.4,40.97 80.61,40.97 81.9,42.26 83.43,42.26 84.52,43.35 84.52,43.45 84.92,43.85 86.84,43.85 87.9,44.92 88.79,45.81 88.79,46.12 88.36,46.55 86.79,46.55 86.3,47.03 86.3,48.2 87.5,49.39 89.12,49.39 90.91,51.18 92.31,51.18 93.87,52.75 93.87,55.85 94.23,56.2 94.63,56.2 95.24,56.81 95.75,56.81 95.91,56.97 95.91,58.36 94.58,59.68 94.58,61.64 94.93,61.98 94.93,62.73 94.47,63.2 94.15,63.2 93.28,64.07 93.28,70.12 95.61,72.46 95.61,75.09 97.16,76.64 97.16,77.47 96.29,78.34 93.24,78.34 92.76,77.85 89.62,77.85 88.27,79.21 55.1,79.21 54.25,80.06 52.85,80.06 52.32,79.52 50.69,79.52 50.14,80.08 47.31,80.08 46.88,79.64 44.83,79.64 44.57,79.9 v1(44.11,79.9)
  IN4 w0.086: v1(34.44,93.46) 34.92,92.98 34.92,91.13 36.8,89.24 36.8,86.61 35.56,85.37 35.56,84.85 36.6,83.81 37.66,83.81 38.14,83.33 38.14,82.8 38.53,82.41 39.8,82.41 41.93,80.28 43.73,80.28 v1(44.11,79.9)
DIFFOUT_4PH_A: length 6.4
  TOP w0.203: PR28.2 168.7,169.79 168.93,170.02 170.5,170.02 171.12,169.39 PC18.2 171.12,169.37 171.67,168.82 171.85,168.82 172.96,167.71 PU2.4
DIMM0_CHA_EVENT_N: length 5
  TOP w0.102: JDIM2.134 139.82,37.02
  TOP w0.14: R332.2 140.08,33.43 R333.2 140.67,34.21 140.15,34.74 v1(140.15,35.17) 140.15,35.84 139.82,36.16 139.82,37.02
DIMM0_CHB_EVENT_N: length 24.4
  TOP w0.102: 136.09,37.02 136.09,38.78 135.63,39.23 135.63,39.84 135.09,40.39 134.69,40.39 ; JDIM1.134 139.82,50.11
  TOP w0.14: 139.82,50.11 139.82,49.3 139.67,49.15 136.81,49.15 136.56,48.9 v1(136.56,47.88) 136.56,46.9 136.74,46.71 136.74,44.37 135.51,43.14 135.51,42.63 135.25,42.37 134.76,42.37 134.39,42 134.39,40.69 134.69,40.39 ; R348.2 138.7,32.67 R331.2 138.48,33.43 138.17,33.75 138.17,34.48 136.09,36.57 136.09,37.02
DIMM1_CHA_EVENT_N: length 83.6
  IN3 w0.089: v1(114.04,61.94) 114.41,61.57 114.41,60.84 112.52,58.94 110.03,58.94 108.16,57.08 108.16,48.89 112.18,44.87 130.57,44.87 132.99,42.46 132.99,40.68 133.98,39.69 v1(135.12,39.69)
  BOTTOM w0.102: v1(135.12,39.69) 135.52,40.1 135.52,41.52 135.73,41.73 135.73,42.79 136.69,43.75 137.31,43.75 137.92,44.36 JDIM4.134
  BOTTOM w0.14: v1(114.04,61.94) 113.82,61.73 106,61.73 105.08,60.81 101.15,60.81 99.62,62.34 99.62,64.61 99.03,65.2 97.35,65.2 97.2,65.35 96.16,65.35 94.98,66.53 94.98,67.19 95.38,67.59 R718.2 95.44,68.11 95.75,68.42 96.54,68.42 96.73,68.23 R717.2
DIMM1_CHB_EVENT_N: length 49.2
  BOTTOM w0.14: JDIM3.134 137.92,60.05 136.29,61.69 136.29,62.64 135.3,63.62 114.61,63.62 v1(114.45,63.46) 112.99,62 105.88,62 104.97,61.09 101.67,61.09 99.9,62.85 99.9,64.72 98.98,65.65 97.6,65.65 R720.2 96.46,65.78 R721.2
DMI_RXN0: length 143.2
  TOP w0.089: U14.C33 219.69,45 219.69,46.82 219.08,47.43 218.76,47.43 218.67,47.52 218.67,47.65 v1(218.67,47.65) ; v1(122.53,108.8) 122.53,108.86 U3.E8
  IN4 w0.086: v1(122.53,108.8) 122.37,108.8 122.26,108.92 122.26,109.02 122.26,109.09 122.4,109.23 122.88,109.23 123.11,109.01 123.11,106.49 123.59,106.01 123.59,104.28 123.05,103.74 123.05,100.71 123.82,99.95 123.82,93.21 130.11,86.91 168.29,86.91 170.62,84.59 171.22,84.59 171.81,84 171.81,83.39 185.97,69.24 188.26,69.24 189.36,68.14 189.36,66.96 192.98,63.34 193.4,63.34 193.84,62.89 194.95,62.89 195.6,62.24 196.67,62.24 197.32,62.89 199.27,62.89 199.95,63.57 204.51,63.57 210.29,57.79 211.91,57.79 214.68,55.02 216.72,55.02 219.46,52.28 219.46,47.7 219.46,47.63 219.05,47.23 218.59,47.23 218.47,47.35 218.47,47.57 218.56,47.65 v1(218.67,47.65)
DMI_RXN1: length 141.8
  TOP w0.089: v1(122.55,108.02) 122.57,108.02 122.57,108.02 122.86,108.31 U3.F6
  TOP w0.102: U14.C32 218.79,44.75 218.7,44.84 218.51,44.84 218.42,44.93 218.42,45.07 218.55,45.2 218.55,45.34 v1(218.38,45.51)
  IN4 w0.086: v1(218.38,45.51) 218.26,45.51 218.18,45.6 218.18,45.82 218.26,45.91 218.67,45.91 218.85,45.73 218.85,45.25 218.65,45.05 217.92,45.05 217.51,45.46 217.51,47.39 217.62,47.49 217.62,47.84 218.89,49.11 218.89,51.93 216.35,54.47 214.45,54.47 211.6,57.32 210.15,57.32 204.35,63.12 200.06,63.12 199.43,62.5 197.57,62.5 196.92,61.85 195.42,61.85 194.77,62.5 193.68,62.5 193.24,62.94 192.82,62.94 188.56,67.2 187.37,67.2 168.05,86.52 129.4,86.52 123.32,92.6 123.32,99.89 122.64,100.57 122.64,107.15 122.25,107.54 122.25,107.97 122.33,108.05 122.52,108.05 v1(122.55,108.02)
DMI_RXN2: length 137.4
  TOP w0.089: U3.E5 v1(121.7,107.15)
  TOP w0.102: v1(216.48,47.26) 216.69,47.47 217.02,47.47 217.35,47.14 217.35,46.59 217.77,46.17 217.77,44.99 217.92,44.84 218.01,44.84 U14.C31
  IN4 w0.086: v1(216.48,47.26) 216.72,47.51 216.85,47.51 217.06,47.72 217.06,48.66 216.16,49.56 216.16,51.06 213.4,53.81 211.7,53.81 203.83,61.69 203.07,61.69 202.25,62.5 200.53,62.5 199.97,61.94 197.85,61.94 197.21,61.29 195.18,61.29 194.54,61.94 193.45,61.94 193.01,62.39 192.59,62.39 188.33,66.64 187.13,66.64 180.85,72.92 180.16,72.92 167.12,85.97 128.84,85.97 122.62,92.18 122.62,99.8 122,100.42 122,106.05 121.1,106.95 121.1,107.28 121.26,107.43 121.42,107.43 v1(121.7,107.15)
DMI_RXN3: length 149.6
  TOP w0.089: v1(123.87,110.42) 123.96,110.42 U3.J9
  TOP w0.102: v1(215.45,47.7) 215.71,47.44 215.78,47.44 215.92,47.31 216.07,47.16 216.07,47.07 216.79,46.35 217.2,46.35 217.54,46.02 217.54,45.05 U14.C29
  IN4 w0.086: v1(123.87,110.42) 123.59,110.13 123.47,110.13 123.03,110.13 122.85,109.95 121.55,109.95 119.94,108.35 119.94,107.8 120.32,107.42 120.32,105.46 119.13,104.27 117.78,104.27 114.18,100.66 114.18,97.33 122.29,89.23 124.34,89.23 128.32,85.24 166.82,85.24 180.02,72.04 180.7,72.04 186.82,65.92 188.03,65.92 192.3,61.66 192.71,61.66 193.15,61.22 194.19,61.22 194.83,60.57 197.73,60.57 198.38,61.22 200.31,61.22 200.74,61.65 201.98,61.65 202.82,60.81 203.36,60.81 211.49,52.68 213.46,52.68 215.42,50.72 215.42,49.27 215.7,49 215.7,48.29 215.91,48.09 215.91,47.6 215.65,47.34 215.57,47.34 215.41,47.5 215.41,47.67 v1(215.45,47.7)
DMI_RXP0: length 143.1
  TOP w0.089: v1(218.77,46.83) 218.5,46.83 218.41,46.92 218.41,47.16 218.5,47.25 219,47.25 219.51,46.74 219.51,45.36 U14.B33 ; v1(121.88,108.81) 121.88,108.86 U3.D8
  IN4 w0.086: v1(218.77,46.83) 218.77,46.88 218.95,47.06 219.12,47.06 219.63,47.57 219.63,47.77 219.63,47.77 219.63,52.35 216.79,55.19 214.75,55.19 211.98,57.95 210.36,57.95 204.58,63.73 199.88,63.73 199.21,63.06 197.25,63.06 196.6,62.41 195.67,62.41 195.01,63.06 193.91,63.06 193.47,63.5 193.05,63.5 189.53,67.02 189.53,68.21 188.33,69.41 186.03,69.41 171.98,83.46 171.98,84.07 171.29,84.75 170.69,84.75 168.36,87.08 130.18,87.08 123.98,93.28 123.98,100.01 123.22,100.78 123.22,103.68 123.75,104.21 123.75,106.07 123.27,106.56 123.27,109.08 122.95,109.4 122.33,109.4 122.1,109.16 122.09,109.05 122.09,109.02 v1(121.88,108.81)
DMI_RXP1: length 141.8
  TOP w0.089: v1(121.85,108.02) 122.19,108.36 U3.E6
  TOP w0.102: U14.B32 218.79,45.71 218.38,46.12 v1(218.38,46.31)
  IN4 w0.086: v1(218.38,46.31) 218.61,46.08 218.74,46.08 219.01,45.8 219.01,45.18 218.72,44.89 217.85,44.89 217.35,45.39 217.35,47.45 217.45,47.56 217.45,47.91 218.73,49.18 218.73,51.87 216.28,54.31 214.38,54.31 211.53,57.15 210.08,57.15 204.28,62.96 200.13,62.96 199.5,62.34 197.64,62.34 196.99,61.69 195.35,61.69 194.7,62.34 193.61,62.34 193.17,62.78 192.75,62.78 188.49,67.03 187.3,67.03 167.98,86.36 129.33,86.36 123.16,92.53 123.16,99.82 122.47,100.5 122.47,107.08 122.08,107.48 122.08,107.79 v1(121.85,108.02)
DMI_RXP2: length 137.3
  TOP w0.089: U3.D5 121.29,107.63 121.2,107.72 v1(121.2,108.01)
  TOP w0.102: U14.B31 218.07,45.04 218,45.04 217.97,45.08 217.97,45.67 218.07,45.78 218.07,45.92 217.97,46.02 217.97,46.26 217.55,46.68 217.55,47.23 217.1,47.68 216.58,47.68 216.48,47.78 v1(216.48,47.92)
  IN4 w0.086: v1(121.2,108.01) 121.31,107.9 121.31,107.72 120.94,107.35 120.94,106.88 121.84,105.98 121.84,100.35 122.46,99.73 122.46,92.11 128.77,85.8 167.05,85.8 180.09,72.76 180.79,72.76 187.06,66.48 188.26,66.48 192.52,62.22 192.94,62.22 193.38,61.78 194.47,61.78 195.12,61.13 197.28,61.13 197.92,61.78 200.04,61.78 200.59,62.34 202.19,62.34 203,61.52 203.76,61.52 211.63,53.65 213.34,53.65 215.99,50.99 215.99,49.49 216.9,48.59 216.9,47.79 216.78,47.67 216.55,47.67 216.46,47.76 216.46,47.91 v1(216.48,47.92)
DMI_RXP3: length 149.5
  TOP w0.089: v1(123.88,109.69) 123.88,109.68 124.13,109.43 U3.J8
  TOP w0.102: U14.B29 217.18,45.4 217.18,45.55 217.33,45.7 217.33,45.93 217.12,46.15 216.71,46.15 215.87,46.99 215.87,47.07 215.7,47.24 215.26,47.24 215.16,47.14 215.16,46.91 215.26,46.8 215.4,46.8 v1(215.41,46.82)
  IN4 w0.086: v1(123.88,109.69) 123.59,109.97 123.47,109.97 123.1,109.97 122.92,109.79 121.62,109.79 120.11,108.28 120.11,107.87 120.49,107.49 120.49,105.39 119.2,104.1 117.85,104.1 114.35,100.6 114.35,97.4 122.35,89.4 124.41,89.4 128.39,85.41 166.89,85.41 180.09,72.2 180.77,72.2 186.89,66.09 188.1,66.09 192.36,61.83 192.78,61.83 193.22,61.38 194.26,61.38 194.9,60.74 197.67,60.74 198.31,61.38 200.24,61.38 200.67,61.81 202.05,61.81 202.89,60.98 203.43,60.98 211.56,52.85 213.53,52.85 215.59,50.79 215.59,49.34 215.87,49.06 215.87,48.36 216.07,48.15 216.07,47.53 215.72,47.18 215.56,47.18 215.41,47.04 v1(215.41,46.82)
DMI_TXN0: length 156.3
  TOP w0.089: v1(117.86,109.05) 117.66,109.05 117.6,109.12 117.6,109.5 117.68,109.59 118.03,109.59 118.33,109.29 119.19,109.29 119.39,109.5 119.87,109.5 119.95,109.42 119.95,109.2 119.86,109.11 119.68,109.11 U3.A8
  TOP w0.14: U14.K34 220.14,41.3 220.14,41.57 219.98,41.72 v1(219.78,41.72)
  IN4 w0.086: v1(219.78,41.72) 219.67,41.72 219.55,41.84 219.55,42.03 219.65,42.13 220.1,42.13 220.25,41.98 220.25,41.54 219.76,41.05 216.49,41.05 215.94,41.6 215.94,42.18 215.59,42.54 215.46,42.54 214.8,43.2 214.8,43.76 212.44,46.11 212.44,47.67 204.46,55.65 204.46,56.25 202.3,58.41 202.17,58.41 198.87,58.41 198.44,57.98 194.43,57.98 193.26,59.15 192.3,59.15 191.86,59.58 190.64,59.58 189.6,60.62 188.94,60.62 188.4,61.17 187.71,61.17 184.98,63.9 184.98,64.8 179.94,69.84 179.31,69.84 165.96,83.18 126.92,83.18 123.75,86.35 122.25,86.35 112.06,96.54 112.06,101.46 115.71,105.11 115.71,107.79 116.4,108.47 117.4,108.47 117.59,108.67 117.59,108.96 117.71,109.08 117.83,109.08 v1(117.86,109.05)
DMI_TXN1: length 153
  TOP w0.089: U3.B6 120.48,108.42 120.53,108.46 120.53,108.66 120.46,108.73 119.39,108.73 119.26,108.86 118.48,108.86 118.08,108.45 117.72,108.45 117.44,108.17 117.44,107.64 117.08,107.28 116.43,107.28 116.32,107.16 v1(116.32,107.01)
  TOP w0.14: v1(218.51,42.37) 218.51,42.45 218.65,42.59 218.84,42.59 218.97,42.71 219.16,42.71 U14.G33
  IN4 w0.086: v1(218.51,42.37) 218.51,42.57 218.41,42.67 218.14,42.67 217.94,42.47 217.94,41.86 217.54,41.46 216.72,41.46 216.44,41.74 216.44,42.39 215.96,42.87 215.96,43.76 215.24,44.48 214.73,44.48 212.94,46.27 212.94,47.73 211.38,49.29 211.38,50.07 202.6,58.85 194.17,58.85 193.48,59.54 192.46,59.54 192.02,59.98 190.81,59.98 189.77,61.01 189.13,61.01 188.59,61.56 187.88,61.56 185.38,64.06 185.38,64.96 180.11,70.23 179.47,70.23 166.12,83.58 127.18,83.58 123.76,86.99 122.16,86.99 112.45,96.71 112.45,101.29 117.25,106.1 117.25,106.78 116.77,107.26 116.56,107.26 v1(116.32,107.01)
DMI_TXN2: length 150.1
  TOP w0.089: v1(118.43,107.56) 118.4,107.58 118.4,107.71 118.53,107.83 118.81,107.83 118.89,107.76 118.89,107.64 118.97,107.56 119.09,107.56 119.14,107.61 119.14,107.78 119.2,107.83 119.26,107.83 119.38,107.96 119.53,107.96 119.64,107.84 119.64,107.71 U3.A5
  TOP w0.14: U14.K32 218.66,41.42 v1(218.36,41.72)
  IN4 w0.086: v1(118.43,107.56) 118.67,107.79 118.91,107.79 119.6,107.1 119.6,105.53 118.9,104.82 117.55,104.82 113.63,100.9 113.63,97.1 122.23,88.5 124.07,88.5 127.89,84.69 166.59,84.69 179.79,71.48 180.46,71.48 186.49,65.45 186.49,64.51 188.22,62.79 189.61,62.79 191.3,61.1 192.48,61.1 192.92,60.66 193.96,60.66 194.6,60.02 198.04,60.02 198.68,60.66 200.74,60.66 201.39,60.01 203.06,60.01 214.72,48.35 214.72,46.27 215.22,45.77 215.65,45.77 217.26,44.16 218.68,44.16 219.11,43.73 219.11,42.37 218.99,42.26 218.99,41.93 218.79,41.72 v1(218.36,41.72)
DMI_TXN3: length 146.9
  TOP w0.089: U3.B4 120.66,106.81 120.66,106.68 120.57,106.59 120.28,106.59 120.13,106.74 120.13,107.09 120.05,107.18 119.17,107.18 118.98,106.98 117.96,106.98 117.82,106.85 v1(117.82,106.72)
  TOP w0.14: v1(217.22,42.66) 217.37,42.82 217.64,42.82 U14.G30
  IN4 w0.086: v1(117.82,106.72) 118.01,106.91 118.17,106.91 118.34,106.73 118.34,106.23 117.58,105.46 117.41,105.46 113.04,101.1 113.04,96.9 122.08,87.86 123.81,87.86 127.54,84.13 166.36,84.13 179.56,70.93 180.2,70.93 185.93,65.2 185.93,64.29 188.09,62.13 189.46,62.13 191.05,60.54 192.25,60.54 192.69,60.1 193.73,60.1 194.37,59.46 198.28,59.46 198.92,60.1 200.38,60.1 201.04,59.44 202.85,59.44 214.15,48.13 214.15,46.05 214.99,45.22 215.32,45.22 216.52,44.02 216.52,43.18 216.71,42.98 217.13,42.98 217.22,42.89 v1(217.22,42.66)
DMI_TXP0: length 156.4
  TOP w0.089: v1(117.2,109.05) 117.42,109.26 117.42,109.58 117.61,109.77 118.1,109.77 118.4,109.47 119.11,109.47 119.32,109.68 119.94,109.68 120.13,109.49 120.13,109.31 U3.B8
  TOP w0.14: U14.J35 220.29,41.98 v1(219.74,42.53)
  IN4 w0.086: v1(117.2,109.05) 117.42,108.83 117.42,108.73 117.33,108.64 116.33,108.64 115.55,107.85 115.55,105.18 111.89,101.52 111.89,96.47 122.18,86.19 123.68,86.19 126.85,83.02 165.9,83.02 179.24,69.68 179.87,69.68 184.82,64.73 184.82,63.83 187.65,61 188.33,61 188.87,60.46 189.54,60.46 190.58,59.42 191.79,59.42 192.23,58.98 193.19,58.98 194.36,57.82 198.51,57.82 198.94,58.25 202.24,58.25 204.3,56.18 204.3,55.58 212.28,47.6 212.28,46.04 214.64,43.69 214.64,43.13 215.39,42.37 215.52,42.37 215.78,42.11 215.78,41.53 216.42,40.89 219.83,40.89 220.41,41.47 220.41,42.05 220.17,42.3 219.97,42.3 v1(219.74,42.53)
DMI_TXP1: length 153
  TOP w0.089: U3.C6 120.7,108.6 120.7,108.74 120.53,108.91 119.46,108.91 119.33,109.04 118.41,109.04 118,108.63 117.65,108.63 117.27,108.25 117.27,107.71 117.01,107.46 116.53,107.46 v1(116.32,107.67)
  TOP w0.14: v1(218.67,43.02) U14.F34
  IN4 w0.086: v1(218.67,43.02) 218.48,42.83 218.07,42.83 217.77,42.54 217.77,41.93 217.47,41.62 216.79,41.62 216.6,41.8 216.6,42.46 216.12,42.94 216.12,43.83 215.31,44.64 214.8,44.64 213.1,46.34 213.1,47.79 211.54,49.36 211.54,50.14 202.67,59.02 194.23,59.02 193.55,59.71 192.53,59.71 192.09,60.14 190.87,60.14 189.84,61.18 189.2,61.18 188.66,61.72 187.95,61.72 185.54,64.13 185.54,65.03 180.18,70.4 179.54,70.4 166.19,83.74 127.25,83.74 123.83,87.16 122.23,87.16 112.61,96.77 112.61,101.23 117.42,106.03 117.42,106.85 116.84,107.42 116.56,107.42 v1(116.32,107.67)
DMI_TXP2: length 150.1
  TOP w0.089: v1(118.46,108.22) 118.66,108.01 119.19,108.01 119.31,108.13 119.6,108.13 120.1,107.63 U3.B5
  TOP w0.14: U14.J32 218.84,41.86 218.84,41.65 219.03,41.46 v1(219.16,41.46)
  IN4 w0.086: v1(118.46,108.22) 118.72,107.95 118.98,107.95 119.77,107.17 119.77,105.46 118.97,104.66 117.62,104.66 113.79,100.83 113.79,97.17 122.29,88.67 124.14,88.67 127.96,84.85 166.65,84.85 179.86,71.65 180.53,71.65 186.66,65.52 186.66,64.58 188.28,62.96 189.68,62.96 191.37,61.27 192.55,61.27 192.99,60.82 194.03,60.82 194.67,60.18 197.97,60.18 198.62,60.82 200.81,60.82 201.46,60.18 203.13,60.18 214.88,48.42 214.88,46.34 215.29,45.94 215.72,45.94 217.33,44.32 218.75,44.32 219.27,43.8 219.27,42.3 219.16,42.19 v1(219.16,41.46)
DMI_TXP3: length 146.9
  TOP w0.089: v1(117.77,107.38) 117.99,107.16 118.92,107.16 119.1,107.34 120.12,107.34 120.24,107.22 120.67,107.22 121.12,106.78 U3.D4
  TOP w0.14: U14.F30 217.33,43.4 v1(217.29,43.37)
  IN4 w0.086: v1(217.29,43.37) 217.07,43.15 216.78,43.15 216.68,43.25 216.68,44.09 215.39,45.38 215.06,45.38 214.32,46.12 214.32,48.2 202.91,59.6 201.11,59.6 200.45,60.27 198.85,60.27 198.21,59.63 194.44,59.63 193.8,60.27 192.76,60.27 192.32,60.71 191.12,60.71 189.53,62.3 188.16,62.3 186.1,64.35 186.1,65.26 180.27,71.09 179.63,71.09 166.42,84.3 127.61,84.3 123.88,88.03 122.15,88.03 113.21,96.97 113.21,101.03 117.48,105.3 117.65,105.3 118.51,106.16 118.51,106.8 118.24,107.07 118.08,107.07 v1(117.77,107.38)
DMIC_CLK: length 262.4
  TOP w0.14: R301.1 32.42,35.2 v1(32.42,35.56) 32.41,35.57 32.41,36.18 C263.2 ; R70.1 180.69,123.93 180.69,122.85 v1(180.51,122.67)
  IN1 w0.086: v1(72.53,32.78) 72.3,33.01 70.81,33.01 70.26,32.46 67.9,32.46 67.67,32.24 66.85,32.24 66.38,32.71 65,32.71 64.35,32.07 63.94,32.07 63.32,32.68 63,32.68 62.85,32.83 60.47,32.83 60.37,32.73 59.18,32.73 58.79,32.34 53.75,32.34 52.61,33.48 50.04,33.48 49.17,32.61 45.8,32.61 45.44,32.97 42.58,32.97 41.89,33.67 40.54,33.67 39.78,34.43 38.5,34.43 38.08,34.85 37.52,35.41 37.14,35.41 35.8,36.75 33.39,36.75 32.42,35.79 v1(32.42,35.56)
  IN3 w0.089: v1(179.72,58.41) 178.93,59.21 178.93,61.25 179.08,61.41 179.08,62.16 178.05,63.19 178.05,64.1 174.12,68.03 174.12,83.98 176.34,86.2 176.34,86.53 176.44,86.63 176.44,87.43 176.88,87.86 177.54,87.86 178.78,89.1 178.78,89.91 178.15,90.54 178.15,95.47 176.92,96.7 176.92,106.74 177.87,107.69 177.87,113.05 176.96,113.97 176.96,116.98 177.12,117.14 177.12,121.65 178.58,123.12 180.07,123.12 v1(180.51,122.67)
  IN4 w0.086: v1(72.53,32.78) 72.53,32.83 72.26,33.1 72.26,34.35 75.5,37.6 77.77,37.6 77.89,37.73 81.06,37.73 81.19,37.6 82.69,37.6 83.64,38.55 83.64,41.96 83.9,42.23 83.9,43.5 84.13,43.72 84.13,46.57 86.44,48.88 86.44,50.44 87.69,51.69 90.13,51.69 90.34,51.47 92.38,51.47 94.04,53.13 97.45,53.13 99.16,54.83 99.16,56.78 98.48,57.45 98.48,58.17 99.37,59.06 99.37,64.07 103.17,67.86 109.57,67.86 109.84,67.59 114.59,67.59 117.03,70.02 162.98,70.02 172.74,60.27 174.06,60.27 175.89,58.44 176.09,58.44 176.22,58.56 178.98,58.56 179.13,58.41 v1(179.72,58.41)
DMIC_CLK_C: length 8.3
  TOP w0.14: v1(176.64,124.18) 176.82,124.37 C62.2 177.9,124.37 177.94,124.33 D12.1 178.97,124.33 179.01,124.37 R70.2
  BOTTOM w0.14: v1(176.64,124.18) 176.07,124.75 CN10.26 174.09,124.75 173.83,125.01 173.83,125.72 173.39,126.16 173.02,126.16 R691.1
DMIC_DAT: length 262.3
  TOP w0.14: C264.2 33.1,35.8 v1(33.1,35.56) 33.1,35.41 R302.1 ; R74.1 180.24,123.13 179.93,122.82 179.93,122.37 180.31,121.98 v1(180.56,121.98)
  IN1 w0.086: v1(33.1,35.56) 33.1,35.98 33.53,36.41 35.66,36.41 37,35.07 37.38,35.07 38.36,34.09 39.64,34.09 40.4,33.33 41.75,33.33 42.44,32.63 45.3,32.63 45.66,32.27 49.31,32.27 50.18,33.14 52.46,33.14 53.61,32 58.93,32 59.32,32.39 60.51,32.39 60.61,32.49 62.65,32.49 62.8,32.34 63.18,32.34 63.8,31.73 64.49,31.73 65.14,32.37 66.23,32.37 66.71,31.9 68.58,31.9 69.3,31.18 71.61,31.18 72.94,32.51 72.94,32.58 v1(73.2,32.84)
  IN3 w0.089: v1(180.56,121.98) 180.03,121.98 179.93,122.09 178.34,122.09 177.46,121.21 177.46,116.99 177.3,116.83 177.3,114.11 178.22,113.19 178.22,107.55 177.27,106.6 177.27,96.84 178.49,95.61 178.49,90.68 179.12,90.06 179.12,88.96 177.68,87.52 177.02,87.52 176.78,87.29 176.78,86.48 176.69,86.39 176.69,86.06 174.47,83.84 174.47,68.17 179.09,63.55 179.09,62.64 179.43,62.3 179.43,61.26 179.27,61.11 179.27,59.6 180.12,58.74 180.12,58.04 v1(179.85,57.77)
  IN4 w0.086: v1(73.2,32.84) 72.94,33.11 72.94,34.56 75.64,37.26 77.91,37.26 78.04,37.39 80.92,37.39 81.05,37.26 82.83,37.26 83.98,38.41 83.98,41.82 84.24,42.09 84.24,43.36 84.47,43.58 84.47,46.43 86.78,48.74 86.78,50.3 87.83,51.35 89.98,51.35 90.2,51.13 92.52,51.13 94.18,52.79 97.6,52.79 99.5,54.69 99.5,56.92 98.82,57.59 98.82,58.03 99.71,58.92 99.71,63.93 103.31,67.52 109.43,67.52 109.7,67.25 114.73,67.25 117.17,69.68 162.84,69.68 172.6,59.92 173.92,59.92 175.75,58.1 176.35,58.1 176.47,58.22 178.69,58.22 178.87,58.04 179.28,58.04 179.56,57.77 v1(179.85,57.77)
DMIC_DATA_C: length 8.4
  TOP w0.14: R74.2 179.38,123.28 D13.1 178.42,123.24 C66.2 177.14,123.54 v1(176.62,123.54)
  BOTTOM w0.14: v1(176.62,123.54) 175.91,124.25 CN10.25 174.03,124.25 173.44,124.85 173.44,125.56 173.23,125.77 173.01,125.77 R692.1
DNBSWON#: length 173.8
  TOP w0.14: v1(225.37,23.73) 225.51,23.73 U14.BE46 ; v1(72.83,36.5) 72.89,36.5 73.03,36.35 U18.123
  IN3 w0.089: v1(72.83,36.5) 73.23,36.9 74.87,36.9 75.69,36.08 79.49,36.08 79.92,35.65 82,35.65 83.47,37.13 84.59,37.13 84.81,37.35 85.19,37.35 85.39,37.14 87.88,37.14 88.66,36.36 90.06,36.36 90.5,36.81 91.99,36.81 93.31,35.48 94.18,35.48 94.65,35.95 96.01,35.95 96.57,35.39 98.83,35.39 98.98,35.53 177.11,35.53 178.41,36.83 187.76,36.83 190.73,33.85 190.73,33.41 191.66,32.48 191.92,32.48 192.54,31.85 193.06,31.85 194.02,30.89 194.02,30.45 193.36,29.79 191.84,29.79 191.59,29.53 191.59,27.42 194.05,24.95 195.88,24.95 197.16,23.67 197.16,22.53 197.84,21.85 198.92,21.85 198.94,21.87 200.51,21.87 201.21,21.17 207.21,21.17 209.15,23.12 210.8,23.12 210.91,23.23 211.33,23.23 211.67,22.89 212.96,22.89 213.36,23.29 214.24,23.29 214.45,23.08 216.62,23.08 217.63,24.08 220.26,24.08 220.62,23.73 v1(225.37,23.73)
DP_D0: length 142.9
  TOP w0.102: UG1.BH17 48.1,95.95 47.77,95.62 v2(47.75,95.62)
  IN4 w0.086: v2(47.75,95.62) 47.77,95.62 47.8,95.65 48.04,95.65 48.2,95.48 48.2,93.83 48.81,93.22 49.41,93.22 53.17,89.46 53.17,89.37 55.95,86.59 74.43,86.59 75.33,87.49 75.96,87.49 76.15,87.69 76.15,88.33 76.24,88.41 76.66,88.41 76.75,88.33 76.75,87.69 76.94,87.49 77.52,87.49 77.72,87.69 77.72,88.33 77.8,88.41 78.23,88.41 78.31,88.33 78.31,87.69 78.51,87.49 79.09,87.49 79.28,87.69 79.28,88.23 79.37,88.31 79.78,88.31 79.88,88.22 79.88,87.69 80.07,87.49 80.65,87.49 80.85,87.69 80.85,88.12 80.94,88.22 81.36,88.22 81.44,88.13 81.44,87.69 81.64,87.49 82.28,87.49 83.16,88.37 83.16,88.65 82.76,89.05 82.76,89.17 83.06,89.47 83.18,89.47 83.58,89.07 83.85,89.07 87.56,92.78 94.97,92.78 95.79,91.95 98.48,91.95 102.5,95.98 102.5,97.36 103.17,98.03 103.17,98.77 104.3,99.9 104.3,116.2 104.38,116.29 104.59,116.29 104.79,116.48 104.79,117.06 104.59,117.26 104.38,117.26 104.3,117.34 104.3,117.77 104.38,117.85 104.59,117.85 104.79,118.05 104.79,118.63 104.59,118.82 104.38,118.82 104.3,118.91 104.3,133.85 104.1,134.04 102.51,134.04 102.42,134.13 102.42,134.55 102.51,134.64 104.08,134.64 104.3,134.86 104.3,135.43 104.1,135.63 100.92,135.63 100.83,135.72 100.83,136.14 100.92,136.23 104.1,136.23 104.3,136.42 104.3,137.62 104.92,138.24 104.92,141.75 104.34,142.33 103.4,142.33 102.92,142.81 99.55,142.81 97.65,144.71 97.65,146.58 v1(97.87,146.8)
  BOTTOM w0.14: C528.1 96.19,148.03 96.04,147.87 96.04,147.73 96.19,147.58 97.04,147.58 97.42,147.2 97.42,147.02 97.64,146.8 v1(97.87,146.8)
DP_D0#: length 143
  TOP w0.105: UG1.BG17 v2(47.75,96.25)
  IN4 w0.086: v1(96.97,146.8) 97.06,146.9 97.31,146.9 97.46,146.74 97.46,144.63 99.47,142.62 102.84,142.62 103.32,142.14 104.26,142.14 104.73,141.67 104.73,138.32 104.11,137.7 104.11,136.5 104.02,136.41 100.84,136.41 100.64,136.22 100.64,135.64 100.84,135.44 104.02,135.44 104.11,135.36 104.11,134.93 104,134.82 102.43,134.82 102.23,134.63 102.23,134.05 102.43,133.85 104.02,133.85 104.11,133.77 104.11,118.83 104.31,118.63 104.51,118.63 104.6,118.55 104.6,118.13 104.51,118.04 104.31,118.04 104.11,117.84 104.11,117.27 104.31,117.07 104.51,117.07 104.6,116.98 104.6,116.56 104.51,116.47 104.31,116.47 104.11,116.28 104.11,99.98 102.98,98.85 102.98,98.11 102.31,97.43 102.31,96.05 98.4,92.14 95.87,92.14 95.05,92.97 87.48,92.97 83.78,89.26 83.65,89.26 83.26,89.66 82.98,89.66 82.57,89.25 82.57,88.97 82.97,88.57 82.97,88.45 82.2,87.68 81.72,87.68 81.63,87.77 81.63,88.21 81.53,88.31 81.53,88.31 81.53,88.31 81.44,88.4 80.86,88.4 80.66,88.2 80.66,87.77 80.57,87.68 80.15,87.68 80.07,87.77 80.07,88.3 79.86,88.5 79.29,88.5 79.1,88.3 79.1,87.77 79.01,87.68 78.59,87.68 78.5,87.77 78.5,88.4 78.3,88.6 77.73,88.6 77.53,88.4 77.53,87.77 77.44,87.68 77.02,87.68 76.94,87.77 76.94,88.4 76.74,88.6 76.16,88.6 75.97,88.4 75.97,87.77 75.88,87.68 75.26,87.68 74.36,86.78 56.03,86.78 53.36,89.45 53.36,89.54 49.49,93.41 48.89,93.41 48.39,93.91 48.39,95.61 v2(47.75,96.25)
  BOTTOM w0.14: C529.1 95.72,147.83 95.72,147.6 96.06,147.26 96.91,147.26 97.1,147.07 97.1,146.93 v1(96.97,146.8)
DP_D1: length 143
  TOP w0.105: v2(47.21,96.23) 46.79,96.65 UG1.BG15
  IN4 w0.086: v1(98.73,148.1) 98.73,148.38 98.85,148.5 99.11,148.5 99.23,148.38 99.23,147.45 98.26,146.47 98.26,144.83 99.81,143.28 103.13,143.28 103.59,142.82 104.64,142.82 105.43,142.03 105.43,137.96 104.81,137.34 104.81,126.51 105.27,126.05 105.27,120.4 105.18,120.31 104.96,120.31 104.76,120.12 104.76,119.54 104.96,119.34 105.18,119.34 105.27,119.26 105.27,111.48 105.18,111.39 104.96,111.39 104.76,111.2 104.76,110.62 104.96,110.42 105.18,110.42 105.27,110.34 105.27,108.7 104.81,108.25 104.81,98.73 102.99,96.92 102.99,95.19 99.24,91.44 95.43,91.44 94.57,92.3 87.88,92.3 82,86.43 81.73,86.43 81.23,86.93 80.7,86.93 80.5,86.73 80.5,86.27 80.35,86.12 79.77,86.12 79.69,86.21 79.69,86.8 79.49,87 78.91,87 78.72,86.8 78.72,86.21 78.63,86.12 78.21,86.12 78.12,86.21 78.12,86.8 77.92,87 77.35,87 77.15,86.8 77.15,86.21 77.06,86.12 76.64,86.12 76.56,86.21 76.56,86.8 76.36,87 75.78,87 75.59,86.8 75.59,86.21 75.5,86.12 55.73,86.12 52.62,89.23 52.62,89.35 49.17,92.8 48.39,92.8 46.86,94.34 46.86,96.45 47.04,96.63 47.32,96.63 47.4,96.54 47.4,96.42 v2(47.21,96.23)
  BOTTOM w0.14: v1(98.73,148.1) 99,147.82 99,147.1 98.02,146.12 95.82,146.12 94.45,147.49 94.45,147.85 94.62,148.03 C530.1
DP_D1#: length 143
  TOP w0.105: UG1.BF15 v2(47.12,96.98)
  IN4 w0.086: v2(47.12,96.98) 46.67,96.53 46.67,94.26 48.31,92.61 49.09,92.61 52.43,89.27 52.43,89.15 55.65,85.93 75.58,85.93 75.77,86.13 75.77,86.72 75.86,86.81 76.28,86.81 76.37,86.72 76.37,86.13 76.56,85.93 77.14,85.93 77.34,86.13 77.34,86.72 77.42,86.81 77.85,86.81 77.93,86.72 77.93,86.13 78.13,85.93 78.71,85.93 78.9,86.13 78.9,86.72 78.99,86.81 79.41,86.81 79.5,86.72 79.5,86.13 79.69,85.93 80.42,85.93 80.68,86.19 80.68,86.65 80.78,86.74 81.15,86.74 81.65,86.24 82.08,86.24 87.95,92.12 94.49,92.12 95.35,91.25 99.32,91.25 103.18,95.12 103.18,96.84 105,98.66 105,108.17 105.45,108.63 105.45,110.41 105.26,110.61 105.04,110.61 104.95,110.7 104.95,111.12 105.04,111.21 105.26,111.21 105.45,111.4 105.45,119.33 105.26,119.53 105.04,119.53 104.95,119.62 104.95,120.04 105.04,120.12 105.26,120.12 105.45,120.32 105.45,126.13 105,126.59 105,137.27 105.62,137.89 105.62,142.11 104.72,143 103.67,143 103.2,143.47 99.89,143.47 98.44,144.91 98.44,146.39 99.42,147.37 99.42,147.89 v1(99.63,148.1)
  BOTTOM w0.14: v1(99.63,148.1) 99.32,147.79 99.32,146.97 98.15,145.8 95.69,145.8 94.13,147.36 94.13,147.9 C531.1
DP_D2: length 143.3
  TOP w0.105: v2(45.69,98.35) 46,98.05 UG1.BE14
  IN4 w0.086: v2(45.69,98.35) 45.69,98.26 45.86,98.09 46.13,98.09 46.32,97.89 46.32,93.92 48.1,92.14 48.9,92.14 51.89,89.16 51.89,88.95 55.41,85.43 66.59,85.43 66.78,85.24 66.78,84.71 66.87,84.62 67.29,84.62 67.38,84.71 67.38,85.23 67.58,85.43 71.82,85.43 72.17,85.09 73.25,85.09 73.59,85.43 81.94,85.43 87.28,90.77 100.1,90.77 103.67,94.34 103.67,96.56 105.48,98.37 105.48,107.96 105.93,108.4 105.93,126.33 105.48,126.77 105.48,137 106.11,137.63 106.11,142.42 104.6,143.93 100.13,143.93 99.34,144.73 99.34,145.47 100.36,146.5 100.36,147.15 100.17,147.35 99.99,147.35 99.86,147.21 v1(99.86,146.85)
  BOTTOM w0.14: v1(99.86,146.85) 100.01,146.85 100.17,146.68 100.17,146.42 99.96,146.21 99.58,146.21 98.53,145.15 95.32,145.15 94.25,146.22 93.49,146.22 92.87,146.84 92.87,147.88 93.02,148.03 C532.1
DP_D2#: length 143.3
  TOP w0.105: UG1.BF14 46.1,97.4 46.1,97.55 45.99,97.65 v2(45.69,97.65)
  IN4 w0.086: v2(45.69,97.65) 45.69,97.85 45.75,97.9 46.05,97.9 46.14,97.82 46.14,93.84 48.02,91.95 48.82,91.95 51.7,89.08 51.7,88.88 55.33,85.24 66.51,85.24 66.6,85.16 66.6,84.63 66.79,84.43 67.37,84.43 67.57,84.63 67.57,85.15 67.66,85.24 71.75,85.24 72.09,84.9 73.33,84.9 73.67,85.24 82.02,85.24 87.36,90.58 100.18,90.58 103.86,94.26 103.86,96.48 105.67,98.29 105.67,107.88 106.11,108.32 106.11,126.41 105.67,126.85 105.67,136.92 106.3,137.56 106.3,142.5 104.68,144.12 100.21,144.12 99.52,144.81 99.52,145.39 100.55,146.42 100.55,146.63 v1(100.76,146.85)
  BOTTOM w0.14: C533.1 92.55,147.95 92.55,146.71 93.36,145.9 94.12,145.9 95.19,144.83 98.66,144.83 99.71,145.89 100.09,145.89 100.49,146.28 100.49,146.58 v1(100.76,146.85)
DP_D3: length 143.9
  TOP w0.102: UG1.BH14 46.05,96.22 46.33,96.5 46.47,96.5 46.59,96.38 46.59,96.27 46.4,96.08 46.4,95.73 46.29,95.62 v2(45.72,95.62)
  IN4 w0.086: v2(45.72,95.62) 45.56,95.46 45.56,95.18 45.72,95.02 45.72,93.58 47.82,91.48 48.63,91.48 51.18,88.93 51.18,87.24 51.89,86.53 52.18,86.53 53.93,84.78 60.28,84.78 61.15,83.91 81.57,83.91 87.75,90.08 101.22,90.08 102.87,91.73 102.87,92.31 104.77,94.21 104.77,96.7 106.16,98.09 106.16,107.64 106.59,108.07 106.59,126.68 106.16,127.11 106.16,136.65 106.85,137.34 106.85,143.06 104.6,145.31 102.7,145.31 101.98,144.59 100.78,144.59 100.57,144.79 100.57,144.99 100.38,145.18 v1(100.2,145.18)
  BOTTOM w0.14: C534.1 91.53,148.03 91.32,147.82 91.32,146.86 93.05,145.13 93.69,145.13 94.63,144.19 99.82,144.19 100.42,144.79 100.42,144.95 v1(100.2,145.18)
DP_D3#: length 144
  TOP w0.105: UG1.BG14 45.7,96.3 v2(45.7,96.29)
  IN4 w0.086: v1(100.93,145.18) 100.76,145.01 100.76,144.87 100.86,144.78 101.9,144.78 102.62,145.49 104.68,145.49 107.04,143.14 107.04,137.26 106.35,136.57 106.35,127.19 106.77,126.76 106.77,107.99 106.35,107.56 106.35,98.01 104.96,96.63 104.96,94.13 103.05,92.23 103.05,91.65 101.3,89.9 87.83,89.9 81.65,83.72 61.07,83.72 60.2,84.59 53.85,84.59 52.1,86.34 51.82,86.34 51,87.16 51,88.85 48.56,91.29 47.74,91.29 45.53,93.5 45.53,94.94 45.37,95.1 45.37,95.96 v2(45.7,96.29)
  BOTTOM w0.14: C535.1 91,147.97 91,146.73 92.92,144.82 93.56,144.82 94.5,143.87 99.96,143.87 100.74,144.66 100.74,144.99 v1(100.93,145.18)
DP_HPD: length 21.5
  TOP w0.14: v1(81.53,159.55) 81.84,159.86 R18.2
  IN4 w0.086: v1(83.53,162.7) 82.15,164.08 81.03,164.08 80.49,164.63 80.49,165.71 80.81,166.03 89.23,166.03 CN2.18
  BOTTOM w0.14: v1(81.53,159.55) 81.78,159.81 81.78,160 C509.1 82.47,159.94 82.47,159.82 82.68,159.61 83.35,159.61 83.59,159.85 83.59,160.25 ESD1.4 83.6,160.5 83.6,161.14 ESD1.7 83.59,161.39 83.59,161.9 83.51,161.98 83.51,162.68 v1(83.53,162.7)
DP_HPD_PCH: length 313.9
  TOP w0.14: R18.1 82.56,160.31 82.73,160.14 84.54,160.14 85.25,159.44 v1(86.16,159.44) ; RG22.2 27.74,98.92 27.61,99.05 CG45.1 27.42,98.84 27.07,98.49 27.07,98.29 v1(27.07,98.29) ; v1(97.45,81.96) 99.91,81.96 101.66,80.2 102.91,80.2 103.21,80.5 104.37,80.5 104.55,80.68 v1(105.02,80.68) 106.15,80.68 106.75,80.08 164.17,80.08 179.01,65.24 179.47,65.24 181.52,63.19 182.34,63.19 186.44,59.08 188.75,59.08 188.87,58.97 190.5,58.97 191.03,58.44 192.4,58.44 192.49,58.35 192.49,58.35 192.87,57.97 199.14,57.97 v1(199.27,57.84)
  IN2 w0.089: v1(105.02,80.68) 105.62,81.28 105.62,85.82 104.65,86.79 104.65,88.64 103.52,89.77 103.52,92.25 102.62,93.15 102.62,96.54 105.08,99 105.08,111.12 105.75,111.8 105.75,143.86 102.1,147.51 102.1,148.4 99.74,150.77 98.6,150.77 97.88,151.48 97.88,154.6 95.05,157.43 91.95,157.43 v1(91.78,157.61) 91.11,158.28 90.34,158.28 89.18,159.44 v1(86.16,159.44) ; v1(27.07,98.29) 27.37,98.29 27.63,98.54 29.41,98.54 31.03,96.92 31.7,96.92 32.71,95.91 34.81,95.91 35.28,96.37 36.48,96.37 38.7,98.59 39.06,98.59 39.19,98.72 41.31,98.72 41.38,98.79 41.69,98.79 42.42,98.06 43.79,98.06 45.18,96.67 45.91,96.67 46.26,96.33 46.26,94.1 47.72,92.63 48.17,92.63 51.28,89.53 51.28,86.6 52.74,85.13 55.09,85.13 56.74,83.48 61.18,83.48 61.96,82.7 82.28,82.7 87.66,88.08 94.12,88.08 97.76,84.44 97.76,82.26 v1(97.45,81.96)
  BOTTOM w0.14: Q70.3 201.14,51.73 200.3,51.73 199.8,51.23 R789.2 198.87,51.23 198.26,51.84 198.26,52.28 198.6,52.62 198.98,52.62 199.38,53.03 199.38,54.07 199.56,54.25 199.56,55.17 199.27,55.45 v1(199.27,57.84) ; v1(91.78,157.61) 91.78,157.86 91.38,158.27 R653.2
DP_HPD_PCH_R: length 38.8
  TOP w0.14: U14.AN10 208.22,30.25 v1(208.61,30.64)
  IN2 w0.089: v1(199.38,52.04) 199.38,49.67 198.49,48.77 197.85,48.77 196.88,47.8 196.88,43.85 197.19,43.54 197.19,42.65 198.57,41.27 198.57,40.03 200.78,37.82 203.16,37.82 204.95,36.03 206.44,36.03 207.51,34.97 209.26,34.97 209.49,34.74 209.49,33.82 209.7,33.62 209.7,32.45 209.59,32.34 209.59,31.65 209.24,31.3 209.24,31.26 208.62,30.64 v1(208.61,30.64)
  BOTTOM w0.14: v1(199.38,52.04) 199.66,52.04 200.51,52.88 201.4,52.88 201.84,53.33 202.8,53.33 203.23,52.89 R781.1 203.23,51.91 203.28,51.86 Q70.4
DP_HPD_TBT_Q: length 16.6
  TOP w0.14: QG7.2 23.53,94.31 v1(24.55,93.29) 24.98,92.87 24.98,92.15 25.19,91.94 25.19,91.39 25.55,91.03 25.55,90.21 25.2,89.87 17.95,89.87 RG38.1 17.7,91.12 17.7,91.95 RG32.1
DP_TXN0_R: length 3.5
  BOTTOM w0.14: U39.10 94.02,150.27 94.06,150.22 94.06,150.01 94.4,149.67 95.22,149.67 95.75,149.14 95.75,148.7 C529.2
DP_TXN1_R: length 3.2
  BOTTOM w0.14: U39.13 92.82,150.24 92.86,150.2 92.86,149.56 93.47,148.95 94.07,148.95 94.22,148.8 94.22,148.7 C531.2
DP_TXN2_R: length 2.9
  BOTTOM w0.14: C533.2 92.69,148.69 92.69,148.8 92.51,148.98 92.23,148.98 91.68,149.53 91.68,150.15 91.62,150.21 U39.16
DP_TXN3_R: length 2.6
  BOTTOM w0.14: U39.19 90.42,150.19 90.46,150.15 90.46,149.55 91.17,148.84 91.17,148.7 C535.2
DP_TXP0_R: length 3.5
  BOTTOM w0.14: U39.9 94.42,150.25 94.38,150.21 94.38,150.14 94.53,149.99 95.35,149.99 96.07,149.28 96.07,148.69 C528.2
DP_TXP1_R: length 3.2
  BOTTOM w0.14: C530.2 94.54,148.7 94.54,148.93 94.2,149.27 93.6,149.27 93.18,149.69 93.18,150.17 93.22,150.22 U39.12
DP_TXP2_R: length 2.9
  BOTTOM w0.14: U39.15 92.02,150.18 92,150.15 92,149.66 92.37,149.29 92.64,149.29 93.01,148.93 93.01,148.7 C532.2
DP_TXP3_R: length 2.6
  BOTTOM w0.14: U39.18 90.82,150.19 90.78,150.15 90.78,149.68 91.49,148.97 91.49,148.7 C534.2
DP_USB_MUX_0V9: length 16.2
  TOP w0.102: 258.77,17.5 258.84,17.5 v1(258.84,17.49)
  TOP w0.203: v1(268.05,19.57) 267.98,19.64 U24.10 ; U24.15 267.43,21.64 267.63,21.84 267.63,22.27 v1(267.51,22.39) ; v1(258.84,17.49) 259.23,17.49 259.37,17.64 U24.41
  TOP w0.508: C455.2 257.89,17.49 258.69,17.49 258.7,17.5 258.77,17.5
  IN2 w0.508: v1(268.05,19.57) 263.41,19.57 262.45,18.61 261.59,18.61 261.26,18.94 260.19,18.94 258.84,17.59 v1(258.84,17.49)
  BOTTOM w0.508: C900.2 267.05,21.94 v1(267.51,22.39) ; v1(268.05,19.57) 267.46,19.57 C911.2
  vias: v1(268.75,11.47) v1(269.51,11.47) v1(274.8,24.5) v1(275.13,23.94) v1(275.13,23.18)
DP_USB_MUX_AUXN: length 338.7
  TOP w0.14: v1(268.73,18.86) 268.67,18.81 268.12,18.81 267.69,19.24 U24.9 ; v1(38.13,85.2) 38.08,85.26 38.08,85.59 CG79.2
  IN1 w0.086: v1(268.73,18.86) 268.41,18.86 268.17,19.1 266.44,19.1 266.21,19.33 266.21,20.74 265.49,21.46 258.05,21.46 257.55,21.96 256.19,21.96 251.68,26.47 247.18,26.47 244.94,28.7 244.15,28.7 243.4,29.46 242.38,29.46 240.69,31.14 240.69,33.89 241.13,34.32 241.13,36.04 240.64,36.52 240.64,40.38 240.08,40.94 240.08,42.2 239.54,42.74 239.54,45.15 238.07,46.62 238.07,49.04 234.22,52.88 229.15,52.88 224.26,57.78 224.26,58.3 223.78,58.77 222.6,58.77 221.93,59.43 218.74,59.43 218.32,59.86 216.11,59.86 215.75,59.49 214.64,59.49 214.32,59.82 212.19,59.82 211.4,60.61 203.59,60.61 202.12,62.08 197.81,62.08 197.12,61.39 195.45,61.39 194.99,61.85 192.88,61.85 191.46,63.27 186.07,63.27 182.83,60.04 182.16,60.04 181.3,59.18 178.9,59.18 175.83,56.1 175.83,53.55 175.29,53.01 175.29,50.54 174.66,49.9 174.66,44.73 175.33,44.06 175.33,40.78 172.72,38.17 104.69,38.17 103.85,39.01 103.85,39.53 102.25,41.13 102.25,43.39 103.76,44.9 103.76,46.86 102.67,47.95 102.67,51.75 101.42,53.01 101.42,65.06 102.05,65.69 102.05,68.66 100.7,70.01 100.7,72.68 100.29,73.09 100.29,76.21 100.73,76.66 100.73,79.66 99.47,80.92 99.47,85.58 98.08,86.98 88.71,86.98 82,80.27 58.44,80.27 53.75,84.95 52.74,84.95 51.59,86.1 51.59,86.67 51.13,87.13 50.56,87.13 50.07,86.63 49.14,86.63 48.22,87.56 40.38,87.56 39.19,86.37 39.19,85.09 38.89,84.79 38.02,84.79 37.94,84.87 37.94,85 v1(38.13,85.2)
DP_USB_MUX_AUXP: length 338.7
  TOP w0.14: CG78.2 37.62,85.89 37.76,85.74 37.76,85.48 v1(37.48,85.2) ; U24.8 267.65,18.84 v1(268.1,18.39)
  IN1 w0.086: v1(37.48,85.2) 37.64,85.2 37.75,85.09 37.75,84.79 37.94,84.6 38.97,84.6 39.38,85.01 39.38,86.29 40.46,87.37 48.14,87.37 49.06,86.45 50.14,86.45 50.64,86.94 51.05,86.94 51.4,86.59 51.4,86.02 52.66,84.77 53.67,84.77 58.36,80.08 82.08,80.08 88.79,86.79 98,86.79 99.28,85.5 99.28,80.85 100.54,79.58 100.54,76.74 100.1,76.29 100.1,73.02 100.52,72.6 100.52,69.93 101.86,68.58 101.86,65.77 101.23,65.13 101.23,52.93 102.48,51.68 102.48,47.87 103.57,46.78 103.57,44.97 102.07,43.47 102.07,41.05 103.67,39.45 103.67,38.93 104.61,37.98 172.79,37.98 175.52,40.7 175.52,44.14 174.85,44.81 174.85,49.83 175.48,50.46 175.48,52.94 176.01,53.47 176.01,56.03 178.98,58.99 181.37,58.99 182.23,59.85 182.91,59.85 186.14,63.08 191.38,63.08 192.81,61.66 194.91,61.66 195.37,61.21 197.2,61.21 197.88,61.89 202.04,61.89 203.51,60.42 211.32,60.42 212.11,59.63 214.24,59.63 214.57,59.31 215.82,59.31 216.19,59.67 218.24,59.67 218.66,59.25 221.85,59.25 222.52,58.58 223.71,58.58 224.07,58.22 224.07,57.71 229.08,52.7 234.14,52.7 237.88,48.96 237.88,46.54 239.35,45.07 239.35,42.66 239.9,42.12 239.9,40.86 240.46,40.3 240.46,36.44 240.94,35.96 240.94,34.39 240.51,33.96 240.51,31.06 242.3,29.27 243.32,29.27 244.08,28.52 244.86,28.52 247.1,26.28 251.61,26.28 256.11,21.77 257.47,21.77 257.97,21.27 265.41,21.27 266.02,20.66 266.02,19.25 266.36,18.91 268.09,18.91 268.24,18.77 268.24,18.53 v1(268.1,18.39)
DP_USB_MUX_AVDD09: length 22.3
  TOP w0.203: U24.51 v1(262.74,14.24) ; U24.21 264.34,23.55 v1(264.38,23.59)
  IN2 w0.508: v1(267.93,15.48) 263.99,15.48 v1(262.74,14.24)
  IN4 w0.508: v1(264.38,23.59) 264.38,23.44 263.82,22.88 263.82,21.38 263.16,20.72 263.16,18.53 263.67,18.03 264.99,18.03 265.35,17.67 265.35,16.01 265.88,15.48 v1(267.93,15.48)
  BOTTOM w0.508: v1(262.74,14.24) 262.71,14.28 C925.1 ; C874.2 264.43,24.1 264.43,23.64 v1(264.38,23.59)
DP_USB_MUX_DCI_CLK: length 1.5
  TOP w0.14: TP56.1 260.88,14.34 261.14,14.61 U24.47
DP_USB_MUX_DCI_DAT: length 2.5
  TOP w0.14: TP58.1 260.37,13.63 260.37,14.29 260.74,14.67 U24.46
DP_USB_MUX_FLIP: length 3.8
  TOP w0.14: v1(260.8,23.36) 261.14,23.01 U24.29
  BOTTOM w0.14: R976.2 261.25,24.06 260.8,23.6 v1(260.8,23.36) 260.8,22.74 R1007.1
DP_USB_MUX_I2C_ADR_SEL0: length 5.3
  TOP w0.14: v1(258.39,20.01) 258.67,19.73 259.32,19.73 259.41,19.64 U24.36
  BOTTOM w0.14: v1(258.39,20.01) 258.69,19.7 259.5,19.7 R1042.1 259.6,19.44 259.43,19.27 258.51,19.27 258.09,18.85 R1069.1
DP_USB_MUX_I2C_ADR_SEL1: length 3
  TOP w0.14: U24.35 259.17,20.04 v1(259.02,20.18)
  BOTTOM w0.14: v1(259.02,20.18) 259.18,20.18 R1022.1 260.12,21.12 R1020.1
DP_USB_MUX_ML0N: length 321.4
  TOP w0.14: CG76.2 46.34,86.06 46.34,85.61 v1(46.25,85.51) ; U24.56 264.74,14.73 264.7,14.68 264.7,13.95 v1(264.92,13.73)
  IN1 w0.086: v1(46.25,85.51) 46.54,85.22 46.54,84.16 46.85,83.85 48.04,83.85 49.21,82.67 51.06,82.67 51.72,82.01 52.14,82.01 52.8,82.67 52.99,82.67 53.39,82.27 53.39,82.15 52.58,81.34 52.58,80.99 52.92,80.64 53.25,80.64 54.05,81.44 54.18,81.44 54.49,81.13 54.49,80.93 53.65,80.09 53.65,79.68 53.85,79.48 54.43,79.48 55.23,80.27 55.35,80.27 57.51,78.11 87.52,78.11 89.09,76.54 92.67,76.54 93.38,75.83 94.45,75.83 95.13,75.16 95.13,73.31 97.53,70.91 97.53,68.95 97.81,68.67 98.75,68.67 98.84,68.59 98.84,68.03 98.75,67.94 97.55,67.94 97.35,67.74 97.35,67.17 97.54,66.97 99.6,66.97 99.69,66.88 99.69,66.46 99.6,66.37 97.59,66.37 97.35,66.13 97.35,65.65 97.59,65.4 98.64,65.4 99.18,64.87 99.18,58.5 98.93,58.25 98.93,56.79 99.26,56.46 99.26,52.11 99.77,51.61 99.77,47.63 100.04,47.36 100.04,44.15 99.57,43.67 99.57,39.39 102.96,36 173.65,36 177.5,39.84 177.5,41.73 178.04,42.27 178.04,51.89 183.64,57.49 183.8,57.49 184.03,57.72 184.03,58.19 185.95,60.1 190.39,60.1 190.82,59.68 193.51,59.68 194.2,58.98 198.43,58.98 198.98,58.44 210.41,58.44 211.23,57.61 213.44,57.61 213.91,57.15 220.18,57.15 221.59,55.73 223.22,55.73 228.24,50.71 231.96,50.71 235.83,46.85 235.83,45.08 236.33,44.58 236.33,41.75 237.17,40.91 237.17,39.62 236.21,38.66 236.21,37.9 237.58,36.52 237.58,31.2 239.99,28.8 239.99,27.56 240.85,26.7 242.12,26.7 244,24.82 244.26,24.82 245.18,23.91 245.64,23.91 246.44,23.11 246.44,22.89 247.17,22.16 247.82,22.16 248.67,21.3 248.67,20.79 249.62,19.84 252.32,19.84 253.61,18.55 255.21,18.55 255.97,17.79 256.68,17.79 259.42,15.05 259.71,14.76 259.84,14.63 261.38,13.09 264.48,13.09 264.68,13.29 264.68,13.46 264.68,13.51 264.9,13.73 v1(264.92,13.73)
DP_USB_MUX_ML0P: length 321.4
  TOP w0.14: CG75.2 46.8,86.27 46.66,86.13 46.66,85.73 46.9,85.49 v1(47.04,85.49) ; U24.55 264.34,14.71 264.38,14.67 264.38,13.9 v1(264.22,13.73)
  IN1 w0.086: v1(47.04,85.49) 46.88,85.49 46.73,85.34 46.73,84.24 46.93,84.03 48.11,84.03 49.29,82.86 51.14,82.86 51.79,82.2 52.06,82.2 52.72,82.86 53.07,82.86 53.57,82.35 53.57,82.07 52.76,81.26 52.76,81.07 53,80.83 53.18,80.83 53.97,81.63 54.26,81.63 54.68,81.21 54.68,80.85 53.84,80.01 53.84,79.76 53.93,79.67 54.35,79.67 55.15,80.46 55.43,80.46 57.59,78.3 87.59,78.3 89.17,76.72 92.75,76.72 93.46,76.02 94.53,76.02 95.32,75.23 95.32,73.39 97.72,70.99 97.72,69.03 97.89,68.86 98.83,68.86 99.03,68.66 99.03,67.95 98.83,67.75 97.63,67.75 97.53,67.66 97.53,67.24 97.62,67.16 99.68,67.16 99.87,66.96 99.87,66.38 99.68,66.19 97.67,66.19 97.53,66.05 97.53,65.73 97.67,65.59 98.72,65.59 99.37,64.94 99.37,58.42 99.12,58.17 99.12,56.87 99.45,56.54 99.45,52.19 99.96,51.69 99.96,47.71 100.23,47.43 100.23,44.07 99.76,43.6 99.76,39.47 103.04,36.19 173.58,36.19 177.31,39.92 177.31,41.81 177.85,42.35 177.85,51.96 183.56,57.68 183.73,57.68 183.85,57.8 183.85,58.27 185.87,60.29 190.47,60.29 190.89,59.86 193.59,59.86 194.28,59.17 198.51,59.17 199.06,58.62 210.49,58.62 211.31,57.8 213.52,57.8 213.98,57.34 220.26,57.34 221.67,55.92 223.3,55.92 228.32,50.9 232.04,50.9 236.02,46.93 236.02,45.16 236.52,44.66 236.52,41.82 237.36,40.99 237.36,39.54 236.4,38.58 236.4,37.98 237.77,36.6 237.77,31.28 240.18,28.88 240.18,27.64 240.92,26.89 242.2,26.89 244.08,25.01 244.34,25.01 245.26,24.1 245.71,24.1 246.62,23.19 246.62,22.97 247.25,22.34 247.9,22.34 248.86,21.38 248.86,20.87 249.7,20.03 252.39,20.03 253.69,18.74 255.29,18.74 256.05,17.97 256.76,17.97 261.46,13.28 264.41,13.28 264.49,13.36 264.49,13.46 v1(264.22,13.73)
