# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMD_DQ30: length 23.8
  TOP w0.102: v2(36.21,111.99) 36.33,111.99 36.38,111.95 37.05,111.95 UG1.AF2
  TOP w0.168: v2(22.52,111.66) 22.52,111.65 VRAM7.U4
  IN2 w0.14: v2(22.52,111.66) 22.51,111.66 22.14,111.3 19.96,111.3 19.69,111.56 19.69,112.71 20.21,113.23 35.21,113.23 35.4,113.02 36.22,112.12 v2(36.21,111.99)
VMD_DQ31: length 21.2
  TOP w0.168: v2(23.23,109.42) 22.88,109.78 VRAM7.U2 ; v2(38.02,110.97) 38.02,111.01 38.35,111.35 UG1.AF3
  IN1 w0.127: v2(38.02,110.97) 38.02,110.96 37.58,110.52 36.48,110.52 36.31,110.35 35.74,110.35 34.51,110.35 34.41,110.25 34.41,109.8 34.26,109.64 33.82,109.64 33.69,109.77 33.69,110.96 33.56,111.09 33.21,111.09 33.05,110.94 33.05,109.77 32.93,109.64 32.55,109.64 32.42,109.77 32.42,110.63 32.29,110.76 31.91,110.76 31.78,110.63 31.78,109.77 31.66,109.64 25,109.64 24.78,109.42 v2(23.23,109.42)
VMD_DQ32: length 20.5
  TOP w0.168: UG1.F4 39.05,125.35 v2(39.38,125.01) ; v2(22.53,131.45) 22.88,131.8 VRAM5.B3
  IN4 w0.127: v2(22.53,131.45) 22.89,131.09 25.19,131.09 26.24,130.04 30.55,130.04 34.72,125.86 36.46,125.86 37.31,125.01 v2(39.38,125.01)
VMD_DQ33: length 16.2
  TOP w0.122: UG1.E1 36.95,126.05 36.51,126.49 v2(36.51,126.52)
  TOP w0.168: VRAM5.A3 v2(24.01,132.2)
  IN4 w0.127: v2(36.51,126.52) 36.27,126.28 35.23,126.28 30.79,130.72 26.61,130.72 25.13,132.2 v2(24.01,132.2)
VMD_DQ34: length 24.3
  TOP w0.168: UG1.F3 38.35,125.35 v2(38.68,125.68) ; VRAM5.E3 20.67,131.83 v2(21.02,131.47)
  IN4 w0.127: v2(21.02,131.47) 21.17,131.47 21.39,131.69 21.39,133.11 21.6,133.32 23.71,133.32 23.82,133.43 25.52,133.43 26.72,132.23 31.14,132.23 35.18,128.2 36.3,128.2 36.78,127.72 36.78,126.89 36.89,126.78 36.89,126.29 37.1,126.07 38.29,126.07 v2(38.68,125.68)
VMD_DQ35: length 21.7
  TOP w0.168: v2(40.07,125.68) 40.07,125.67 UG1.F5 ; VRAM5.B4 v2(23.26,130.7)
  IN4 w0.127: v2(23.26,130.7) 23.35,130.61 23.36,130.61 23.9,130.08 24.97,130.08 25.76,129.29 30.27,129.29 34.53,125.03 36.38,125.03 36.7,124.72 37.1,124.72 37.8,124.02 39.19,124.02 40.07,124.9 v2(40.07,125.68)
VMD_DQ36: length 24.8
  TOP w0.168: VRAM5.F2 19.54,132.92 v2(19.53,132.92) ; v2(37.3,127.1) 37.64,126.75 UG1.D2
  IN4 w0.127: v2(37.3,127.1) 37.3,127.81 37.66,128.17 37.66,128.76 37.43,128.99 37.12,128.99 36.92,129.19 36.01,129.19 31.46,133.74 26.98,133.74 25.83,134.9 23.78,134.9 23.53,134.65 20.48,134.65 19.91,134.08 19.91,133.34 19.53,132.97 v2(19.53,132.92)
VMD_DQ37: length 17.8
  TOP w0.102: v2(35.89,127.66) 35.89,127.37 36.17,127.1 36.6,127.1 UG1.D1
  TOP w0.168: VRAM5.B2 22.6,132.86 22.59,132.86 v2(22.51,132.94)
  IN4 w0.127: v2(22.51,132.94) 22.51,132.91 22.89,132.54 23.65,132.54 23.7,132.59 24.24,132.59 24.35,132.7 25.47,132.7 26.7,131.47 31.06,131.47 34.87,127.66 v2(35.89,127.66)
VMD_DQ38: length 26.3
  TOP w0.168: v2(18.82,132.21) 18.82,132.27 VRAM5.G2 ; UG1.C3 38.35,127.45 38,127.82 37.97,127.82 v2(37.97,127.82)
  IN4 w0.127: v2(18.82,132.21) 18.91,132.21 19.16,132.46 19.16,134.15 20.19,135.19 23.28,135.19 23.59,135.5 26.1,135.5 27.1,134.5 31.79,134.5 36.81,129.48 36.95,129.48 37.22,129.22 37.53,129.22 37.95,128.8 37.95,127.91 37.97,127.89 37.97,127.82 v2(37.97,127.82)
VMD_DQ39: length 23
  TOP w0.102: UG1.C2 37.27,127.83 36.76,127.83 36.59,127.99 v2(36.59,128.81)
  TOP w0.168: VRAM5.E2 20.63,132.58 v2(20.26,132.21)
  IN4 w0.127: v2(20.26,132.21) 20.41,132.21 20.62,132.43 20.62,133.92 20.83,134.12 23.75,134.12 24,134.37 25.51,134.37 26.85,133.02 31.26,133.02 35.47,128.81 v2(36.59,128.81)
VMD_DQ40: length 19.5
  TOP w0.168: v2(39.44,123.61) 39.44,123.56 UG1.J5
  TOP w0.178: VRAM5.B13 23.24,124.69 v2(23.31,124.69)
  IN1 w0.127: v2(23.31,124.69) 23.31,124.65 23.69,124.28 28.94,124.28 30.7,122.52 34.62,122.52 35.3,121.83 37.37,121.83 37.4,121.86 38.4,121.86 39.44,122.9 v2(39.44,123.61)
VMD_DQ41: length 17.6
  TOP w0.168: VRAM5.A12 v2(24.01,125.45) ; v2(38.57,122.62) 38.57,122.75 38.76,122.95 39.05,123.25 UG1.J4
  IN1 w0.127: v2(38.57,122.62) 38.54,122.62 38.34,122.82 37.64,122.82 37.04,122.22 35.36,122.22 34.46,123.12 31.06,123.12 29.01,125.17 24.29,125.17 v2(24.01,125.45)
VMD_DQ42: length 23.9
  TOP w0.168: UG1.L8 v2(42.19,122.19) ; VRAM5.B12 v2(22.51,125.45)
  IN1 w0.127: v2(42.19,122.19) 41.9,121.9 41.22,121.9 41.15,121.83 40.48,121.83 40.21,122.09 39.86,122.09 39.59,121.82 38.9,121.82 38.72,121.64 37.72,121.64 37.4,121.32 35.14,121.32 34.76,121.7 30.31,121.7 28.43,123.57 25.11,123.57 24.98,123.43 23.15,123.43 22.88,123.7 22.88,125.08 v2(22.51,125.45)
VMD_DQ43: length 16.7
  TOP w0.122: UG1.J2 37.65,123.25 37.43,123.25 37.12,122.93 36.6,122.93 v2(36.47,123.05)
  TOP w0.168: v2(23.3,126.2) 23.26,126.2 VRAM5.B11
  IN1 w0.127: v2(36.47,123.05) 35.8,123.05 34.11,124.75 31.58,124.75 29.74,126.58 23.68,126.58 23.3,126.2 v2(23.3,126.2)
VMD_DQ44: length 21.6
  TOP w0.122: UG1.F1 36.66,125.35 36.61,125.41 v2(36.26,125.41)
  TOP w0.168: VRAM5.E13 20.26,124.7 v2(20.26,124.71)
  IN1 w0.127: v2(36.26,125.41) 35.8,125.87 35.41,125.87 34.77,126.52 33.02,126.52 30.88,128.66 21.89,128.66 20.64,127.41 20.64,125.08 20.26,124.7 v2(20.26,124.71)
VMD_DQ45: length 25.9
  TOP w0.168: UG1.F2 37.65,125.35 v2(37.32,125.68) ; v2(18.76,124.7) VRAM5.G13
  IN1 w0.127: v2(18.76,124.7) 19.11,125.06 19.11,127.81 20.89,129.59 20.89,130.03 21.07,130.21 22.02,130.21 22.4,129.83 31.68,129.83 33.84,127.66 35.37,127.66 35.74,127.3 35.88,127.3 36.23,126.94 36.65,126.94 36.89,126.71 36.89,126.11 v2(37.32,125.68)
VMD_DQ46: length 22.6
  TOP w0.168: v2(38.58,124.42) 39.05,123.95 UG1.H4 ; VRAM5.E12 v2(21.01,125.45)
  IN1 w0.127: v2(38.58,124.42) 38.58,124.19 38.42,124.04 37.32,124.04 36.42,124.94 35.58,124.94 34.71,125.81 32.67,125.81 30.44,128.04 22.15,128.04 21.38,127.26 21.38,125.97 21.01,125.6 v2(21.01,125.45)
VMD_DQ47: length 28
  TOP w0.168: v2(40.08,124.28) 39.98,124.28 39.75,124.07 UG1.H5 ; VRAM5.F13 v2(19.49,123.93)
  IN1 w0.127: v2(19.49,123.93) 19.88,124.33 19.88,127.09 20.07,127.28 20.07,127.6 21.76,129.29 31.28,129.29 33.44,127.13 34.96,127.13 35.77,126.31 36.15,126.31 36.81,125.66 36.81,125.26 37.12,124.95 38.81,124.95 39.12,124.63 39.69,124.63 40.05,124.28 v2(40.08,124.28)
VMD_DQ48: length 39.5
  TOP w0.168: VRAM5.V12 v2(10.51,125.45) ; v2(40.79,117.26) 40.8,117.25 40.85,117.25 UG1.V7
  IN1 w0.127: v2(40.79,117.26) 40.47,116.93 36.85,116.93 36.03,117.75 24.92,117.75 24.66,118 20.12,118 20.12,118 19.68,118 19.68,118 19.37,118 19.37,118 18.93,118 18.92,118.01 18.62,118.01 18.6,118 18.2,118 18.19,118.01 17.89,118.01 17.88,118 17.43,118 17.09,118 16.89,117.8 16.89,117.49 16.67,117.27 16.36,117.27 16.15,117.49 16.15,117.8 15.95,118 15.93,118 15.93,118 15.62,118 15.62,118 15.18,118 14.87,118 14.87,118 14.43,118 14.43,118 14.12,118 14.12,118 13.92,118 13.89,118.04 11.79,118.04 11.6,118.23 11.6,121.2 10.76,122.04 10.76,125.2 v2(10.51,125.45)
VMD_DQ49: length 40.3
  TOP w0.102: v2(11.26,126.2) VRAM5.U11
  TOP w0.168: v2(42.26,116.48) 42.2,116.55 42.2,116.6 UG1.V8
  IN1 w0.127: v2(11.26,126.2) 11.6,125.86 11.6,125.03 11.64,125 11.64,123.69 11.6,123.64 11.6,122.16 12.15,121.61 12.15,119.85 12.27,119.72 12.83,119.72 13.11,119.44 13.11,118.91 13.24,118.78 25.71,118.78 26.17,118.32 36.69,118.32 37.54,117.47 38.87,117.47 39.14,117.73 40.41,117.73 40.49,117.65 41.7,117.65 41.87,117.48 41.87,116.93 42.2,116.6 42.2,116.55 v2(42.26,116.48)
VMD_DQ50: length 35.9
  TOP w0.168: v2(11.24,124.72) VRAM5.U13 ; v2(40.85,116.6) 40.75,116.6 40.45,116.91 UG1.V6
  IN2 w0.14: v2(40.85,116.6) 40.8,116.6 40.49,116.91 37.84,116.91 35.38,119.36 24.53,119.36 24.35,119.55 18.27,119.55 18.03,119.79 17.21,119.79 16.75,120.26 16.75,120.43 16.19,121 15.07,121 14.79,121.27 12.51,121.27 10.79,122.99 10.79,124.28 v2(11.24,124.72)
VMD_DQ51: length 32.8
  TOP w0.168: UG1.V9 42.81,117.21 v2(42.88,117.28) ; VRAM5.N13 14.98,123.98 v2(14.98,123.94)
  IN2 w0.14: v2(14.98,123.94) 15.02,123.94 15.37,123.59 16.04,123.59 16.05,123.58 17.42,123.58 18.25,122.74 18.25,122.18 18.88,121.55 36.41,121.55 37.16,120.8 38.61,120.8 39,120.42 39,120.04 39.2,119.84 39.59,119.84 40.65,118.77 40.92,118.77 41.21,119.06 41.64,119.06 41.83,118.87 41.83,118.37 42.85,117.36 42.85,117.32 v2(42.88,117.28)
VMD_DQ52: length 32.6
  TOP w0.168: UG1.U4 39.05,117.65 38.82,117.87 38.76,117.87 v2(38.58,118.05) ; v2(12.06,125.47) 12.02,125.47 11.93,125.37 VRAM5.U12
  IN1 w0.127: v2(12.06,125.47) 12.38,125.14 12.38,122.41 13.9,120.89 18.98,120.89 19.44,120.43 23.88,120.43 24.31,120 25.75,120 26.84,118.9 34.54,118.9 34.69,118.76 37.03,118.76 37.92,117.86 38.34,117.86 38.53,118.05 v2(38.58,118.05)
VMD_DQ53: length 30
  TOP w0.168: UG1.R5 39.58,118.42 v2(39.56,118.41) ; VRAM5.P13 13.76,124.2 v2(13.51,123.95)
  IN2 w0.14: v2(39.56,118.41) 39.56,118.54 38.4,119.69 38.28,119.73 36.96,120.11 36.06,121.01 18.69,121.01 16.96,122.74 16.65,122.74 16.59,122.68 16.18,122.68 16.08,122.79 15.4,122.79 15.29,122.68 14.19,122.68 13.88,122.98 13.88,123.58 v2(13.51,123.95)
VMD_DQ54: length 30.5
  TOP w0.168: UG1.R6 40.76,119.37 v2(40.79,119.37) ; VRAM5.M13 v2(15.76,124.7)
  IN1 w0.127: v2(40.79,119.37) 40.71,119.37 40.42,119.67 39.9,119.67 39.75,119.82 34.87,119.82 34.56,120.12 28.25,120.12 26.69,121.69 20.26,121.69 19.97,121.97 15.39,121.97 15.2,122.16 15.2,122.47 15.37,122.64 15.37,124.32 v2(15.76,124.7)
VMD_DQ55: length 35.4
  TOP w0.168: v2(14.26,124.7) VRAM5.P12 ; UG1.U8 42.24,118.04 42.83,118.04 v2(42.88,117.99)
  IN1 w0.127: v2(14.26,124.7) 14.26,124.5 13.88,124.13 13.88,122.38 14.84,121.42 19.67,121.42 19.97,121.12 25.9,121.12 27.56,119.46 34.65,119.46 34.82,119.3 38.93,119.3 39.16,119.07 40.27,119.07 40.5,118.84 40.93,118.84 41.13,119.04 41.63,119.04 41.83,118.84 41.83,118.5 42.06,118.28 42.53,118.28 42.82,117.99 v2(42.88,117.99)
VMD_DQ56: length 36.3
  TOP w0.168: v2(40.13,120.09) 40.13,120.07 UG1.P6 ; VRAM5.U4 v2(11.26,130.7)
  IN4 w0.102: 39.02,119.87 39.97,119.87 40.13,120.02 v2(40.13,120.09)
  IN4 w0.127: 39.02,119.87 38.82,119.66 35.23,119.66 33.72,119.96 32.58,120.19 31.81,120.42 30.54,120.81 29.01,121.51 28.36,122.16 27.54,122.16 26.13,123.57 24.93,123.57 24.19,124.31 20.8,124.31 20.63,124.48 20.63,124.93 20.48,125.08 20.01,125.08 19.88,125.21 19.88,125.8 19.7,125.98 19.7,126.57 19.15,127.13 19.15,127.67 18.14,128.68 16.22,128.68 15.8,128.26 13,128.26 12.77,128.49 12.77,129.35 11.42,130.7 v2(11.26,130.7)
VMD_DQ57: length 41.3
  TOP w0.168: VRAM5.P3 v2(13.51,131.45) ; UG1.R9 v2(42.91,119.41)
  IN2 w0.14: v2(42.91,119.41) 42.91,119.83 43.17,120.1 43.17,120.56 41.84,121.89 41.21,121.89 41.15,121.83 40.44,121.83 40.41,121.86 40.35,121.92 39.74,121.92 39.55,121.73 38.17,121.73 37.22,122.67 36.32,122.67 35.86,123.13 35.55,123.13 34.89,123.44 32.71,124.49 25.75,124.49 24.8,123.53 20.73,123.53 20.58,123.38 20.11,123.38 19.87,123.63 19.87,127.06 20.1,127.28 20.1,128.39 19.75,128.74 16.54,128.74 16.42,128.76 15.24,128.96 14.2,129.15 13.88,129.46 13.88,131.08 v2(13.51,131.45)
VMD_DQ58: length 33.7
  TOP w0.168: UG1.P4 39.05,119.75 38.68,120.14 v2(38.62,120.2) ; v2(12.01,131.45) VRAM5.U3
  IN4 w0.127: v2(12.01,131.45) 12.39,131.08 12.95,131.08 13.13,130.9 13.13,130.38 13.24,130.27 13.62,130.27 14.03,129.85 14.03,129.41 14.53,128.91 18.69,128.91 20.25,127.35 20.47,127.35 20.63,127.19 20.63,126.01 20.81,125.83 21.25,125.83 21.38,125.7 21.38,125.2 21.5,125.08 24.23,125.08 25,124.31 26.15,124.31 27.76,122.7 28.58,122.7 29.23,122.04 30.82,121.28 33.72,120.51 34.77,120.23 37.64,120.23 37.89,119.98 38.4,119.98 v2(38.62,120.2)
VMD_DQ59: length 39
  TOP w0.168: v2(11.26,132.2) VRAM5.V3 ; v2(39.4,119.44) 39.43,119.44 39.73,119.75 UG1.P5
  IN4 w0.127: v2(39.4,119.44) 39.08,119.12 37.67,119.12 37.5,118.96 35.95,118.96 33.72,119.41 33.24,119.51 32.62,119.62 30.36,120.25 30.25,120.31 28.79,120.98 28.14,121.63 27.32,121.63 26.21,122.74 23.71,122.74 22.88,123.56 19.99,123.56 19.87,123.69 19.87,124.14 19.68,124.33 19.33,124.33 19.13,124.53 19.13,125.17 19.01,125.29 19.01,125.77 19.14,125.91 19.14,126.37 18.13,127.38 18.13,127.97 17.75,128.35 16.47,128.35 15.73,127.61 12.75,127.61 11.89,128.47 11.89,129.75 11.37,130.27 11.14,130.27 10.88,130.52 10.88,131.83 v2(11.26,132.2)
VMD_DQ60: length 36.1
  TOP w0.168: UG1.L7 v2(41.49,121.51) ; v2(12.01,132.95) VRAM5.U2
  IN4 w0.102: 23.37,127.46 23.62,127.21 23.62,126.81 23.83,126.6 24.15,126.6 25.03,125.72
  IN4 w0.127: 23.37,127.46 22.01,127.46 21.24,128.23 20.66,128.23 19.6,129.28 19.6,129.29 18.84,130.05 16.18,130.05 15.15,131.09 14.11,131.09 13.89,131.3 13.89,132.35 13.66,132.58 12.38,132.58 v2(12.01,132.95) ; 25.03,125.72 26.24,125.72 28.2,123.76 29.02,123.76 29.74,123.04 31.41,122.28 33.72,121.61 34.21,121.47 37.07,121.47 37.34,121.21 39.71,121.21 39.73,121.19 39.9,121.01 40.99,121.01 v2(41.49,121.51)
VMD_DQ61: length 33.7
  TOP w0.168: v2(40.84,122.21) 40.8,122.21 40.63,122.03 40.45,121.85 UG1.L6 ; VRAM5.N2 v2(15.01,132.95)
  IN4 w0.127: v2(15.01,132.95) 15.4,132.56 16.69,132.56 16.86,132.39 16.86,131.26 17.06,131.06 18.29,131.06 18.6,130.75 19.69,130.75 20.05,130.39 20.59,130.39 20.79,130.2 20.79,129.52 21.11,129.2 22.52,129.2 22.98,128.74 23.85,128.74 25.13,127.47 29.91,127.47 31.52,125.85 31.52,123.92 32.45,123.17 33.72,122.87 34.1,122.79 34.68,122.66 36.89,122.66 37.79,121.77 39.62,121.77 39.83,121.98 40.55,121.98 40.76,122.2 40.83,122.2 v2(40.84,122.21)
VMD_DQ62: length 34
  TOP w0.168: v2(39.36,122.2) 39.34,122.2 39.05,121.85 UG1.L4 ; VRAM5.P2 v2(14.26,132.2)
  IN2 w0.14: v2(39.36,122.2) 39.36,122.59 38.81,123.14 37.61,123.14 36.75,124.01 36.5,124.05 35.8,123.97 35.38,123.97 33.43,125.08 25.48,125.08 24.7,124.3 20.82,124.3 20.63,124.49 20.63,128.41 19.87,129.18 17.29,129.18 16.72,129.75 16.18,129.75 15.65,130.28 14.89,130.28 14.63,130.53 14.63,131.83 v2(14.26,132.2)
VMD_DQ63: length 30.9
  TOP w0.168: UG1.L5 40.04,121.54 v2(40.1,121.54) ; VRAM5.M2 15.76,132.21 v2(15.76,132.14)
  IN4 w0.127: v2(15.76,132.14) 15.4,131.79 15.4,131.15 16.28,130.28 18.35,130.28 18.56,130.5 19.45,130.5 19.94,130 19.94,129.68 20.84,128.78 21.81,128.78 22.58,128.02 23.63,128.02 25.05,126.6 26.11,126.6 28.42,124.3 29.24,124.3 29.89,123.64 31.46,122.96 32.83,122.43 33.72,122.19 34.32,122.04 37,122.04 37.49,121.54 40.09,121.54 v2(40.1,121.54)
VMD_WCK01: length 35
  TOP w0.102: VRAM7.D4 13.13,111.29 v2(12.76,111.66)
  TOP w0.122: v2(42.79,109.79) 42.7,109.69 42.5,109.69 42.19,109.39 41.99,109.39 UG1.AJ8
  IN2 w0.102: v2(42.79,109.79) 42.77,109.77 42.18,109.77 41.83,110.12 41.83,110.57 41.07,111.33 40.61,111.33 40.38,111.1 39.93,111.1 39.43,111.6 37.39,111.6 35.14,113.86 20.26,113.86 19.22,112.82 19.22,112.42 18.83,112.02 13.36,112.02 13.21,111.88 13.21,111.88 13.16,111.83 12.93,111.83 v2(12.76,111.66)
VMD_WCK01#: length 35.2
  TOP w0.102: VRAM7.D5 13.12,112.03 v2(12.75,112.41)
  TOP w0.122: UG1.AJ7 41.8,109.62 42.1,109.62 42.33,109.84 v2(42.33,110.12)
  IN2 w0.102: v2(12.75,112.41) 12.75,112.13 12.85,112.03 13.08,112.03 13.12,112.08 13.13,112.08 13.27,112.23 18.75,112.23 19.02,112.5 19.02,112.91 20.17,114.06 35.22,114.06 37.48,111.81 39.51,111.81 40.02,111.3 40.29,111.3 40.53,111.54 41.15,111.54 42.03,110.65 42.03,110.22 42.13,110.12 v2(42.33,110.12)
VMD_WCK23: length 25.5
  TOP w0.122: VRAM7.R11 21.75,116.17 21.75,115.31 21.59,115.15 v2(21.54,115.15) ; UG1.AD8 42.17,112.43 v2(42.17,112.39)
  IN2 w0.102: v2(21.54,115.15) 21.45,115.24 21.45,115.49 21.57,115.62 35.19,115.62 37.6,113.21 39.65,113.21 39.9,113.46 40.27,113.46 40.51,113.21 41.11,113.21 41.34,113.44 41.75,113.44 42.33,112.85 42.33,112.55 42.33,112.55 v2(42.17,112.39)
VMD_WCK23#: length 25.6
  TOP w0.122: v2(42.85,112.4) 42.73,112.4 42.6,112.52 42.6,112.69 UG1.AD9 ; v2(20.95,115.16) 20.99,115.16 21.38,115.56 VRAM7.R10
  IN2 w0.102: v2(42.85,112.4) 42.77,112.4 42.54,112.64 42.54,112.94 41.83,113.64 41.25,113.64 41.03,113.42 40.6,113.42 40.35,113.66 39.81,113.66 39.57,113.42 37.68,113.42 35.28,115.82 21.49,115.82 21.48,115.81 21.24,115.58 21.24,115.56 20.95,115.28 v2(20.95,115.16)
VMD_WCK45: length 25.1
  TOP w0.122: v2(21.76,130.7) VRAM5.D4 ; v2(40.07,122.84) 40.45,123.21 UG1.J6
  IN4 w0.114: v2(40.07,122.84) 40.31,122.84 40.42,122.95 40.42,123.15 40.34,123.23 39.79,123.23 39.68,123.12 39.68,122.96 39.59,122.87 39.39,122.87 39.03,123.22 38.16,123.22 38,123.05 37.52,123.05 37.31,123.27 37.31,123.81 36.88,124.24 36.37,124.24 36.28,124.15 34.51,124.15 30.23,128.42 25.48,128.42 24.45,129.45 23.45,129.45 22.62,130.28 21.57,130.28 21.47,130.38 21.47,130.53 21.64,130.7 v2(21.76,130.7)
VMD_WCK45#: length 25.1
  TOP w0.122: UG1.J7 41.12,123.25 40.82,122.94 v2(40.82,122.83) ; v2(21.02,130.69) 21.08,130.69 21.38,130.38 VRAM5.D5
  IN4 w0.114: v2(21.02,130.69) 21.25,130.46 21.25,130.29 21.48,130.06 22.53,130.06 23.36,129.23 24.34,129.23 25.38,128.2 30.14,128.2 34.4,123.93 36.36,123.93 36.46,124.02 36.79,124.02 37.09,123.72 37.09,123.18 37.43,122.84 38.09,122.84 38.25,123.01 38.94,123.01 39.08,122.87 39.13,122.81 39.3,122.65 39.66,122.65 39.83,122.47 40.46,122.47 v2(40.82,122.83)
VMD_WCK67: length 38.7
  TOP w0.122: v2(13.51,126.2) 13.4,126.2 13.13,125.93 VRAM5.R11 ; UG1.P8 42.13,120.08 v2(42.21,120.08)
  IN1 w0.114: v2(13.51,126.2) 13.35,126.36 13.35,126.59 13.75,126.99 13.75,127.28 14.67,128.2 17.81,128.2 18.05,127.96 18.05,127.38 18.34,127.08 18.34,126.68 18.1,126.44 18.1,123.61 19.17,122.54 27.35,122.54 27.61,122.29 29.07,120.82 34.5,120.82 34.93,120.38 37.35,120.38 37.74,120.78 38.69,120.78 39.11,121.19 39.58,121.19 39.82,120.95 40.2,120.95 40.58,120.58 40.58,120.14 41.17,119.55 41.6,119.55 42.14,120.08 v2(42.21,120.08)
VMD_WCK67#: length 38.6
  TOP w0.122: UG1.P7 41.55,120.09 41.55,120.09 v2(41.55,120.1) ; VRAM5.R10 13.13,126.53 v2(12.77,126.17)
  IN1 w0.102: 24.33,122.77 24.31,122.77 24.3,122.76
  IN1 w0.114: v2(12.77,126.17) 13.13,126.53 13.13,126.69 13.52,127.08 13.52,127.37 14.58,128.43 17.9,128.43 18.28,128.06 18.28,127.46 18.56,127.17 18.56,126.59 18.32,126.35 18.32,123.7 19.26,122.76 24.3,122.76 ; v2(41.55,120.1) 41.56,120.09 41.56,119.81 41.51,119.76 41.25,119.76 40.79,120.23 40.79,120.67 40.29,121.17 39.91,121.17 39.67,121.41 39.02,121.41 38.6,120.99 37.65,120.99 37.26,120.6 35.02,120.6 34.59,121.04 33.92,121.04 33.9,121.05 29.17,121.05 27.77,122.45 27.45,122.77 24.33,122.77
VMD_WCKB01: length 35.9
  TOP w0.122: UG1.AG8 42.12,110.92 42.15,110.92 v2(42.21,110.98) ; VRAM7.D11 12.95,116.35 v2(12.76,116.16)
  IN2 w0.102: v2(12.76,116.16) 12.76,116.11 12.55,115.91 12.45,115.91 12.19,115.65 12.19,115.02 13.96,113.26 17.1,113.26 17.43,113.58 19.06,113.58 19.99,114.51 24,114.51 24.18,114.69 35.12,114.69 37.12,112.68 39.09,112.68 39.15,112.74 39.66,112.74 39.87,112.53 40.38,112.53 40.61,112.76 40.97,112.76 41.77,111.96 41.77,111.59 42.21,111.14 v2(42.21,110.98)
VMD_WCKB01#: length 36
  TOP w0.122: UG1.AG9 42.57,110.65 42.86,110.94 v2(42.86,110.99) ; VRAM7.D10 12.94,115.59 v2(12.76,115.41)
  IN2 w0.102: v2(12.76,115.41) 12.76,115.64 12.69,115.7 12.53,115.7 12.4,115.56 12.4,115.11 14.05,113.46 17.02,113.46 17.34,113.78 18.97,113.78 19.9,114.71 23.91,114.71 24.1,114.89 35.2,114.89 37.21,112.89 39.01,112.89 39.06,112.94 39.75,112.94 39.96,112.73 40.29,112.73 40.53,112.97 41.06,112.97 41.97,112.05 41.97,111.67 42.3,111.35 42.47,111.35 42.83,110.99 v2(42.86,110.99)
VMD_WCKB23: length 33.5
  TOP w0.102: VRAM7.R4 21,111.67 v2(21,111.67)
  TOP w0.122: UG1.AC7 41.21,113.43 41.8,113.79 42.03,113.79 42.36,114.12 v2(42.36,114.16)
  IN2 w0.102: v2(42.36,114.16) 42.36,113.77 42.94,113.19 42.94,112.9 43.27,112.57 43.27,109.64 43.04,109.41 42.56,109.41 42.51,109.47 41.31,109.47 41.23,109.38 40.76,109.38 40.56,109.58 40.56,110.43 40.21,110.78 39.8,110.78 39.72,110.7 39.05,110.7 38.96,110.79 38.38,110.79 38.2,110.62 37.14,110.62 36.31,111.45 35.5,111.45 34.52,112.43 25.18,112.43 24.61,113.01 20.74,113.01 20.49,112.76 20.49,112.2 20.71,111.98 20.84,111.98 21,111.82 v2(21,111.67)
VMD_WCKB23#: length 33.6
  TOP w0.102: v2(21.1,112.45) 21.41,112.45 21.51,112.35 21.51,112.16 VRAM7.R5
  TOP w0.122: UG1.AC8 42.15,113.6 42.34,113.79 42.78,113.79 42.8,113.77 v2(42.9,113.77)
  IN2 w0.102: v2(42.9,113.77) 42.9,113.81 43.09,114 43.31,114 43.45,113.86 43.45,113.62 43.34,113.5 43.2,113.5 43.14,113.44 43.14,112.99 43.47,112.66 43.47,109.55 43.13,109.21 42.48,109.21 42.43,109.26 41.39,109.26 41.31,109.18 40.67,109.18 40.36,109.5 40.36,110.34 40.12,110.58 39.88,110.58 39.82,110.51 38.96,110.51 38.88,110.59 38.46,110.59 38.29,110.41 37.06,110.41 36.22,111.25 35.41,111.25 34.43,112.23 25.1,112.23 24.52,112.8 20.82,112.8 20.7,112.68 20.7,112.28 20.8,112.18 20.9,112.18 21,112.28 21,112.35 v2(21.1,112.45)
VMD_WCKB45: length 23.6
  TOP w0.122: v2(41.46,123.61) 41.15,123.91 UG1.H7 ; v2(21.76,126.2) VRAM5.D11
  IN2 w0.102: v2(41.46,123.61) 41.06,124 40.69,124 40.43,124.26 40.43,124.48 40.24,124.67 39.86,124.67 39.63,124.43 39.1,124.43 38.58,124.95 37.03,124.95 36.7,125.28 36.7,125.47 36.03,126.14 34.73,126.14 34.31,126.56 26.49,126.56 25.59,127.46 22.46,127.46 22.32,127.32 22.32,126.76 22.05,126.49 22.04,126.49 v2(21.76,126.2)
VMD_WCKB45#: length 23.7
  TOP w0.102: VRAM5.D10 21.53,126.58 21.75,126.81 v2(21.75,126.99)
  TOP w0.122: v2(40.84,124.36) 40.83,124.36 40.83,123.83 40.74,123.74 40.57,123.74 40.45,123.87 UG1.H6
  IN2 w0.102: v2(21.75,126.99) 21.68,126.91 21.68,126.74 21.76,126.66 21.94,126.66 22.12,126.85 22.12,127.41 22.37,127.66 25.68,127.66 26.58,126.76 34.4,126.76 34.82,126.34 36.12,126.34 36.9,125.55 36.9,125.36 37.11,125.15 38.66,125.15 39.18,124.63 39.54,124.63 39.78,124.87 40.33,124.87 40.64,124.56 40.64,124.46 40.74,124.36 40.84,124.36 v2(40.84,124.36)
VMD_WCKB67: length 43
  TOP w0.122: v2(41.55,120.8) 41.53,120.82 41.53,120.82 UG1.M7 ; VRAM5.R4 v2(12.76,130.7)
  IN2 w0.102: v2(41.55,120.8) 41.55,120.8 41.4,120.95 41.1,120.95 40.87,120.72 40.37,120.72 40.16,120.93 39.78,120.93 39.52,121.19 37.59,121.19 36.69,122.09 35.91,122.09 35.66,122.34 30.11,122.34 29.83,122.62 29.83,123.21 29.73,123.31 29.32,123.31 29.22,123.21 29.22,122.78 29,122.56 28.43,122.56 28.21,122.78 28.21,123.21 28.1,123.31 27.7,123.31 27.6,123.21 27.6,122.78 27.38,122.56 26.8,122.56 26.58,122.78 26.58,123.21 26.48,123.31 26.07,123.31 25.97,123.21 25.97,122.82 25.75,122.59 19.28,122.59 18.11,123.77 18.11,125.02 19.17,126.08 19.17,126.61 19.07,126.71 19.07,127.7 18.78,127.99 18.08,127.99 17.95,128.12 13.6,128.12 12.09,129.63 12.09,130.14 12.36,130.41 12.68,130.41 12.76,130.49 v2(12.76,130.7)
VMD_WCKB67#: length 43.1
  TOP w0.122: UG1.M8 42.18,120.86 v2(42.2,120.84) ; v2(12.78,129.92) 13.13,130.28 VRAM5.R5
  IN2 w0.102: v2(42.2,120.84) 42.01,120.84 41.7,121.15 41.02,121.15 40.79,120.93 40.45,120.93 40.24,121.14 39.86,121.14 39.61,121.39 37.68,121.39 36.77,122.29 35.99,122.29 35.75,122.54 30.2,122.54 30.03,122.7 30.03,123.29 29.81,123.51 29.24,123.51 29.02,123.29 29.02,122.87 28.92,122.77 28.51,122.77 28.41,122.87 28.41,123.29 28.19,123.51 27.61,123.51 27.39,123.29 27.39,122.87 27.29,122.77 26.88,122.77 26.78,122.87 26.78,123.29 26.56,123.51 25.99,123.51 25.77,123.29 25.77,122.9 25.67,122.8 19.37,122.8 18.31,123.85 18.31,124.94 19.37,126 19.37,126.69 19.27,126.79 19.27,127.79 18.87,128.19 18.17,128.19 18.03,128.32 13.69,128.32 12.3,129.71 12.3,130.06 12.45,130.21 12.69,130.21 12.78,130.12 v2(12.78,129.92)
VR_SVID_ALERT#: length 53.6
  TOP w0.14: PR17.2 179.85,172.98 179.89,173.01 v1(179.89,173.51) ; v1(168.5,133.11) 168.5,133.53 167.52,134.5 C48.1 167.27,134.92 165.76,134.92 165.49,134.65 R36.1 R35.2
  IN4 w0.086: v1(179.89,173.51) 179.97,173.42 179.97,164.01 180.45,163.53 180.45,156.51 177.18,153.24 177.18,151.83 175.44,150.09 174.72,150.09 173.35,148.71 173.35,145.83 172.11,144.6 172.11,136.36 168.87,133.11 v1(168.5,133.11)
  BOTTOM w0.14: v1(179.89,173.51) 179.67,173.29 PR435.2
VR_SVID_CLK: length 51.3
  TOP w0.14: v1(179.17,173.61) 179.17,173.13 PR13.1 ; v1(167.52,133.74) 167.46,133.8 166.02,133.8 R39.2 R38.2
  IN4 w0.086: v1(179.17,173.61) 179.17,173.58 179.5,173.24 179.5,163.41 179.98,162.93 179.98,156.71 176.71,153.44 176.71,152.02 175.25,150.56 174.53,150.56 172.88,148.91 172.88,146.02 171.65,144.79 171.65,136.55 168.99,133.9 167.68,133.9 v1(167.52,133.74)
  BOTTOM w0.14: PR431.2 178.69,173.13 v1(179.17,173.61)
VR_SVID_CLK_R: length 11.5
  TOP w0.114: v1(155.64,127.3) 155.53,127.3 155.26,127.56 U3.BH32
  TOP w0.14: R38.1 163.48,133.49 v1(162.55,133.49)
  IN2 w0.089: v1(155.64,127.3) 156.03,127.3 159.31,130.58 160.05,130.58 162.55,133.09 v1(162.55,133.49)
VR_SVID_DATA: length 53.1
  TOP w0.14: v1(167.68,132.55) 167.58,132.66 165.03,132.66 R41.2 ; v1(180.56,173.68) 180.56,173.15 PR14.2
  IN4 w0.086: v1(180.56,173.68) 180.43,173.55 180.43,164.2 180.92,163.72 180.92,156.32 177.64,153.05 177.64,151.63 175.63,149.62 174.92,149.62 173.81,148.52 173.81,145.64 172.62,144.44 172.62,136.2 168.97,132.55 v1(167.68,132.55)
  BOTTOM w0.14: PR434.2 180.59,172.97 180.59,173.65 v1(180.56,173.68)
VRON: length 276.2
  TOP w0.14: U18.69 86.33,22.62 86.52,22.81 89.32,22.81 R429.1 89.62,23.02 90.04,23.44 v1(90.19,23.44)
  IN3 w0.089: v1(177.8,59.41) 177.8,59.41 177.8,61.05 177.11,61.74 177.11,63.69 173.15,67.65 173.15,81.35 172.73,81.77 172.73,84.4 174.63,86.31 174.63,89.49 175.27,90.12 175.27,93.95 175.36,94.04 175.36,102.35 174.18,103.53 174.18,121 169.82,125.37 169.82,126.86 170.43,127.48 170.43,130.14 171.17,130.88 171.17,135.4 173.39,137.62 173.39,145.33 174.64,146.58 174.64,149.63 178.11,153.1 178.11,157.5 179.08,158.46 179.08,159.18 180.57,160.67 180.57,170.23 180.91,170.57 180.93,170.57 v1(180.94,170.58)
  IN4 w0.086: v1(177.8,59.41) 177.56,59.16 176.3,59.16 174.6,60.86 172.98,60.86 162.86,70.98 117.15,70.98 114.35,68.18 110.09,68.18 109.81,68.46 102.92,68.46 99.21,64.75 98.38,64.75 97.87,64.24 96.42,62.8 96.42,59.84 94.93,58.34 94.93,57.54 89.67,52.28 87.44,52.28 85.84,50.69 85.84,49.13 83.54,46.82 83.54,43.97 v1(83.43,43.86)
  BOTTOM w0.14: v1(83.43,43.86) 83.61,44.05 86.21,44.05 86.41,43.84 86.75,43.84 87.93,42.66 87.93,42.3 88.24,42 88.24,41.36 90.19,39.41 90.19,39.19 91.24,38.14 91.56,38.14 93.39,36.31 93.39,35.26 94.38,34.27 v1(94.38,33.94) 94.86,33.47 95.18,33.47 95.92,32.73 95.92,31.82 94.37,30.28 92.2,30.28 91.23,29.31 91.23,28.36 91.59,28 91.59,27.6 91.84,27.35 91.84,25.97 91.61,25.74 91.6,25.74 91.29,25.42 91.29,25.42 90.34,24.47 90.34,24.25 90.19,24.09 v1(90.19,23.44) ; PR438.2 180.14,170.35 180.37,170.57 180.93,170.57 v1(180.94,170.58)
VSN_1PH: length 3.5
  TOP w0.203: PU2.51 174.83,169.96 174.07,170.71 174.07,171.26 173.62,171.71 PC12.2 PR15.2
VSN_4PH_A: length 3.9
  TOP w0.203: PC14.2 PR23.2 171.84,170.25 172.52,169.57 v1(172.66,169.57) 172.75,169.48 172.75,168.9 173.14,168.51 PU2.2
VSP_1PH: length 4.9
  TOP w0.191: PU2.52 174.43,169.88 174.09,170.22 174.08,170.22
  TOP w0.203: v1(171.85,171.72) 171.87,171.7 PC11.2 172.54,171.5 172.67,171.36 173.2,171.36 173.73,170.84 173.73,170.57 174.08,170.22
  BOTTOM w0.203: PR437.2 172.02,171.89 v1(171.85,171.72)
VSP_4PH_A: length 82.6
  TOP w0.191: PU2.1 173.39,168.91 173.19,169.12
  TOP w0.203: 173.19,169.12 173.19,169.97 v1(173.09,170.07) 172.91,170.25 PC15.2 ; v1(132.42,137) 132.36,137.06 PR129.2
  IN4 w0.203: v1(173.09,170.07) 177.62,170.07 178.5,169.18 178.5,162.73 178.68,162.55 178.68,159.29 174.23,154.83 174.23,152.68 172.05,150.5 172.05,146.37 169.67,143.99 169.67,138.34 167.41,136.09 132.55,136.09 132.2,136.44 132.2,136.78 v1(132.42,137)
VSTBY_FSPI: length 3.1
  TOP w0.381: R221.2 82.42,40.67 82.42,40.32 R235.2 81.46,39.36 R236.2
WIGIG_LED: length 2.2
  BOTTOM w0.14: CN16.6 48.82,34 TP91.1
WLAN_CLKREQ#: length 9.9
  TOP w0.14: v1(53.81,42.34) 54.13,42.01 54.13,40.99 53.83,40.69 Q28.1 52.58,40.69 R220.1
  BOTTOM w0.14: v1(53.81,42.34) 54.14,42.67 54.14,44.28 54.5,44.64 54.5,45.38 55.1,45.99 56.4,45.99 56.64,45.75 CN16.53
WLAN_RST#: length 3.8
  TOP w0.14: v1(51.14,45.15) 50.36,45.15 49.41,44.2 R200.1
  BOTTOM w0.14: CN16.52 50.79,45.5 v1(51.14,45.15)
WLAN_WAKE_R#: length 12.6
  TOP w0.14: v1(51.1,42.37) 51.83,42.37 R204.1 52.97,43.51 52.97,43.87 53.47,44.37 Q26.1
  BOTTOM w0.14: CN16.55 54.99,46.25 54.24,45.5 54.24,44.83 51.77,42.37 v1(51.1,42.37)
WLANPWR#: length 39.6
  TOP w0.14: U18.83 84.11,28.22 83.36,28.97 v1(83.36,29.25) ; R300.2 54.45,34.79 54.99,34.25 v1(54.99,33.6)
  IN2 w0.089: v1(54.99,33.6) 54.99,33.07 56.01,32.05 56.01,30.93 57.66,29.28 59.12,29.28 59.23,29.17 60.9,29.17 61.2,29.47 61.42,29.47 61.72,29.17 63.52,29.17 63.93,28.76 64.47,28.76 64.72,28.51 65.16,28.51 67.16,26.51 67.63,26.51 69.16,24.97 71.99,24.97 72.9,25.88 72.9,27.15 73.5,27.76 79.77,27.76 80.5,28.49 82.59,28.49 v1(83.36,29.25)
WOOFER_SPK: length 7.3
  TOP w0.203: v1(25.72,30.49) 25.85,30.37 26.79,30.37 26.8,30.36 U17.20
  BOTTOM w0.381: C864.2 23.15,27.5 23.59,27.5 23.92,27.83 v1(23.92,28.66) 23.92,29.18 25.19,30.45 25.21,30.45 25.25,30.49 v1(25.72,30.49)
WP#_3: length 5.8
  TOP w0.14: UG2.3 54.01,81.59 53.66,81.93 53.66,83.13 54.2,83.66 55.27,83.66 v1(55.46,83.84) 55.75,84.14 RG48.2
WRST#: length 56.9
  TOP w0.14: v1(86.12,43.45) 86.12,42.96 86.33,42.75 86.33,42.12 86.56,41.9 87.81,41.9 90.12,39.59 90.12,38.38 90.56,37.94 91.57,37.94 92.37,37.14 92.6,37.14 93.42,36.32 Q30.6 ; R287.1 62.11,35.8 61.59,35.28 61.59,34.93 61.28,34.62 C282.1 62.05,34.46 D44.2 62.73,34.19 62.73,32.9 61.87,32.04 61.87,30.73 62.19,30.41 62.98,30.41 63.39,30.83 66.49,30.83 66.69,30.62 66.69,30.04 66.62,29.96 66.62,29.77 66.92,29.47 66.92,29.14 67.84,28.22 U18.14 70.49,28.22 70.99,28.72 73.86,28.72 v1(74.71,29.57)
  BOTTOM w0.14: v1(86.12,43.45) 85.87,43.7 84.98,43.7 82.98,41.71 82.98,41.24 82.07,40.33 82.07,38.57 82.37,38.27 82.37,36.24 79.59,33.46 79.59,32.61 77.66,30.68 76.46,30.68 75.35,29.57 v1(74.71,29.57)
XCLK_RBIAS: length 6.8
  TOP w0.14: U14.T3 204.37,38.82 203.93,38.82 203.74,38.62 203.42,38.62 203.4,38.6 201.34,38.6 200.38,39.56 200.38,40.1 199.36,41.12 R218.2
XDP_BPM0: length 6.5
  TOP w0.089: TP7.1 162.99,120.77 v1(162.71,121.05)
  TOP w0.114: U3.BR27 159.92,123.58 160.36,123.58 160.4,123.54 161.08,123.54 v1(161.48,123.93)
  IN2 w0.102: v1(162.71,121.05) 161.64,122.12 161.64,123.77 v1(161.48,123.93)
XDP_BPM1: length 7.5
  TOP w0.089: v1(163.75,119.47) 163.8,119.42 TP8.1
  TOP w0.114: v1(160.83,123.94) U3.BT27
  IN2 w0.102: v1(160.83,123.94) 161.38,123.38 161.38,121.02 162.93,119.47 v1(163.75,119.47)
XDP_BPM2: length 9.9
  TOP w0.079: 161.46,126.87 161.35,126.75 157.94,126.75 U3.BM31
  TOP w0.089: 161.46,126.87 161.71,127.12 164.36,127.12 164.59,127.35 165.24,127.35 165.37,127.48
  TOP w0.14: TP4.1 166.41,128.52 165.37,127.48
XDP_BPM3: length 6.7
  TOP w0.114: U3.BT30 160.24,126.32 161.21,126.32 161.63,125.9 163.74,125.9 164,126.17 164.75,126.17 165.03,126.45
  TOP w0.14: 165.03,126.45 166,127.42 TP5.1
XDP_DBRESET#: length 66.9
  TOP w0.102: U14.AU2 204.08,28.35 203.44,29 202.75,29 v1(202.36,28.61)
  TOP w0.14: CN5.13 230.11,15.25 230.47,15.61 v1(230.47,15.71)
  IN4 w0.086: v1(202.36,28.61) 201.51,27.76 200.99,27.76 199.82,26.6 199.82,25.91 199.02,25.11 198.24,25.11 197.65,24.52 197.65,23.1 198.02,22.73 199.06,22.73 200.56,21.23 201.35,21.23 201.72,20.86 207.37,20.86 209.81,23.3 214.04,23.3 214.45,22.9 214.45,21.17 215.75,19.87 219.07,19.87 219.45,20.24 223.99,20.24 224.37,19.87 232.04,19.87 232.66,19.24 234.03,19.24 234.74,19.96 235.5,19.96 236.21,19.24 236.21,17.87 235.74,17.4 235.74,15.27 235.02,14.55 231.64,14.55 v1(230.47,15.71)
  BOTTOM w0.102: v1(202.36,28.61) 201.85,28.1 R935.1
XTAL24_IN: length 8.3
  TOP w0.14: v1(207.56,37.43) 207.89,37.76 U14.U10
  BOTTOM w0.14: R820.2 203.62,42.91 203.67,42.85 L32.3 203.67,42.19 203.87,41.98 203.97,41.98 207.56,38.39 v1(207.56,37.43)
XTAL24_IN_L: length 5.8
  BOTTOM w0.14: R820.1 203.62,44.18 L32.4 203.67,45.49 203.13,46.03 R814.1 202.76,46.03 202.1,46.7 C771.2 201.49,46.7 201.07,46.28 Y5.1
XTAL24_OUT: length 7.8
  TOP w0.14: v1(206.98,37.76) 207.25,37.76 U14.U9
  BOTTOM w0.14: R821.2 202.91,42.84 202.87,42.81 L32.2 202.87,42.25 203.66,41.46 203.76,41.46 206.98,38.24 v1(206.98,37.76)
XTAL24_OUT_L: length 6.4
  BOTTOM w0.14: Y5.3 199.39,45.44 199.53,45.58 201,45.58 201.14,45.72 201.62,45.72 C778.2 202.25,45.39 202.44,45.58 R814.2 202.96,44.84 202.87,44.75 L32.1 202.87,43.69 R821.1
XTALOUT_RC: length 2.3
  TOP w0.14: RG41.2 33.92,87.4 34.13,87.19 34.13,87.01 33.87,86.75 CG77.1 33.55,86.75 33.42,86.88 33.42,87.04 33.28,87.18 33.04,87.18 RG44.1
XTALOUTBUFF: length 11.1
  TOP w0.102: v2(40.54,92.3) 40.54,92.52 41.03,93.01 41.03,93.42 40.77,93.68 40.77,94.23 UG1.BK6
  BOTTOM w0.14: v2(40.54,92.3) 39.92,91.69 39.36,91.69 39.08,91.41 39.08,90.53 38.94,90.39 38.04,90.39 37.74,90.69 37.74,91.71 38.8,92.78 39.92,92.78 RG167.2
XTALSSIN: length 11.1
  TOP w0.102: UG1.BJ6 40.13,94.93 40.13,93.1 39.88,92.84 39.46,92.84 38.53,91.91 36.82,91.91 36.59,92.14 35.99,92.14 35.85,92
  TOP w0.14: 35.85,92 34.77,90.93 33.26,90.93 RG37.1
N16787949: length 2.2
  BOTTOM w0.14: R939.1 63.36,27.19 63.85,26.7 v1(63.85,26.3) 63.72,26.16 C866.2
N16788300: length 3.8
  TOP w0.14: C334.1 67.02,31.31 67.02,30.66 67.84,29.85 67.84,29.68 68.5,29.02 U18.12
N16788450: length 2.9
  TOP w0.14: U18.3 68.28,32.62 v1(68,32.9) 68,33.25 67.27,33.99 R326.1
N16788484: length 4.5
  TOP w0.14: R450.2 87.61,21.38 C426.1 86.97,21.06 86.39,21.06 86.02,21.42 U18.66
N16788554: length 4.8
  TOP w0.14: U18.82 85.84,27.82 86.1,28.08 86.54,28.08 87.13,28.67 C344.2 87.61,29.61 88.52,29.61 R374.2
N16788625: length 6.1
  TOP w0.14: U18.98 83.03,36.25 82.95,36.34 82.95,37.37 C253.1 83.94,38.36 v1(83.94,38.83) 83.94,39.7 R227.1
N17045084: length 3.5
  TOP w0.14: R297.1 67.09,34.67 67.27,34.5 67.6,34.5 67.73,34.36 67.73,33.92 68.64,33.02 U18.2
N17045098: length 2.2
  TOP w0.14: U18.128 70.2,35.07 C275.1 70.13,35.18 69.67,35.64 69.67,35.72 R284.2
N17086720: length 3.7
  BOTTOM w0.14: UG7.4 48.26,84.89 48.15,85.01 47.77,85.01 47.64,84.87 47.64,84.65 47.14,84.16 RG177.2 RG182.2
N17086723: length 3.6
  BOTTOM w0.14: UG7.5 49.56,84.83 49.7,84.97 50.07,84.97 50.68,84.36 CG893.2 RG181.1
N17327231: length 1.3
  TOP w0.14: R55.1 113.23,129.62 112.94,129.9 Q5.2
N17914278: length 114.4
  TOP w0.203: v1(171.65,173.49) 171.9,173.49 172.2,173.19 PC6.1 172.72,173.19 173.17,172.73 PR15.1 PC12.1 ; v1(128.7,143.12) 128.57,143 PR119.2
  IN4 w0.203: v1(171.65,173.49) 171.8,173.49 172.3,173 172.9,173 174.64,174.74 181.29,174.74 182.19,173.84 182.19,156.42 178.5,152.73 178.5,150.33 176.85,148.68 175.15,148.68 174.64,148.17 174.64,145.29 173.45,144.1 173.45,133.42 172.38,132.35 171.01,132.35 170.33,131.66 166.82,131.66 163.37,135.12 131.19,135.12 128.65,137.66 128.65,138.9 128.36,139.18 128.36,141.7 128.01,142.05 128.01,142.43 v1(128.7,143.12)
N17914320: length 111.3
  TOP w0.203: PR121.2 128.52,142.38 v1(128.67,142.23) ; v1(171.62,172.84) 171.88,172.84 171.98,172.74 PC6.2 PC11.1
  IN4 w0.203: v1(128.67,142.23) 128.67,139.31 128.95,139.03 128.95,137.79 131.32,135.43 163.49,135.43 166.95,131.97 170.2,131.97 170.88,132.66 172.26,132.66 173.15,133.54 173.15,144.22 174.34,145.42 174.34,148.3 175.03,148.99 176.73,148.99 178.19,150.45 178.19,152.85 181.88,156.54 181.88,173.72 181.16,174.44 174.77,174.44 173.03,172.69 172.61,172.69 171.77,172.69 v1(171.62,172.84)
  BOTTOM w0.203: v1(171.62,172.84) 171.79,172.67 PR437.1
N17914416: length 3.2
  TOP w0.203: PU2.24 178.43,162.94 178.76,162.61 178.76,162.2 v1(178.8,162.15) 179.08,161.88 PR71.2 179.08,161.01 178.98,160.91 PR75.1
N17914428: length 7
  TOP w0.203: PC68.2 175.43,160.88 174.77,161.54 v1(174.77,161.74) 174.77,162.3 175.23,162.75 PU2.16
  BOTTOM w0.203: PR458.1 174.85,161.66 v1(174.77,161.74) v1(174.77,162.89) 174.77,163.96 174.8,163.99 PR454.1
N17914498: length 6.1
  TOP w0.203: v1(172.05,169.33) 172.4,168.98 172.4,168.76 173.05,168.11 PU2.3
  BOTTOM w0.203: v1(172.05,169.33) 172.56,169.33 174.08,167.82 PR443.2 PC299.2
N17914678: length 2.1
  TOP w0.191: PU2.39 180.45,168.91
  TOP w0.203: PR25.1 181.54,169.75 181.07,169.28 v1(180.89,169.28) 180.52,168.91 180.45,168.91
N17914704: length 4.4
  BOTTOM w0.203: PR431.1 179.42,172.35 PR435.1 PR434.1 181.34,172.09 PC295.1 181.88,172.23 PR433.1
N17915153: length 14.1
  TOP w0.203: PR9.1 172.49,174.31 172.89,174.71 177.39,174.71 v1(177.57,174.54) 178.01,174.1 PC4.2 PC9.1 177.46,172.14 176.28,172.14 v1(175.76,171.62) 175.76,171.4 176.14,171.02 176.43,170.73 PU2.47
  BOTTOM w0.203: v1(175.76,171.62) 176.53,172.38 PR432.1
N17915219: length 3.8
  TOP w0.203: v1(176.93,170.93) 176.83,170.83 PU2.46
  BOTTOM w0.203: PR440.2 PC298.2 177.06,170.81 v1(176.93,170.93)
N17915331: length 4.3
  TOP w0.203: PC67.2 174.12,161.28 v1(174.12,161.77) 174.26,161.91 174.26,162.3 174.83,162.87 PU2.15
  BOTTOM w0.203: v1(174.12,161.77) 173.6,161.25 PR457.1
N17915365: length 3.7
  TOP w0.203: v1(178.18,162.41) 178.18,162.51 177.63,163.06 PU2.22
  BOTTOM w0.203: v1(178.18,162.41) 178.75,162.98 v1(178.75,163.44) 178.2,163.99 PR452.2
N17915469: length 82
  TOP w0.203: PR114.1 119.38,148.35 v1(119.57,148.54)
  IN4 w0.203: v1(119.57,148.54) 119.87,148.25 120.67,148.25 121.35,147.57 125.27,147.57 126.46,148.76 126.46,156.53 126.28,156.71 126.28,163.67 128.34,165.73 134.41,165.73 136.47,167.78 138.52,167.78 142.51,171.77 144.31,171.77 147.08,174.54 169.06,174.54 170.58,173.02 170.58,172.25 171.66,171.18 172.32,171.18 173.03,171.89 173.84,171.89 174.77,172.81 176.47,172.81 176.68,173.02 176.68,173.27 v1(176.6,173.35)
  BOTTOM w0.203: PR432.2 176.65,173.3 v1(176.6,173.35)
N17915487: length 7.3
  TOP w0.203: v1(169.13,158.35) 169.05,158.35 168.85,158.55 PR78.2 ; 172.29,160.29 172.29,159.55 172.69,159.14 v1(172.69,158.64) ; 172.29,160.29 PR77.1 ; 172.29,160.29 PR72.2
  IN1 w0.203: v1(169.13,158.35) 169.23,158.45 172.5,158.45 v1(172.69,158.64)
N17915542: length 4
  TOP w0.203: v1(175.03,170.94) 175.63,170.34 PU2.49
  BOTTOM w0.203: PC296.2 174.83,169.89 PR441.2 175.08,170.46 175.03,170.5 v1(175.03,170.94)
N17915544: length 0.9
  TOP w0.203: PC7.1 174.82,173.45 PR10.2
N17915546: length 5
  TOP w0.203: PU2.50 175.23,170.04 174.44,170.83 174.44,171.81 174.62,171.99 PC7.2 174.07,172.47 173.97,172.57 173.97,172.9 173.62,173.25 PC5.2
N17915609: length 3.2
  TOP w0.203: v1(177.38,171.4) 177.43,171.35 177.43,170.73 177.23,170.53 PU2.45
  BOTTOM w0.203: v1(177.38,171.4) 177.38,171.71 177.76,172.1 PR436.1
N17915654: length 3.1
  TOP w0.203: PU2.43 178.03,170.28 178.57,170.82 v1(178.57,170.95)
  BOTTOM w0.203: PC297.2 178.99,169.82 178.91,169.89 PR438.1 178.57,170.7 v1(178.57,170.95)
N17915810: length 4.8
  TOP w0.203: PU2.48 176.03,170.65 v1(175.02,171.65) 175.69,172.31 PC8.2
  BOTTOM w0.203: v1(175.02,171.65) 175.74,172.36 PR430.2
N17915949: length 1
  TOP w0.203: PR29.2 169.65,169.58 169.85,169.38 PC18.1
N17916003: length 2.4
  TOP w0.203: PC22.2 169.38,168.23 168.55,167.4 v1(168.55,167.3) 168.67,167.17 169.22,167.17 PR33.2
N17916033: length 84.1
  TOP w0.203: PR128.2 131.79,137.05 v1(131.77,137.02) ; v1(173.09,170.78) 173.01,170.7 PC15.1 172.49,170.7 PR23.1 PC14.1
  IN4 w0.203: v1(131.77,137.02) 131.87,136.92 131.87,136.31 132.4,135.78 167.54,135.78 169.97,138.22 169.97,143.86 172.35,146.24 172.35,150.37 174.53,152.55 174.53,154.71 178.99,159.17 178.99,163.06 178.81,163.24 178.81,169.31 177.64,170.48 173.39,170.48 v1(173.09,170.78)
N17916345: length 24.1
  TOP w0.203: v1(171.1,146.99) 171.2,146.99 172.16,146.03 PR117.1 ; v1(168.17,164.88) 168.37,165.08 168.37,165.32 168.36,165.33 PR49.2 168.36,165.97 PR40.2
  IN3 w0.203: v1(168.17,164.88) 168.26,164.88 168.53,164.62 168.87,164.62 169.62,163.86 169.62,158.79 171.85,156.57 171.85,147.29 171.56,146.99 v1(171.1,146.99)
N17988049: length 1
  BOTTOM w0.14: C694.2 R727.2
N17989426: length 0.9
  TOP w0.508: C151.2 R151.1
N18332322: length 3.4
  TOP w0.102: U14.BE33 219.5,24.15 219.69,23.95 219.69,23.55 219.56,23.42 219.56,22.98 219.9,22.64 v1(219.92,22.64)
  BOTTOM w0.102: v1(219.92,22.64) 220.1,22.64 220.52,22.23 220.52,21.52 TP118.1
N18828625: length 2.4
  TOP w0.203: PU4.1 166.83,163.76 167.18,164.1 v1(167.53,164.1) 167.81,163.82 PR60.2
N18828828: length 2.5
  TOP w0.203: PU6.1 155.94,163.71 156.38,164.15 v1(156.89,164.15) 157.05,164 PR59.2
N18847325:
  vias: v1(168.2,157.6) v3(166.95,158.28)
N18849314: length 1.9
  TOP w0.203: PR42.1 164.18,164.87 PU4.5
N18849316: length 2.1
  TOP w0.203: PU4.7 163.18,164.44 162.2,165.43 PC31.2
N18849320: length 1.4
  TOP w0.203: PR42.2 PC31.1
N18865779: length 10.6
  TOP w0.203: v1(167.51,165.67) 167.33,165.49 PR52.1 166.9,165.84 166.72,166.01 PR47.2 165.95,166.01 165.54,166.43 165.54,166.44 165.26,166.71 PR37.1 ; v1(168.69,161.57) PC63.1 168.03,161.57 167.49,162.11 PU4.29
  IN1 w0.203: v1(167.51,165.67) 167.51,165.46 167.28,165.23 167.28,162.35 168.06,161.57 v1(168.69,161.57)
N18869413: length 2.1
  TOP w0.203: PR52.2 166.9,164.68 166.54,164.33 165.96,164.33 165.68,164.06 PU4.2
N18873454: length 2.6
  TOP w0.203: PR50.1 PC41.1 154.41,164.87 PU6.3
N18873473: length 9.4
  TOP w0.203: PR38.1 154.54,166.51 154.69,166.36 154.69,166.35 155.1,165.94 PR50.2 155.77,165.94 155.95,165.76 PR54.1 v1(156.53,165.42) ; v1(157.92,161.77) PC62.1 156.64,161.77 156.36,162.06 PU6.29
  IN1 w0.203: v1(157.92,161.77) 157.67,161.77 156.53,162.91 v1(156.53,165.42)
N18873491: length 2
  TOP w0.203: PR54.2 155.95,164.58 155.75,164.38 155.29,164.38 154.91,164.01 PU6.2
N18875415:
  vias: v1(156.71,158.35) v3(156.03,158.18)
N18875431: length 12.4
  TOP w0.203: PR81.1 158.6,157.08 159.4,156.28 159.4,152.19 157.88,150.66 155.19,150.66 154.5,149.98 PR112.1
N18875461: length 2
  TOP w0.203: PC34.2 151.5,165.35 152.41,164.44 PU6.7
N18875463: length 1.4
  TOP w0.203: PR44.2 PC34.1
N18875958: length 1.8
  TOP w0.203: PU6.5 153.41,164.2 152.93,164.68 PR44.1
N18877550: length 2.5
  TOP w0.203: PR48.1 PC40.1 144.32,164.73 144.46,164.59 PU3.3
N18877577: length 10.4
  TOP w0.203: v1(148.23,161.23) 148.01,161.23 PC60.1 146.71,161.87 146.4,162.18 PU3.29 ; PR36.1 145.34,166.49 145.36,166.47 PR48.2 146.12,165.99 146.3,165.81 PR53.1 146.73,165.47 v1(146.88,165.32)
  IN2 w0.203: v1(148.23,161.23) 147.82,161.23 147.47,161.59 147.47,164.73 v1(146.88,165.32)
N18877595: length 2.2
  TOP w0.203: PR53.2 146.21,165.02 145.8,164.61 145.15,164.61 144.96,164.41 PU3.2
N18877670:
  vias: v1(146.2,157.97) v3(145.43,158.23)
N18877682: length 11.5
  TOP w0.203: PR83.1 147.82,152.62 146.02,150.82 143.83,150.82 143.38,150.36 PR113.1
N18877704: length 1.9
  TOP w0.203: PC32.2 141.6,165.4 142.46,164.54 PU3.7
N18877706: length 1.4
  TOP w0.203: PC32.1 PR43.2
N18877926: length 1.8
  TOP w0.203: PR43.1 143.02,164.94 143.46,164.5 PU3.5
N18877936: length 1
  TOP w0.203: PU3.30 146.7,162.68 146.77,162.75 PR63.2
N18877948: length 1.8
  TOP w0.203: PR58.2 146.77,163.52 146.45,163.83 PU3.1
N18879612: length 2.3
  TOP w0.203: PU5.3 134.02,164.51 134.03,164.52 PC42.1 PR51.1
N18879633: length 9.1
  TOP w0.203: PR39.1 135.73,165.81 PR51.2 135.41,165.45 135.78,165.45 PR55.1 v1(137.17,165.27) 137.89,164.54 137.89,162.73 136.93,161.77 PC61.1 136.25,161.77 135.96,162.06 PU5.29
N18879659: length 2.3
  TOP w0.203: PU5.2 134.52,164.25 134.67,164.41 135.76,164.41 135.96,164.61 PR55.2
N18879722:
  vias: v1(135.35,157.57) v3(134.74,158.06)
N18879742: length 11.9
  TOP w0.203: PR110.1 132.17,150.13 132.61,150.56 135.07,150.56 137.05,152.54 PR82.1
N18879764: length 1.8
  TOP w0.203: PU5.7 132.02,164.57 131.34,165.25 PC37.2
N18879766: length 1.4
  TOP w0.203: PC37.1 PR46.2
N18879983: length 1.7
  TOP w0.203: PU5.5 133.02,164.34 132.76,164.6 PR46.1
N18879988: length 1.1
  TOP w0.203: PR64.2 136.38,162.7 136.24,162.56 PU5.30
N18879992: length 1.9
  TOP w0.203: PR57.2 136.34,163.37 136,163.71 PU5.1
N18886111: length 1.2
  TOP w0.203: PR89.2 114.75,154.91 PU8.30
N18886117:
  vias: v1(118.72,155.12) v3(119.68,154.27)
N18886141: length 11
  TOP w0.203: PR108.1 123.39,151.27 125.39,151.27 126.51,152.39 126.51,156.2 v1(125.63,157.08) 125.27,157.45 124.85,157.45 PR79.1
N18886171: length 1.8
  TOP w0.203: PR106.1 112.15,150.64 112.73,151.22 112.85,151.22 113.01,151.38 PU8.5
N18886173: length 2.3
  TOP w0.203: PC85.2 112.57,149.19 112.82,149.44 112.82,150.11 113.09,150.38 PU8.7
N18886175: length 1.4
  TOP w0.203: PC85.1 PR106.2
N18886322: length 2.6
  TOP w0.203: PR100.1 PC82.1 112.6,152.16 112.82,152.38 PU8.3
N18886341: length 8.8
  TOP w0.203: PU8.29 115.25,154.69 115.4,154.85 PC78.1 PR86.1 114.87,156.35 114.65,156.57 v1(113.56,156.57) 113.26,156.57 111.34,154.64 PR100.2
N18886385: length 1.8
  TOP w0.203: PR90.2 113.81,153.99 113.6,153.77 PU8.1
N18886387: length 2.1
  TOP w0.203: PU8.2 113.05,152.88 112.77,153.16 112.77,153.63 PR93.2
N19092935: length 2.8
  TOP w0.14: v1(227.4,15.74) 227.27,15.74 226.66,16.36 R543.2
  BOTTOM w0.14: TP122.1 226.94,16.55 227.48,16.02 227.48,15.82 v1(227.4,15.74)
N19940934: length 2.2
  TOP w0.508: PR410.2 115.17,22.19 v1(115.17,22.83) 115.79,22.83 PC264.2
N19940984: length 1.4
  TOP w0.508: PR422.2 101.11,18.8 PC277.1
N19941004: length 30.2
  TOP w0.203: PU28.14 120.81,20.97 v1(120.87,20.91)
  IN1 w0.203: v1(142,24.86) 141.04,23.89 132.37,23.89 130.78,22.31 126.57,22.31 125.22,23.66 125.22,24.53 124.62,25.13 122.03,25.13 121.37,24.47 121.37,22.57 120.81,22.01 120.81,20.97 v1(120.87,20.91)
  BOTTOM w0.14: v1(142,24.86) 142,26.08 141.79,26.29 PR564.2
N19941046: length 3.5
  TOP w0.14: PR392.2 PR397.1 PR402.1 v1(117.78,24.04) 118.17,23.66 PU28.7
N19941188: length 1.5
  TOP w0.762: PR423.2 PC291.1
N19941230: length 1.5
  TOP w0.508: PC263.2 125.21,22.56 PR409.1
N20974309: length 6.4
  TOP w0.14: PR164.1 95.83,70.33 95.83,71.95 95.63,72.15 93.6,72.15 v1(92.98,72.77) 92.96,72.79 PR152.1
N20974323: length 1.5
  TOP w0.178: PR163.2 PR162.2 PR161.1
N20974337: length 2.8
  TOP w0.254: PR151.1 PR152.2 93.05,74.57 93.57,74.06 94.29,74.06 94.4,74.16 PU13.6
N20974353: length 3.8
  TOP w0.178: PR161.2 93.01,71.47 93.2,71.66 93.76,71.66 94.13,71.29 PU13.1 94.4,70.67 94.13,70.4 94.13,70.04 PC135.2
N20974362: length 1.6
  TOP w0.254: PU13.5 95.34,75.15 95.34,75.15 95.34,75.2 PR150.2
N21715610:
  vias: v1(77.07,28.91)
N21715630: length 3
  BOTTOM w0.14: PU31.4 78.71,24.74 PC438.1 78.61,24 78.66,24.05 PR566.1
N21715632: length 1.1
  BOTTOM w0.14: PU31.12 79.11,28.11 79.09,28.13 PC425.1
N21715634: length 1.1
  BOTTOM w0.14: PU31.10 78.31,28.11 78.33,28.13 PC426.1
N21715675: length 5.9
  BOTTOM w0.14: PU31.5 78.31,24.86 77.97,24.53 77.35,24.53 v1(77.14,24.32) 77.09,24.27 76.95,24.27 76.29,23.61 75.83,23.61 PC441.1 74.99,23.44 PR567.1
N21715683: length 3.3
  BOTTOM w0.14: PR569.2 81.17,23.56 80.82,23.92 80.74,23.92 80.6,24.05 PC437.1 80,24.05 79.55,24.5 79.27,24.5 79.11,24.67 PU31.3
N21716560:
  vias: v1(93.49,28.62)
N21716580: length 2.6
  TOP w0.14: PU26.4 96.38,25.55 96.86,26.03 PC251.1 PR395.1
N21716582: length 1.2
  TOP w0.14: PC252.1 93.14,25.15 PU26.12
N21716584: length 1.2
  TOP w0.14: PU26.10 93.19,25.97 92.88,26.28 PC249.1
N21716627: length 2.8
  TOP w0.14: PR371.1 97.19,27.89 PC245.1 97.19,26.86 96.29,25.95 PU26.5
N21716633: length 3.3
  TOP w0.14: PR406.2 97.84,23.4 PC260.1 97.19,24.29 96.73,24.75 96.73,24.95 96.52,25.15 PU26.3
N22707794: length 4.9
  TOP w0.14: TP48.1 200.15,23.71 202.76,23.71 203.24,24.2 203.24,24.7 U14.BC1
N23148426: length 3.1
  TOP w0.14: Q16.2 108.37,103.73 v1(108.62,103.98) 108.62,104.09 108.48,104.23 Q16.3 107.65,104.23 107.56,104.33 107.56,104.86 R101.1
N23148930: length 7.8
  TOP w0.14: Q6.1 109.63,129.22 v1(109.8,129.05) 113.76,129.05 R55.2 115.36,128.58 R62.2
N23334321: length 1.2
  TOP w0.203: PU27.4 158.76,24.5 158.87,24.6
N23334329: length 1.4
  TOP w0.254: PR414.1 152.02,21.32 PC266.2
N23334507: length 1.8
  TOP w0.203: PR404.2 159.07,23.59 158.56,24.1 PU27.3
N23334555: length 1.4
  TOP w0.762: PR425.2 PC293.1
N23796258: length 4.8
  TOP w0.14: R83.1 169.41,118.01 v1(169.41,119.02) 169.41,119.63 169.11,119.93 Q8.2 168.22,119.93 168.12,120.03 168.12,120.35 168.2,120.43 Q8.3
N23796391: length 3
  TOP w0.14: LED1.2 166.07,117.28 165.22,116.44 165.22,116.24 v1(165.24,116.23) 165.46,116.01 166,116.01 R85.1
N24995566: length 3.4
  TOP w0.14: PU9.5 173.18,147.64 173.04,147.5 v1(173.04,147.07) 173.04,146.68 PR116.2 PC93.1
N24995570: length 1.4
  TOP w0.14: PU9.1 173.94,151.99 PR101.1
N24995581: length 1.3
  TOP w0.14: PR103.1 172.1,151.53 172.04,151.47 PU9.3
N25255287: length 1.7
  TOP w0.178: PR179.1 94.76,58.21 94.6,58.05 PU23.20
N25255291: length 1.9
  TOP w0.178: PU23.19 95,57.98 95.38,58.36 PR180.1
N25255301: length 140.9
  TOP w0.508: PR269.1 94.13,50.03 v1(93.85,49.75)
  IN3 w0.508: v1(116.9,158.53) 115.25,156.89 113.43,156.89 111.6,155.06 111.6,154.42 112.26,153.76 112.26,151.25 110.68,149.67 108.49,149.67 107.99,149.16 107.99,144.54 109.03,143.49 109.03,138.33 108.37,137.66 108.37,133.08 106,130.71 106,125.74 106.85,124.88 106.85,108.57 106.52,108.23 106.52,104.04 109.46,101.09 110.09,101.09 116.65,94.53 116.65,68.55 115.42,67.32 108.64,67.32 106.41,65.09 106.41,62.73 105.35,61.68 103.18,61.68 101.65,60.15 101.65,56.31 100.81,55.47 100.81,53.53 98.18,50.89 98.18,49.86 97.41,49.09 96.57,49.09 95.61,50.05 94.29,50.05 93.99,49.75 v1(93.85,49.75)
N25255306: length 40.6
  TOP w0.381: v1(72.85,53.04) 72.85,48.34 PL20.2 ; v1(95.61,60.97) 95.61,60.97 95.63,60.96 95.78,60.96 96.71,60.03 PR175.1
  IN1 w0.381: v1(95.61,60.97) 94.97,60.97 93.92,62.02 92.55,62.02 92.04,61.51 92.04,60.53 91.73,60.21 91.73,58.79 90.66,57.72 90.66,57.33 90.06,56.73 88.22,56.73 86.14,54.64 84.46,54.64 83.75,53.93 83.75,53.24 83.37,52.86 81.19,52.86 80.91,52.58 80.27,52.58 79.96,52.27 79.32,52.27 77.16,54.42 73.2,54.42 72.7,53.93 72.7,53.19 v1(72.85,53.04)
N25255314: length 162.1
  TOP w0.508: v1(94.52,49.15) 95.27,49.89 PR270.1 ; PQ4.4 117.09,163.16 v1(116.44,163.81)
  IN3 w0.508: v1(118.29,158.66) 117,157.38 116.71,157.38 115.84,156.51 115.84,156 113.56,153.71 113.56,151.27 110.74,148.45 109.47,148.45 108.96,147.95 108.96,145.81 109.91,144.86 109.91,138.07 109.25,137.42 109.25,132.83 106.8,130.38 106.8,129.84 107.28,129.35 108.15,129.35 108.76,128.74 108.76,125.54 108.38,125.17 108.38,108.7 109.04,108.04 109.04,103.52 110.05,102.5 113.58,102.5 114.93,103.85 120.11,103.85 122.88,101.08 122.88,96.97 118.3,92.39 118.3,68.2 115.94,65.85 110.66,65.85 105.69,60.88 103.51,60.88 102.45,59.82 102.45,55.98 101.61,55.14 101.61,53.14 100.2,51.72 100.2,50.17 98.96,48.93 98.96,47.35 98,46.39 97.28,46.39 95.9,47.77 95.65,47.77 94.52,48.89 v1(94.52,49.15)
  IN4 w0.508: v1(116.44,163.81) 118.59,161.66 118.59,158.97 v1(118.29,158.66)
