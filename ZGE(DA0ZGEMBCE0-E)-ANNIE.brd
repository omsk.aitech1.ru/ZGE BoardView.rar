# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQSN3: length 72.7
  TOP w0.089: v1(151.03,110.44) 151.06,110.42 U3.BC9
  TOP w0.102: JDIM1.74 154.82,51.16 155.09,51.42 155.09,51.86 154.67,52.27 154.67,52.98 155.15,53.45 155.15,53.78 154.93,54.01 154.56,54.01 154.47,53.92 154.2,53.92 154.1,54.02 v1(154.1,54.16)
  IN1 w0.079: v1(151.03,110.44) 150.73,110.44 150.61,110.33 150.61,108.6 149.86,107.85 149.86,100.64 151.46,99.03 151.52,99.03 151.53,99.03
  IN1 w0.127: v1(154.1,54.16) 154.1,53.96 154.01,53.87 153.79,53.87 153.66,54 153.66,54.33 154.24,54.91 154.24,62.88 154.76,63.4 154.76,75.91 155.37,76.52 155.37,92.63 152.12,95.88 152.12,98.44 151.53,99.03
  BOTTOM w0.102: v1(154.1,54.16) 154.1,53.99 153.99,53.88 153.8,53.88 153.07,54.61 153.07,56.89 152.63,57.34 152.63,57.45 152.68,57.5 152.78,57.5 152.92,57.64 JDIM3.74
M_B_DQSN4: length 74.9
  TOP w0.089: U3.AC9 135.05,110.23 134.92,110.36 v1(134.56,110.36)
  TOP w0.102: v1(125.95,53.48) 125.95,53.67 126.1,53.82 126.31,53.82 127.12,54.63 127.12,57.36 127.07,57.41 JDIM1.177
  IN1 w0.079: 130.23,98.44 130.23,98.5 130.29,98.56 130.29,99.2 133.57,102.48 133.57,108.37 134.18,108.97 134.18,109.26 134.06,109.38 134.06,109.86 v1(134.56,110.36)
  IN1 w0.127: 130.23,98.44 130.23,97.02 127.59,94.38 127.59,91.18 123.89,87.48 123.89,76.76 123.44,76.31 123.44,70.71 122.93,70.19 122.93,59.38 125.21,57.1 125.21,54.03 125.55,53.69 125.8,53.69 125.95,53.54 v1(125.95,53.48)
  BOTTOM w0.102: JDIM3.177 125.17,51.28 125.08,51.37 124.96,51.37 124.88,51.45 124.88,51.59 125.07,51.78 125.07,52.29 124.89,52.46 124.89,52.68 125.17,52.95 125.17,53.34 124.92,53.58 124.92,53.8 125.07,53.95 125.8,53.95 125.95,53.8 v1(125.95,53.48)
M_B_DQSN5: length 74.3
  TOP w0.089: v1(131.84,110.42) 132.04,110.42 132.31,110.15 U3.W9
  TOP w0.102: JDIM1.198 121.82,52.93 121.33,53.43 121.33,54.9 121.07,55.16 120.68,55.16 v1(120.49,55.34)
  IN1 w0.079: 127.68,99.1 127.64,99.14 127.64,99.82 131.39,103.58 131.39,108.77 131.45,108.82 131.45,110.4 131.55,110.5 131.76,110.5 v1(131.84,110.42)
  IN1 w0.127: 127.68,99.1 127.68,97.78 124.24,94.34 124.24,92.54 120.12,88.42 120.12,78.51 119.09,77.48 119.09,71.06 118.99,70.97 118.99,58.24 119.95,57.28 119.95,55.29 120.13,55.11 120.34,55.11 120.49,55.27 v1(120.49,55.34)
  BOTTOM w0.102: v1(120.49,55.34) 120.38,55.45 120.24,55.45 120.03,55.23 120.03,54.96 119.82,54.75 119.4,54.75 119.3,54.85 119.3,54.99 119.85,55.54 119.85,56.21 120.09,56.45 120.09,57.05 120.05,57.08 119.82,57.32 119.82,57.49 119.92,57.59 JDIM3.198
M_B_DQSN6: length 77.4
  TOP w0.089: U3.R9 129.48,110.1 v1(129.08,110.5)
  TOP w0.102: v1(115.23,52.83) 115.56,53.16 115.73,53.16 116.09,53.52 116.09,54.33 116.28,54.51 116.28,56.69 116.5,56.91 116.5,57.38 116.57,57.45 JDIM1.219
  IN1 w0.079: v1(129.08,110.5) 128.84,110.26 128.71,110.26 128.54,110.09 128.54,108.74 127.55,107.75 127.55,103.23 123.41,99.08 123.41,97.46 120.43,94.48
  IN1 w0.127: v1(115.23,52.83) 115.04,53.02 114.77,53.02 114.49,53.31 114.49,81.46 116.31,83.28 116.31,90 120.43,94.12 120.43,94.48
  BOTTOM w0.102: v1(115.23,52.83) 115.23,53.27 115.03,53.47 114.83,53.47 114.53,53.77 114.53,53.91 114.29,54.14 114.1,54.14 113.89,53.93 113.89,53.7 114.67,52.91 114.67,51.89 114.67,51.88 JDIM3.219
M_B_DQSN7: length 80.2
  TOP w0.089: U3.M9 126.5,110.42 v1(126.33,110.42)
  TOP w0.102: JDIM1.240 111.32,51.79 111.22,51.89 111.22,53.05 111.44,53.27 111.44,54.19 111.07,54.56 110.67,54.56 110.49,54.74 v1(110.49,54.83)
  IN1 w0.079: v1(126.33,110.42) 126.11,110.42 125.95,110.26 125.95,110.05 126.04,109.96 126.04,108.82 125.73,108.51 125.11,108.51 124.51,107.9 124.51,106.08 124.46,106.04
  IN1 w0.127: v1(110.49,54.83) 110.51,54.81 110.51,54.8 110.52,54.79 110.52,54.55 110.4,54.42 110.12,54.42 109.93,54.61 109.93,72.58 109.14,73.36 109.14,74.72 109.93,75.51 109.93,81.62 112.82,84.51 112.82,101.15 116,104.33 122.75,104.33 124.46,106.04
  BOTTOM w0.102: JDIM3.240 109.42,57.64 109.32,57.54 109.32,57.23 109.55,57 109.55,54.83 110.02,54.37 110.39,54.37 110.57,54.54 110.57,54.76 v1(110.49,54.83)
M_B_DQSN8: length 71
  TOP w0.089: v1(148.31,110.42) 148.63,110.1 U3.AY9
  TOP w0.102: JDIM1.95 149.57,57.35 149.48,57.25 149.48,54.33 149.15,54 148.66,54 148.51,53.86 v1(148.51,53.77)
  IN3 w0.079: 146.39,107.65 146.39,107.71 147.26,108.58 147.55,108.58 147.97,108.99 147.97,110.08 v1(148.31,110.42)
  IN3 w0.127: 146.39,107.65 146.39,104.06 146.34,104.01 146.34,86.56 149.15,83.74 149.15,64.04 149.87,63.32 149.87,58.64 149.24,58.02 149.24,54.37 148.87,54 148.74,54 v1(148.51,53.77)
  BOTTOM w0.102: v1(148.51,53.77) 148.51,54.08 148.27,54.31 147.99,54.31 147.67,54 147.67,53.52 147.74,53.44 147.74,52.98 147.51,52.75 147.51,51.36 147.67,51.2 JDIM3.95
M_B_DQSP0: length 82.2
  TOP w0.089: U3.BP9 158.59,110.87 v1(158.59,110.94)
  TOP w0.102: v1(169.33,54.67) 169.33,54.22 169.44,54.11 169.78,54.11 170.27,54.61 170.27,57.24 170.07,57.44 JDIM1.13
  IN1 w0.127: v1(158.59,110.94) 158.46,110.94 158.35,111.05 158.35,111.18 158.63,111.46 160.62,111.46 161.87,110.21 163.01,110.21 163.38,109.84 164.93,109.84 165.54,109.22 165.7,109.22 171.79,103.13 171.79,96.04 167.42,91.67 167.42,66.83 169.8,64.46 169.8,54.13 169.66,53.99 169.11,53.99 168.97,54.13 168.97,54.52 169.13,54.67 v1(169.33,54.67)
  BOTTOM w0.102: JDIM3.13 168.17,51.28 168.3,51.4 168.3,51.75 168.54,52 168.54,53.3 168.38,53.46 168.38,54.1 168.63,54.35 169,54.35 v1(169.33,54.67)
M_B_DQSP1: length 78
  TOP w0.089: U3.BJ9 156.04,110.14 156.04,110.29 156.17,110.42 v1(156.47,110.42)
  TOP w0.102: v1(164.5,53.89) 164.5,53.96 164.69,54.16 165.09,54.16 165.4,53.85 165.4,53.62 165.26,53.48 165.14,53.48 164.93,53.27 164.93,52.89 165.17,52.66 165.17,51.47 165.1,51.4 164.88,51.4 164.78,51.3 164.78,51.16 164.82,51.11 JDIM1.34
  IN1 w0.079: 158.65,106.8 158.65,106.82 158.7,106.86 158.7,108.51 158.38,108.83 157.86,108.83 157.77,108.74 157.07,108.74 156.63,109.18 156.63,109.88 156.75,110 156.75,110.44 156.7,110.5 156.55,110.5 v1(156.47,110.42)
  IN1 w0.127: 158.65,106.8 158.65,105.28 161.31,102.62 161.31,101.58 160.83,101.1 160.83,97.35 163.85,94.33 163.85,93.73 163.73,93.61 162.79,93.61 162.52,93.34 162.52,92.76 162.8,92.49 163.73,92.49 163.85,92.36 163.85,91.98 163.73,91.85 162.76,91.85 162.49,91.59 162.49,91 162.76,90.74 163.73,90.74 163.85,90.61 163.85,65.34 164.07,65.12 164.07,55.85 163.83,55.61 163.83,54.37 164.06,54.15 164.31,54.15 164.5,53.96 v1(164.5,53.89)
  BOTTOM w0.102: v1(164.5,53.89) 164.31,54.07 164.06,54.07 163.36,54.77 163.36,56.63 162.92,57.06 JDIM3.34
M_B_DQSP2: length 71.5
  TOP w0.089: U3.BF9 152.96,110.47 v1(152.93,110.47)
  TOP w0.102: JDIM1.55 159.57,57.57 159.77,57.38 159.77,57.23 159.4,56.87 159.4,55.8 159.96,55.25 159.96,54.36 159.83,54.23 159.39,54.23 159.27,54.35 v1(159.27,54.7)
  IN1 w0.079: v1(152.93,110.47) 153.08,110.47 153.29,110.26 153.29,107.67 153.73,107.24 153.73,103.56 155.78,101.5 155.78,99.24 155.74,99.2 155.74,99.18
  IN1 w0.127: 155.74,99.18 155.74,97.39 158.69,94.44 158.69,71.61 159.51,70.8 159.51,56.88 159.85,56.54 159.85,54.53 159.58,54.27 159.4,54.27 159.27,54.4 v1(159.27,54.7)
  BOTTOM w0.102: v1(159.27,54.7) 159.27,54.67 159.12,54.51 158.68,54.51 157.78,53.61 157.78,51.34 157.67,51.23 JDIM3.55
M_B_DQSP3: length 72.7
  TOP w0.089: U3.BB9 150.27,110.42 v1(150.12,110.42)
  TOP w0.102: v1(154.08,53.45) 154.08,53.61 154.18,53.71 154.55,53.71 154.64,53.8 154.84,53.8 154.94,53.7 154.94,53.54 154.47,53.06 154.47,52.19 154.88,51.77 154.88,51.5 154.68,51.3 154.39,51.3 154.32,51.24 JDIM1.76
  IN1 w0.079: v1(150.12,110.42) 150.29,110.42 150.46,110.26 150.46,108.67 149.7,107.91 149.7,100.57 151.33,98.94 151.33,98.88 151.36,98.86
  IN1 w0.127: 151.36,98.86 151.88,98.34 151.88,95.78 155.13,92.53 155.13,76.62 154.52,76.01 154.52,63.5 154,62.98 154,55.01 153.42,54.43 153.42,53.89 153.69,53.63 153.9,53.63 v1(154.08,53.45)
  BOTTOM w0.102: JDIM3.76 152.42,57.25 152.87,56.81 152.87,54.52 153.72,53.67 153.85,53.67 v1(154.08,53.45)
M_B_DQSP4: length 74.9
  TOP w0.089: v1(134.59,109.67) 134.5,109.67 134.13,110.04 U3.AA9
  TOP w0.102: JDIM1.179 126.57,57.47 126.71,57.34 126.82,57.34 126.91,57.25 126.91,54.71 126.41,54.21 126.23,54.03 126.05,54.03 125.95,54.13 v1(125.95,54.49)
  IN1 w0.079: 130.47,98.44 130.47,98.49 130.45,98.52 130.45,99.13 133.73,102.41 133.73,108.3 134.33,108.91 134.33,109.33 134.22,109.44 134.22,109.79 134.32,109.89 134.44,109.89 134.59,109.74 v1(134.59,109.67)
  IN1 w0.127: v1(125.95,54.49) 126.13,54.3 126.13,54.04 126.03,53.93 125.65,53.93 125.45,54.13 125.45,57.2 123.17,59.48 123.17,70.09 123.69,70.61 123.69,76.21 124.13,76.66 124.13,87.38 127.83,91.08 127.83,94.28 130.47,96.92 130.47,98.44
  BOTTOM w0.102: v1(125.95,54.49) 125.95,54.33 125.77,54.15 124.99,54.15 124.72,53.88 124.72,53.5 124.96,53.25 124.96,53.04 124.67,52.75 124.67,52.39 124.86,52.2 124.86,51.86 124.67,51.67 JDIM3.179
M_B_DQSP5: length 74.4
  TOP w0.089: U3.V9 131.39,110.27 131.24,110.41 v1(131.01,110.41)
  TOP w0.102: v1(120.49,54.72) 120.72,54.95 120.99,54.95 121.12,54.82 121.12,53.34 121.62,52.84 121.62,51.56 121.53,51.47 121.28,51.47 121.19,51.37 121.19,51.23 121.32,51.09 JDIM1.200
  IN1 w0.079: 127.44,99.08 127.44,99.11 127.48,99.16 127.48,99.89 131.24,103.65 131.24,108.83 131.29,108.89 131.29,110.13 131.24,110.19 v1(131.01,110.41)
  IN1 w0.127: 127.44,99.08 127.44,97.88 124,94.44 124,92.64 119.88,88.52 119.88,78.61 118.85,77.58 118.85,71.16 118.75,71.07 118.75,58.14 119.71,57.18 119.71,55.19 120.03,54.87 120.34,54.87 v1(120.49,54.72)
  BOTTOM w0.102: v1(120.49,54.72) 120.36,54.84 120.19,54.84 119.9,54.55 119.31,54.55 119.09,54.77 119.09,55.07 119.65,55.63 119.65,56.29 119.89,56.53 119.89,56.96 119.62,57.24 119.62,57.43 119.42,57.62 JDIM3.200
M_B_DQSP6: length 77.4
  TOP w0.089: U3.P9 128.69,110.14 128.95,110.14 129.08,110.01 v1(129.08,109.85)
  TOP w0.102: JDIM1.221 116.07,57.47 116.3,57.25 116.3,57 116.07,56.78 116.07,54.59 115.89,54.41 115.89,53.61 115.65,53.37 115.36,53.37 115.23,53.5 v1(115.23,53.86)
  IN1 w0.079: v1(129.08,109.85) 129.08,109.95 128.93,110.11 128.77,110.11 128.7,110.03 128.7,108.67 127.71,107.69 127.71,103.16 123.56,99.02 123.56,97.4 120.67,94.5 120.67,94.4
  IN1 w0.127: v1(115.23,53.86) 115.37,53.72 115.37,53.44 115.19,53.26 114.87,53.26 114.73,53.41 114.73,81.36 116.55,83.18 116.55,89.9 120.67,94.02 120.67,94.4
  BOTTOM w0.102: JDIM3.221 114.17,51.22 114.47,51.52 114.47,52.82 113.68,53.61 113.68,54.02 114.01,54.35 114.37,54.35 114.73,53.99 114.73,53.86 114.91,53.68 115.04,53.68 v1(115.23,53.86)
M_B_DQSP7: length 80.2
  TOP w0.089: v1(125.48,110.44) 125.65,110.44 125.9,110.19 U3.L9
  TOP w0.102: v1(110.49,53.97) 110.49,54.23 110.62,54.35 110.99,54.35 111.23,54.11 111.23,53.35 111.02,53.14 111.02,51.8 111.12,51.7 111.12,51.36 111.05,51.29 110.92,51.29 110.82,51.2 JDIM1.242
  IN1 w0.079: v1(125.48,110.44) 125.79,110.13 125.79,109.99 125.88,109.9 125.88,108.88 125.66,108.66 125.05,108.66 124.35,107.96 124.35,106.27 124.26,106.18
  IN1 w0.127: v1(110.49,53.97) 110.29,54.18 110.02,54.18 109.69,54.51 109.69,72.48 108.9,73.26 108.9,74.82 109.69,75.61 109.69,81.72 112.58,84.61 112.58,101.25 115.9,104.57 122.65,104.57 124.26,106.18
  BOTTOM w0.102: JDIM3.242 108.92,57.59 109.12,57.4 109.12,57.14 109.35,56.91 109.35,54.74 109.93,54.16 110.3,54.16 v1(110.49,53.97)
M_B_DQSP8: length 71
  TOP w0.089: U3.AW9 147.85,110.23 147.66,110.42 v1(147.47,110.42)
  TOP w0.102: v1(148.51,54.7) 148.47,54.65 148.47,54.34 148.61,54.21 149.06,54.21 149.27,54.42 149.27,57.3 149.07,57.5 JDIM1.97
  IN3 w0.079: 146.15,107.58 146.15,107.69 147.2,108.73 147.48,108.73 147.81,109.06 147.81,110.08 v1(147.47,110.42)
  IN3 w0.127: v1(148.51,54.7) 148.43,54.61 148.43,54.42 148.6,54.25 148.78,54.25 149,54.47 149,58.12 149.62,58.74 149.62,63.22 148.91,63.94 148.91,83.64 146.09,86.46 146.09,104.11 146.15,104.16 146.15,107.58
  BOTTOM w0.102: v1(148.51,54.7) 148.51,54.63 148.4,54.52 147.9,54.52 147.46,54.08 147.46,53.44 147.54,53.36 147.54,53.06 147.31,52.84 147.31,51.36 147.17,51.23 JDIM3.97
M_B_ODT0: length 68.9
  TOP w0.089: U3.AF7 137.79,108.64 137.45,108.29 137.25,108.29 137.16,108.38 137.16,108.5 137.43,108.77 137.43,108.96 v1(137.32,109.07)
  TOP w0.216: JDIM1.155 132.57,59.41 132.62,59.46 132.62,60.48 130.32,62.79 v1(129.94,62.79) 129.84,62.89 v1(127.66,62.89)
  IN1 w0.079: v1(137.32,109.07) 137.32,108.82 136.97,108.47 136.97,105.32 136.81,105.15 136.7,105.15 136.65,105.2 136.65,105.61 136.57,105.69 136.43,105.69 136.33,105.58 136.33,101.3 135.61,100.58 135.61,99.07 135.23,98.7
  IN1 w0.127: 135.23,98.7 135.23,97.25 132.34,94.36 132.34,89.15 132.22,89.02 132.13,89.02 131.99,88.88 131.99,88.7 132.16,88.53 132.16,88.35 131.98,88.17 131.8,88.17 131.63,88.34 131.45,88.34 131.27,88.16 131.27,87.98 131.44,87.81 131.44,87.63 131.26,87.45 131.08,87.45 130.91,87.62 130.73,87.62 130.19,87.08 130.19,86.86 130.32,86.73 130.32,86.58 130.12,86.38 129.66,86.38 129.53,86.25 129.53,86.02 129.67,85.87 130.19,85.87 130.32,85.75 130.32,85.57 130.12,85.36 129.66,85.36 129.53,85.24 129.53,84.98 129.66,84.86 130.11,84.86 130.24,84.73 130.24,84.49 130.11,84.37 129.66,84.37 129.53,84.24 129.53,83.99 129.66,83.86 130.19,83.86 130.32,83.73 130.32,70.88 128.34,68.9 128.34,68.9 128.04,68.6 128.04,68.38 127.91,68.25 127.74,68.25 127.66,68.17 127.66,67.79 127.79,67.67 127.91,67.67 128.04,67.54 128.04,67.28 127.91,67.16 127.79,67.16 127.66,67.03 127.66,66.78 127.79,66.65 127.91,66.65 128.04,66.52 128.04,66.27 127.91,66.14 127.79,66.14 127.66,66.01 127.66,65.76 127.79,65.63 127.91,65.63 128.04,65.51 128.04,65.25 127.91,65.13 127.79,65.13 127.66,65 127.66,64.74 127.79,64.62 127.91,64.62 128.04,64.49 128.04,64.24 127.91,64.11 127.79,64.11 127.66,63.98 127.66,63.7 127.79,63.57 127.92,63.57 128.04,63.46 128.04,63.02 127.91,62.89 v1(127.66,62.89)
M_B_ODT1: length 71.7
  TOP w0.089: v1(136.39,109.77) 136.86,109.45 U3.AE8
  TOP w0.216: v1(126.2,61.23) 126.21,61.22 127.1,61.22 127.32,61.44 129.83,61.44 v1(130.01,61.26) 130.01,61.23 131.07,60.17 JDIM1.161
  IN1 w0.079: v1(136.39,109.77) 136.27,109.89 136.27,110.09 136.16,110.21 136.04,110.21 135.93,110.1 135.93,108.85 136.07,108.71 136.07,108.07 135.66,107.66 135.52,107.66 134.98,107.12 134.98,106.96 135.06,106.88 135.15,106.88 135.22,106.8 135.22,106.64 135.15,106.56 135.06,106.56 134.98,106.49 134.98,106.33 135.06,106.25 135.14,106.25 135.22,106.17 135.22,106.01 135.14,105.93 135.06,105.93 134.98,105.86 134.98,105.22 135.65,104.55 135.65,101.66 134.69,100.69 134.69,99.66 134.51,99.48 134.4,99.48 134.32,99.56 134.21,99.56 134.09,99.45 134.09,99.34 134.17,99.26 134.17,99.15 133.99,98.96
  IN1 w0.127: v1(126.2,61.23) 125.91,61.52 125.91,68.95 127.78,70.82 127.78,80.19 127.65,80.32 127.37,80.32 127.24,80.44 127.24,80.7 127.37,80.82 127.65,80.82 127.78,80.95 127.78,81.21 127.65,81.33 127.37,81.33 127.24,81.46 127.24,81.71 127.37,81.84 127.65,81.84 127.78,81.97 127.78,82.22 127.65,82.35 127.37,82.35 127.24,82.48 127.24,82.73 127.37,82.86 127.65,82.86 127.78,82.98 127.78,83.24 127.65,83.36 127.37,83.36 127.24,83.49 127.24,83.75 127.37,83.87 127.65,83.87 127.78,84 127.78,84.25 127.65,84.38 127.37,84.38 127.24,84.51 127.24,84.76 127.37,84.89 127.65,84.89 127.78,85.02 127.78,85.27 127.65,85.4 127.37,85.4 127.24,85.52 127.24,85.78 127.37,85.9 127.65,85.9 127.78,86.03 127.78,86.29 127.65,86.42 127.43,86.42 127.33,86.52 127.33,86.7 130.59,89.96 130.59,94.26 132.61,96.28 132.61,96.78 132.82,96.99 133.06,96.99 133.21,97.14 133.21,97.36 133.06,97.51 132.69,97.51 132.59,97.61 132.59,97.81 132.7,97.92 133.22,97.92 133.29,97.99 133.29,98.2 133.15,98.34 132.77,98.34 132.57,98.53 132.57,98.84 132.78,99.05 133,99.05 133.35,98.7 133.72,98.7 133.99,98.96
M_B_ODT2: length 74.3
  TOP w0.089: U3.AE9 136.81,110.1 v1(136.46,110.45)
  IN1 w0.079: 134.61,98.83 135.14,99.37 135.14,100.66 135.99,101.51 135.99,105.71 136.53,106.25 136.53,108.6 136.77,108.84 136.77,109.28 136.67,109.38 136.67,109.51 136.77,109.61 136.77,109.93 136.66,110.04 136.66,110.39 136.6,110.45 v1(136.46,110.45)
  IN1 w0.127: 134.61,98.83 134.61,97.48 131.45,94.32 131.45,89.6 128.64,86.79 128.64,81.95 128.84,81.74 129.3,81.74 129.42,81.62 129.42,81.36 129.3,81.24 128.77,81.24 128.64,81.11 128.64,80.91 128.82,80.73 129.3,80.73 129.42,80.6 129.42,80.35 129.3,80.22 128.77,80.22 128.64,80.09 128.64,79.84 128.77,79.71 129.3,79.71 129.42,79.59 129.42,79.33 129.3,79.2 128.77,79.2 128.64,79.08 128.64,78.82 128.77,78.7 129.3,78.7 129.42,78.57 129.42,78.32 129.3,78.19 128.77,78.19 128.64,78.06 128.64,77.79 128.77,77.66 129.29,77.66 129.42,77.53 129.42,77.28 129.29,77.15 128.77,77.15 128.64,77.02 128.64,76.69 128.77,76.56 129.31,76.56 129.43,76.43 129.43,71.25 126.77,68.59 126.77,62.4 127.09,62.08 127.09,61.51 126.69,61.12 126.69,60.36 129.25,57.81 129.25,55.75 v1(129.43,55.58)
  BOTTOM w0.102: v1(129.43,55.58) 129.86,55.14 129.86,52.8 130.67,51.99 JDIM3.155
M_B_ODT3: length 75.7
  TOP w0.089: U3.AE11 136.52,111.76 v1(136.43,111.76)
  IN1 w0.079: 131.93,99.05 131.93,99.32 134.65,102.04 134.65,107.32 135.6,108.27 135.6,110.38 136.04,110.82 136.04,111.41 135.92,111.52 135.92,111.83 135.69,112.06 135.69,112.2 135.76,112.27 135.92,112.27 v1(136.43,111.76)
  IN1 w0.127: 131.93,99.05 131.93,96.41 129.73,94.21 129.73,90.32 129.71,90.3 126.38,86.97 126.38,82.61 126.25,82.48 126.14,82.48 126.01,82.35 126.01,82.1 126.14,81.97 126.25,81.97 126.38,81.85 126.38,81.59 126.25,81.46 126.14,81.46 126.01,81.34 126.01,81.08 126.14,80.96 126.25,80.96 126.38,80.83 126.38,80.58 126.25,80.45 126.14,80.45 126.01,80.32 126.01,80.07 126.14,79.94 126.25,79.94 126.38,79.81 126.38,79.56 126.25,79.43 126.14,79.43 126.01,79.31 126.01,79.05 126.14,78.92 126.25,78.92 126.38,78.8 126.38,78.54 126.25,78.42 126.14,78.42 126.01,78.29 126.01,78.04 126.14,77.91 126.25,77.91 126.38,77.78 126.38,77.53 126.25,77.4 126.14,77.4 126.01,77.27 126.01,77.02 126.14,76.89 126.25,76.89 126.38,76.77 126.38,76.51 126.25,76.38 126.14,76.38 126.01,76.26 126.01,76 126.14,75.88 126.25,75.88 126.38,75.75 126.38,75.5 126.25,75.37 126.14,75.37 126.01,75.24 126.01,74.99 126.14,74.86 126.25,74.86 126.38,74.73 126.38,74.48 126.25,74.35 126.14,74.35 126.01,74.23 126.01,73.97 126.14,73.84 126.25,73.84 126.38,73.72 126.38,73.46 126.25,73.34 126.14,73.34 126.01,73.21 126.01,72.96 126.14,72.83 126.25,72.83 126.38,72.7 126.38,72.45 126.25,72.32 126.14,72.32 126.01,72.19 126.01,71.94 126.14,71.81 126.25,71.81 126.38,71.69 126.38,71.44 126.27,71.33 126.08,71.33 126.01,71.26 126.01,70.98 126.1,70.89 126.22,70.89 126.33,70.79 126.33,70.59 125.92,70.19 125.92,70.19 125.05,69.31 125.05,60.79 128.39,57.45 128.39,52.12 128.83,51.68 v1(129.4,51.68)
  BOTTOM w0.102: v1(129.4,51.68) 129.17,51.45 JDIM3.161
MACRO_BTN_1: length 112.7
  TOP w0.14: U4.11 12.9,73.48 13.08,73.3 13.08,73.3 13.4,72.98 13.4,72.84 v1(13.61,72.64)
  IN3 w0.089: v1(67.38,17.43) 68.96,17.43 71.74,20.22 71.74,20.85 71.2,21.39 69.16,21.39 68.23,22.32 68.23,25.67 67.56,26.33 67.17,26.33 66.78,26.72 66.63,26.72 65.41,27.93 65.28,27.93 64.9,28.32 64.51,28.32 64.25,28.57 63.23,28.57 62.57,29.23 61.08,29.23 60.86,29.01 59.44,29.01 59.17,29.28 56.71,29.28 54.04,31.95 54.04,32.63 52.89,33.78 49.62,33.78 48.83,34.56 47.93,34.56 47.26,35.23 46.32,35.23 45.08,36.47 42.54,36.47 41.85,37.16 40.9,37.16 40.29,37.77 38.43,37.77 37.81,38.38 36.28,38.38 32.61,42.05 28.13,42.05 27.83,42.34 27.83,43.63 25.53,45.93 22.04,45.93 20.1,47.86 20.1,49.7 18.72,51.08 17.96,51.08 17.12,51.92 17.12,55.04 16.51,55.65 16.51,57.16 13.61,60.05 13.61,60.71 13.42,60.91 13.42,65.27 13.73,65.59 13.73,69.23 13.08,69.88 13.08,71.92 13.61,72.44 v1(13.61,72.64)
  BOTTOM w0.14: v1(67.38,17.43) 67.53,17.58 67.53,18.51 67.65,18.63 CN19.43 ; D92.1 v1(17.8,67.99) 17.27,68.52 17.27,70.55 16.94,70.88 15.66,70.88 13.9,72.64 v1(13.61,72.64)
MACRO_BTN_2: length 111.5
  TOP w0.14: U4.12 12.9,73.88 13.39,73.39 v1(13.64,73.39)
  IN3 w0.089: v1(13.64,73.39) 13.37,73.39 12.87,72.89 12.87,69.83 13.54,69.15 13.54,65.67 13.23,65.35 13.23,60.83 13.42,60.63 13.42,59.98 13.61,59.79 16.32,57.08 16.32,55.57 16.93,54.96 16.93,51.84 17.88,50.89 18.64,50.89 19.36,50.17 19.36,48.87 19.21,48.72 19.21,47.51 19.44,47.28 20.32,47.28 20.79,46.81 20.79,45.93 21.12,45.6 21.64,45.6 21.79,45.74 25.45,45.74 27.64,43.55 27.64,42.26 28.05,41.86 32.53,41.86 36.2,38.19 37.73,38.19 38.35,37.58 40.21,37.58 40.82,36.97 41.77,36.97 42.46,36.28 45,36.28 46.24,35.04 47.19,35.04 47.85,34.37 48.75,34.37 49.54,33.59 52.81,33.59 53.85,32.55 53.85,31.87 56.63,29.09 59.09,29.09 59.57,28.61 61.26,28.61 61.7,28.16 63.17,28.16 63.39,28.38 64.17,28.38 64.43,28.13 64.82,28.13 65.21,27.74 65.33,27.74 66.19,26.88 66.19,25.86 68.04,24.02 68.04,22.24 69.08,21.2 71.12,21.2 71.55,20.77 71.55,20.31 69.55,18.3 v1(69.06,18.3)
  BOTTOM w0.14: v1(69.06,18.3) 69.03,18.3 68.98,18.36 68.65,18.36 68.15,18.86 CN19.42 ; v1(13.64,73.39) 13.64,73.29 15.78,71.16 17.17,71.16 17.55,70.78 17.55,69.27 17.81,69 D91.1
MACRO_BTN_3: length 106.3
  TOP w0.14: U4.13 12.9,74.28 13.17,74.01 v1(13.44,74.01)
  IN3 w0.089: v1(68.95,20.05) 68.95,21.06 67.85,22.16 67.85,23.94 67.84,23.94 67.83,23.94 66,25.78 66,26.81 65.25,27.55 65.13,27.55 64.74,27.94 64.35,27.94 64.09,28.19 63.46,28.19 63.25,27.97 61.62,27.97 61.18,28.42 59.49,28.42 59.01,28.9 56.54,28.9 53.66,31.79 53.66,32.48 52.73,33.4 49.46,33.4 48.67,34.18 47.77,34.18 47.11,34.85 46.17,34.85 44.92,36.09 42.13,36.09 41.83,35.79 40.79,35.79 40.51,36.07 40.51,36.21 40.26,36.46 39.09,36.46 38.9,36.65 37.3,36.65 32.28,41.67 27.97,41.67 27.45,42.18 27.45,43.47 25.37,45.55 21.86,45.55 21.72,45.41 21.04,45.41 20.6,45.85 20.6,46.73 20.24,47.09 19.36,47.09 19.02,47.44 19.02,48.8 19.17,48.95 19.17,50.09 18.57,50.7 17.8,50.7 16.74,51.76 16.74,54.88 16.13,55.49 16.13,57 13.61,59.52 13.42,59.71 13.23,59.9 13.23,60.55 13.04,60.75 13.04,65.43 13.35,65.75 13.35,69.07 12.68,69.75 12.68,73.65 13.04,74.01 v1(13.44,74.01)
  BOTTOM w0.14: CN19.41 68.65,19.59 68.95,19.89 v1(68.95,20.05) ; D90.1 18.03,70.15 v1(18.01,70.13) 18.01,71.08 17.65,71.43 15.89,71.43 15.28,72.05 15.28,72.54 13.81,74.01 v1(13.44,74.01)
MACRO_BTN_P: length 113.2
  TOP w0.14: U4.10 12.9,73.08 13.12,72.86 13.12,72.02 13.29,71.85 v1(13.61,71.85)
  IN3 w0.089: v1(66.9,16.96) 68.75,16.96 71.93,20.14 71.93,20.93 71.28,21.58 69.24,21.58 68.42,22.4 68.42,25.74 67.63,26.53 67.3,26.53 66.92,26.92 66.69,26.92 65.49,28.12 65.36,28.12 64.98,28.51 64.59,28.51 64.33,28.76 63.31,28.76 62.65,29.42 61,29.42 60.78,29.2 59.52,29.2 59.25,29.47 56.79,29.47 54.23,32.03 54.23,32.71 52.97,33.97 49.69,33.97 48.91,34.76 48.01,34.76 47.34,35.42 46.42,35.42 43.76,38.08 41.98,38.08 41.86,37.96 38.51,37.96 37.89,38.57 36.36,38.57 32.69,42.24 29.66,42.24 28.86,43.04 28.69,43.04 25.61,46.12 22.12,46.12 20.29,47.94 20.29,49.78 18.8,51.27 18.04,51.27 17.31,52 17.31,55.12 16.7,55.73 16.7,57.24 13.8,60.13 13.8,60.79 13.61,60.99 13.61,65.19 13.93,65.51 13.93,69.31 13.5,69.73 13.5,71.74 v1(13.61,71.85)
  BOTTOM w0.14: CN19.44 67.15,18.13 66.81,17.79 66.81,17.04 v1(66.9,16.96) ; D93.1 18.05,66.97 16.91,68.11 16.91,70.36 16.77,70.51 15.4,70.51 14.06,71.85 v1(13.61,71.85)
MACRO_BTN_T: length 110.9
  TOP w0.14: v1(13.64,74.63) 13.12,74.63 13.07,74.68 U4.14
  IN3 w0.089: v1(13.64,74.63) 13.24,74.63 12.49,73.88 12.49,69.67 13.16,68.99 13.16,65.83 12.85,65.51 12.85,60.67 13.04,60.47 13.04,59.82 13.23,59.63 15.94,56.92 15.94,55.41 16.55,54.8 16.55,51.68 17.72,50.51 18.11,50.51 18.31,50.31 18.31,49.04 18.83,48.52 18.83,47.23 20.31,45.74 20.31,45.01 19.95,44.65 19.95,44.22 20.4,43.78 20.81,43.78 22.39,45.36 25.29,45.36 27.26,43.39 27.26,42.11 27.89,41.48 32.2,41.48 37.22,36.46 38.82,36.46 39.74,35.55 41.86,35.55 42.21,35.9 44.84,35.9 46.09,34.66 47.03,34.66 47.69,33.99 48.6,33.99 49.38,33.21 52.65,33.21 53.47,32.4 53.47,31.71 56.47,28.71 58.93,28.71 59.42,28.23 61.1,28.23 61.54,27.78 63.33,27.78 63.54,28 64.02,28 64.27,27.75 64.66,27.75 65.05,27.36 65.18,27.36 65.81,26.73 65.81,25.7 66.8,24.71 66.8,23.44 66.29,22.93 66.29,21.97 67.47,20.78 67.47,19.86 67.69,19.64 69.2,19.64 69.61,20.05 v1(69.7,20.05)
  BOTTOM w0.14: CN19.40 69.15,19.59 69.61,20.05 v1(69.7,20.05) ; v1(13.64,74.63) 13.95,74.63 15.56,73.02 15.56,72.17 16.01,71.71 18.22,71.71 D89.1
MAIND: length 342.9
  TOP w0.14: v1(184.72,51.9) 184.72,51.2 186.04,49.89 186.04,49.18 185.9,49.04 PR285.1 ; v1(176.93,150.08) 176.39,150.62 PQ10.2
  IN1 w0.086: v1(179.11,67.96) 179.52,68.37 179.52,95.42 178.68,96.26 178.68,102 177.21,103.47 177.21,106.32 168.27,115.26 168.27,116.22 170.35,118.3 170.35,124.81 169.74,125.42 169.74,126.89 170.35,127.5 170.35,140.28 172.66,142.59 172.66,148 174.75,150.08 v1(176.93,150.08)
  IN3 w0.089: v1(176.93,150.08) 176.93,148.04 174.05,145.16 174.05,137.19 174.97,136.28 176.75,136.28 180.74,132.28 180.74,130.83 181.74,129.83 181.74,112.38 181.01,111.64 181.01,106.83 181.74,106.1 181.74,89.7 181.87,89.57 181.87,89.39 184.54,86.73 184.54,81.56 181.08,78.1 181.08,73.14 192.64,61.59 198.92,61.59 200.65,59.85 200.65,59.17 200.2,58.72 197.58,58.72 197.54,58.75 197.54,58.75 195.68,60.61 192.2,60.61 187.5,55.91 187.5,54.81 187.74,54.57 188.34,54.57 188.8,54.11 188.8,50.88 188.49,50.56 185.28,50.56 184.88,50.95 184.88,51.73 v1(184.72,51.9)
  BOTTOM w0.14: PQ41.3 179.24,155.48 PC319.1 177.6,155.48 177.34,155.74 PR466.2 176.09,155.06 176.09,150.92 v1(176.93,150.08) ; v1(179.11,67.96) 176.67,70.4 170.05,70.4 166.25,66.6 136.68,66.6 134.63,64.55 115.62,64.55 v1(114.86,65.31) 114.1,66.08 110.69,66.08 107,69.77 102.52,69.77 102.34,69.59 102.02,69.59 101.73,69.3 101.3,69.3 100.53,70.07 100.53,73.27 99.83,73.97 94.39,73.97 94.13,73.7 94.13,71.7 93.77,71.34 PQ46.2
MAINON: length 587.9
  TOP w0.14: PR371.2 97.65,28.03 97.91,28.29 98.37,28.29 98.93,27.72 v1(98.93,26.73) ; v1(273.96,59.19) 273.96,58.9 273.52,58.46 R139.1 ; v1(73.73,24.4) 73.73,23.77 73.39,23.42 72.27,23.42 70.67,21.82 U18.30 68.46,21.82 67.9,21.27 R464.1 ; v1(65.81,159.38) 65.48,159.38 64.92,159.94 R17.1 ; PR374.1 158.46,28.68 v1(158.57,28.79)
  IN1 w0.086: v1(179.37,136.21) 178.91,136.67 176.47,136.67 175.89,137.25 175.89,137.96 173.88,139.97 173.88,144.77 176.77,147.67 180.52,147.67 182.06,149.21 182.06,171.17 180.51,172.73 173.27,172.73 171.94,174.06 171.24,174.06 170.29,173.11 165.33,173.11 161.44,169.22 158.68,169.22 157.65,168.19 153.16,168.19 152.15,167.19 149.03,167.19 148.12,166.28 146.02,166.28 145.16,165.42 143.18,165.42 141.23,167.37 138.67,167.37 137.87,166.57 137.86,166.57 137.13,165.84 128.21,165.84 125.5,163.13 125.5,160.98 123.71,159.19 115.22,159.19 112.79,156.76 112.79,156.06 111.72,154.98 111.72,144.46 111.13,143.87 107.57,143.87 103.03,148.41 103.03,150.16 97.83,155.37 97.83,158.63 97.68,158.78 97.68,162.55 96.65,163.59 91.78,163.59 90.87,162.67 86.62,162.67 86.08,163.21 81.02,163.21 80.28,162.47 77.99,162.47 77.61,162.86 77.61,163.96 77.05,164.52 75.61,164.52 75.25,164.15 75.25,161.67 75.2,161.62 75.2,159.96 74.95,159.71 66.13,159.71 v1(65.81,159.38) ; v1(73.73,24.4) 73.73,24.93 74.12,25.31 75.57,25.31 79.97,29.72 81.93,29.72 82.28,29.37 82.53,29.37 82.76,29.14 82.76,28.78 83.23,28.31 83.98,28.31 84.06,28.24 84.54,28.24 85.01,27.76 86.82,27.76 86.94,27.89 86.95,27.89 86.98,27.92 88.7,27.92 88.89,28.1 91.07,28.1 91.5,28.53 92.26,28.53 92.85,29.11 95.15,29.11 95.62,28.64 96.71,28.64 97.25,28.1 97.25,27.66 97.93,26.98 98.68,26.98 v1(98.93,26.73)
  IN3 w0.089: v1(179.37,136.21) 180.02,136.21 181.41,134.82 181.41,132.81 182.03,132.2 182.03,106.65 182.03,89.83 184.89,86.96 184.89,81.5 181.41,78.02 181.41,73.23 192.76,61.88 202.19,61.88 204.41,59.66 204.41,55.67 203.57,54.83 202.05,54.83 200.83,56.05 199.79,56.05 199.03,55.29 v1(199.03,54.55) 199.13,54.45 201.11,54.45 202.41,53.15 221.63,53.15 223.54,51.25 225,51.25 v1(225.55,51.79) 225.55,52.44 226.8,53.7 238.36,53.7 239.44,54.78 241.45,54.78 243.35,52.87 245.31,52.87 245.79,53.36 247.85,53.36 248.84,54.35 250.03,54.35 254.37,58.69 254.78,58.69 256.5,60.41 258.72,60.41 260.34,58.79 273.56,58.79 v1(273.96,59.19)
  IN4 w0.086: v1(98.93,26.73) 99.16,26.73 99.4,26.49 110.55,26.49 112.34,28.28 135.4,28.28 135.43,28.31 147.94,28.31 148.56,27.68 157.46,27.68 v1(158.57,28.79) 159.48,27.89 163.33,27.89 164.45,29.01 172.19,29.01 172.57,29.39 177.04,29.39 178.81,31.16 v1(178.81,31.26)
  BOTTOM w0.14: PQ49.2 218.2,57.54 218.2,56.71 218.67,56.25 219.77,56.25 PR486.1 221.06,57.55 222.93,57.55 223.89,56.59 PR494.1 224.55,55.03 225.55,54.04 v1(225.55,51.79) 226.12,51.79 226.46,52.14 231.13,52.14 232.18,51.09 PR512.2 ; v1(199.03,54.55) 198.86,54.39 198.86,53.7 198.52,53.36 198.11,53.36 196.13,55.34 191.41,55.34 191.13,55.61 189.32,55.61 188.99,55.29 188.34,55.29 188.02,55.6 187.48,55.6 185.11,53.23 185.11,52.95 184.22,52.06 183.77,52.06 181.88,50.18 181.88,46.68 182.37,46.19 182.37,45.25 181.78,44.67 181.78,41.12 182.39,40.51 182.39,39.77 181.66,39.04 181.66,35.64 178.81,32.78 v1(178.81,31.26) ; PR567.2 73.81,24.32 v1(73.73,24.4)
MAINON_ON_G: length 159.1
  TOP w0.14: PR85.1 180.44,156.41 PQ8.2 180.09,153.48 180.67,152.89 v1(180.67,152.63) 180.86,152.63 PQ9.2 180.26,150.52 180.26,149.16 PQ11.2
  IN3 w0.089: v1(180.67,152.63) 180.67,151.51 174.24,145.08 174.24,139 176.4,136.84 179.81,136.84 181.7,134.94 181.7,132.93 182.32,132.32 182.32,89.95 185.18,87.08 185.18,81.38 181.7,77.9 181.7,73.35 192.88,62.17 202.31,62.17 205.34,59.14 v1(216.52,59.14)
  BOTTOM w0.14: PR467.2 178.75,154.22 180.34,152.63 v1(180.67,152.63) PQ42.2 182.11,153.13 182.11,155.56 PQ41.2 ; PQ51.2 218.73,55.47 217.23,56.97 PQ49.3 217.23,58.43 v1(216.52,59.14)
MB_THRMTRIP#: length 6.3
  BOTTOM w0.14: R666.2 20.57,157.9 20.97,157.5 D88.1 21.99,156.12 24.02,156.12 24.36,156.47 U38.4
MBCLK: length 91.2
  TOP w0.14: U18.110 78.23,35.96 78.54,36.26 v1(78.54,36.67) 78.66,36.79 R274.1 78.99,37.15 79.14,37.3 79.14,39.19 78.85,39.48 R238.1 ; v1(77.04,52.24) 76.56,52.24 PD4.1
  IN4 w0.086: v1(78.54,36.67) 78.47,36.67 76.59,34.79 75.63,34.79 74.16,33.32 74.16,32.23 73.7,31.76 73.34,31.76 73.1,31.53 73.1,30.74 72.72,30.36 69.46,30.36 68.7,31.12 67.48,31.12 65.95,32.65 65.95,35.31 66.1,35.47 66.1,36.29 65.91,36.48 65.91,42.46 63.03,45.34 63.03,47.82 63.7,48.49 64.99,48.49 66.87,50.37 68.44,50.37 68.71,50.64 70.41,50.64 70.65,50.88 72.28,50.88 72.8,50.36 74.71,50.36 76.6,52.24 v1(77.04,52.24)
  BOTTOM w0.14: v1(77.04,52.24) 76.91,52.11 PR502.1 76.06,53.14 PC410.1 76.55,53.16 77.44,54.04 77.44,54.54 78.02,55.12 80.19,55.12 80.86,54.45 80.86,53.79 81.82,52.84 v1(82.54,52.84) 83.46,52.84 83.97,53.34 83.97,55.73 84.81,56.58 87.88,56.58 88.1,56.81 89.73,56.81 90.04,57.12 90.04,58.1 91.11,59.17 91.11,59.36 91.8,60.05 93.29,60.05 93.84,59.5 94.03,59.5 94.51,59.03 94.51,57.27 95.04,56.74 96.87,56.74 97.41,56.19 PR498.1
MBCLK1_GPU: length 69.9
  TOP w0.14: QG10.3 26.33,86.65 26,86.33 26,84.87 v1(26.08,84.79) ; PR304.1 33.5,47.06 33.9,46.65 v1(34.01,46.65) 34.12,46.77 34.47,46.77 PR305.2
  IN4 w0.086: v1(26.08,84.79) 25.79,84.5 25.79,84.23 24.83,83.27 24.83,80.57 23.08,78.82 23.08,78.25 22.56,77.73 16.09,77.73 15.41,77.05 15.41,69.08 14.46,68.13 14.46,66.14 15.56,65.04 15.56,61.18 17.65,59.09 20.67,59.09 20.92,58.84 22.52,58.84 23.64,57.72 23.64,55.97 23.84,55.77 26.36,55.77 26.79,56.2 32.78,56.2 33.9,55.08 35.07,55.08 35.42,54.73 35.42,47.54 34.88,47 34.35,47 v1(34.01,46.65)
MBCLK_CONN: length 1.8
  BOTTOM w0.254: PR502.2 75.61,51.6 76.18,51.04 PJ22.5
MBDATA: length 87.9
  TOP w0.14: PD5.1 78.53,51.27 v1(78.77,51.5) ; U18.111 v1(77.83,36.66) 77.84,36.66 R275.1 78.1,37.12 78.24,37.26 78.24,38.14 77.97,38.41 v1(77.97,38.8) R237.1
  IN4 w0.086: v1(78.77,51.5) 78,50.73 75.72,50.73 74.9,49.91 72.62,49.91 72.1,50.44 70.83,50.44 70.59,50.2 68.89,50.2 68.62,49.93 67.05,49.93 65.17,48.05 63.88,48.05 63.47,47.64 63.47,45.53 66.35,42.64 66.35,36.66 66.54,36.47 66.54,35.28 66.39,35.13 66.39,32.84 67.66,31.57 68.88,31.57 69.64,30.8 72.4,30.8 72.66,31.07 72.66,31.71 73.15,32.2 73.51,32.2 73.72,32.41 73.72,33.5 75.45,35.23 76.41,35.23 v1(77.83,36.66)
  BOTTOM w0.14: PR497.1 96.98,55.74 96.98,55.92 96.66,56.24 94.83,56.24 94.01,57.06 94.01,58.82 93.83,59.01 93.63,59.01 93.08,59.55 92,59.55 91.6,59.16 91.6,58.96 90.53,57.89 90.53,56.91 89.93,56.31 88.31,56.31 88.08,56.09 85.02,56.09 84.46,55.53 84.46,53.14 83.66,52.34 81.58,52.34 v1(81.12,52.8) 80.37,53.55 80.37,54.24 79.99,54.62 78.23,54.62 77.94,54.33 77.94,53.84 77.74,53.65 PR501.1 78.25,52.59 78.5,52.34 PC409.1 78.8,51.83 78.77,51.8 v1(78.77,51.5)
MBDATA1_GPU: length 67.9
  TOP w0.14: v1(25.39,84.7) 25.6,84.91 25.6,85.2 25.45,85.35 QG10.6 ; PR297.2 34.08,47.41 v1(33.98,47.31) 33.92,47.26 33.78,47.26 33.34,47.7 PR293.1
  IN4 w0.086: v1(33.98,47.31) 34.09,47.21 34.79,47.21 35.21,47.63 35.21,54.64 34.98,54.87 33.81,54.87 32.7,55.99 26.88,55.99 26.45,55.56 23.75,55.56 23.43,55.88 23.43,57.63 22.43,58.63 20.83,58.63 20.58,58.88 17.56,58.88 15.35,61.09 15.35,64.95 14.24,66.06 14.24,68.22 15.2,69.17 15.2,77.14 16,77.94 22.48,77.94 22.87,78.34 22.87,78.91 24.61,80.65 24.61,83.36 25.57,84.32 25.57,84.52 v1(25.39,84.7)
MBDATA_CONN: length 1.8
  BOTTOM w0.254: PJ22.4 78.18,51.34 77.74,51.77 PR501.2
MCR_LED_CTL_B: length 94.7
  TOP w0.14: v1(10.54,77.5) 10.55,77.48 10.55,77.22 10.11,76.78 U4.21 ; R560.2 50.12,16.03 Q43.2 50.71,16.99 50.31,17.39 50.31,17.66 50,17.97 v1(49.74,17.97) 48.71,19 v1(48.71,19.07)
  IN3 w0.089: v1(10.54,77.5) 10.55,77.5 11.15,76.9 11.15,74.31 10.38,73.53 10.38,70.15 10.14,69.92 10.14,64.74 10.46,64.42 10.46,60.97 11.07,60.35 11.07,56.16 12.75,54.48 14.06,54.48 15.02,53.52 15.02,51.1 15.77,50.35 15.77,48.71 16.1,48.38 16.1,47.06 17.37,45.79 17.37,45.4 18.62,44.15 18.62,43.67 19.4,42.89 19.4,40.08 21.66,37.82 21.99,37.82 22.43,37.38 27.92,37.38 28.13,37.18 29.77,37.18 29.96,36.99 34.8,36.99 36.66,35.13 37.39,35.13 38.3,34.21 39.91,34.21 40.64,33.49 42,33.49 43.02,32.47 44.93,32.47 45.48,31.92 45.48,31.23 45.76,30.95 46.64,30.95 47.05,30.55 48.17,30.55 48.55,30.17 v1(48.59,30.17)
  IN4 w0.086: v1(48.71,19.07) 48.89,19.24 48.89,20.03 47.92,21 47.92,25.62 48.66,26.36 48.66,28.97 48.59,29.04 48.59,30.17 v1(48.59,30.17)
MCR_LED_CTL_G: length 127
  TOP w0.14: v1(76.75,14.77) 76.75,14.55 R590.2 75.96,13.76 Q51.2 ; U4.20 10.51,76.68 11.44,77.61 12.88,77.61 v1(13.01,77.49)
  IN3 w0.089: v1(76.75,14.77) 76.75,14.55 75.91,13.71 68.22,13.71 66.94,15 63.07,15 62.55,15.52 62.55,18.27 63.39,19.12 64.71,19.12 65.17,19.57 65.17,20.34 64.58,20.93 63.38,20.93 62.1,22.22 61.19,22.22 59.27,24.14 57.09,24.14 55.03,26.2 53.86,26.2 53.74,26.08 51.97,26.08 51.58,26.46 51.58,27.19 51.2,27.57 51.2,28.64 51.37,28.81 51.37,29.52 50.88,30.01 50.29,30.01 48.59,31.71 46.41,31.71 45.46,32.66 43.1,32.66 42.08,33.68 40.72,33.68 39.99,34.4 38.38,34.4 37.46,35.32 36.74,35.32 34.88,37.18 30.08,37.18 29.9,37.37 28.21,37.37 28,37.57 22.51,37.57 22.07,38.01 21.74,38.01 19.59,40.16 19.59,42.97 18.81,43.75 18.81,44.23 17.56,45.48 17.56,45.87 16.29,47.13 16.29,48.46 16.05,48.71 16.05,50.54 15.33,51.25 15.33,53.48 14.12,54.69 12.81,54.69 11.26,56.23 11.26,60.43 10.65,61.05 10.65,64.5 10.33,64.82 10.33,69.71 11.34,70.72 11.34,76.52 12.31,77.49 13.01,77.49 v1(13.01,77.49)
MCR_LED_CTL_R: length 120.8
  TOP w0.14: Q51.5 72.67,13.76 R589.2 72.11,14.32 71.88,14.55 v1(71.88,14.73) ; U4.19 10.91,76.68 11.4,77.17 12.67,77.17 12.82,77.03 13.16,77.03 v1(13.43,76.75)
  IN3 w0.089: v1(13.43,76.75) 13.1,77.09 12.18,77.09 11.53,76.44 11.53,70.64 10.52,69.63 10.52,64.89 10.84,64.58 10.84,61.13 11.46,60.51 11.46,56.31 12.89,54.88 14.2,54.88 15.52,53.56 15.52,51.33 16.24,50.62 16.24,48.78 16.48,48.54 16.48,47.21 17.75,45.95 17.75,45.56 19,44.31 19,43.83 19.78,43.05 19.78,40.24 21.82,38.2 22.15,38.2 22.59,37.76 28.08,37.76 28.28,37.56 29.98,37.56 30.16,37.37 34.96,37.37 36.82,35.51 37.54,35.51 38.46,34.59 40.07,34.59 40.79,33.87 42.16,33.87 43.18,32.85 45.54,32.85 46.49,31.9 48.67,31.9 50.37,30.2 50.96,30.2 51.18,29.98 52.29,29.98 52.98,29.29 52.98,27.42 54.01,26.39 55.11,26.39 57.17,24.33 59.35,24.33 61.27,22.41 62.18,22.41 62.75,21.84 63.94,21.84 65.36,20.42 65.36,19.5 64.79,18.93 63.47,18.93 62.74,18.19 62.74,15.6 63.15,15.19 67.02,15.19 68.3,13.9 71.01,13.9 71.83,14.73 v1(71.88,14.73)
MCR_LED_EN_B: length 33.2
  TOP w0.508: v1(75.66,15.33) 75.2,15.79 D67.1 ; Q43.3 53.05,15.32 v1(53.05,14.22)
  IN2 w0.508: v1(53.05,14.22) 53.05,14.95 54.55,16.45 57.5,16.45 57.83,16.12 58.34,16.12 58.77,15.69 58.95,15.69 59.76,14.88 67.41,14.88 68.56,16.02 69.69,16.02 69.82,16.15 74.85,16.15 v1(75.66,15.33)
  BOTTOM w0.254: CN19.32 73.15,18.33 73.38,18.1 73.38,17.64
  BOTTOM w0.508: v1(75.66,15.33) 74.44,16.55 74.34,16.55 73.38,17.5 73.38,17.64
MCR_LED_EN_G: length 11.5
  TOP w0.508: D66.1 74.19,15.87 v1(74.96,15.09) ; v1(72.66,12.69) 73.1,12.69 Q51.6
  BOTTOM w0.254: CN19.33 72.65,18.33 72.73,18.24 72.73,17.83
  BOTTOM w0.508: 72.73,17.83 72.73,17.24 74.07,15.9 74.15,15.9 v1(74.96,15.09) 74.21,14.34 74.21,13.42 73.49,12.69 v1(72.66,12.69)
MCR_LED_EN_R: length 8.1
  TOP w0.508: v1(72.74,15.43) 72.74,15.69 73.17,16.12 D65.1 73.42,16 73.42,15.56 v1(73.69,15.29) 73.82,15.29 74.71,14.41 Q51.3
  BOTTOM w0.254: CN19.34 72.15,18.1 72.09,18.03 72.09,17.97
  BOTTOM w0.508: v1(72.74,15.43) 72.74,16.3 72.09,16.95 72.09,17.97
MCR_LED_PWR_1: length 9.1
  TOP w0.254: v1(68.9,15.37) 69.11,15.57 D61.1 69.05,16.25 67.95,15.15 66.87,15.15 66.33,14.61 Q45.3
  BOTTOM w0.254: CN19.38 70.15,18.03 69.06,16.93 69.06,15.52 v1(68.9,15.37)
MCR_LED_PWR_2: length 9
  TOP w0.254: v1(70.17,15.47) 70.17,16.33 D62.1 69.64,15.77 69.64,15.14 69.23,14.73 69.23,13.5 68.96,13.23 Q50.6
  BOTTOM w0.254: v1(70.17,15.47) 70.17,15.64 70.13,15.68 70.13,17.45 70.65,17.97 CN19.37
MCR_LED_PWR_3: length 7
  TOP w0.254: v1(71.22,15.41) 71.22,16.3 D63.1 70.69,15.81 70.69,15.2 Q50.3
  BOTTOM w0.254: CN19.36 71.15,16.56 71.25,16.45 71.25,16.09 71.22,16.07 v1(71.22,15.41)
MCR_LED_PWR_CTL_1: length 111.2
  TOP w0.14: v1(64.17,16.63) 64.17,17.17 64.44,17.44 R519.2 64.94,17.44 65.42,16.96 Q45.5 ; v1(13.64,75.76) 13.55,75.67 13.11,75.67 12.93,75.48 U4.16
  IN3 w0.089: v1(64.17,16.63) 64.32,16.78 65.89,16.78 67.09,17.99 67.09,20.62 65.91,21.81 65.91,23.09 66.41,23.59 66.41,24.51 65.02,25.9 64.33,25.9 63.86,26.38 59.84,26.38 58.82,27.39 56.82,27.39 54.51,29.7 53.94,29.7 52.66,30.99 51.73,30.99 51.15,31.56 50.49,31.56 48.44,33.61 47,33.61 46.81,33.42 43.41,33.42 41.67,35.17 39.58,35.17 38.66,36.08 37.06,36.08 32.97,40.17 31.39,40.17 29.34,38.13 28.52,38.13 27.53,39.12 26.71,39.12 25.91,38.33 22.83,38.33 22.39,38.77 22.11,38.77 20.35,40.53 20.35,43.29 19.57,44.07 19.57,44.81 19.93,45.17 19.93,45.58 18.45,47.07 18.45,47.86 16.86,49.45 16.86,50.83 16.17,51.52 16.17,54.01 14.55,55.63 13.48,55.63 12.86,56.25 12.86,56.72 12.03,57.56 12.03,60.54 12.39,60.9 12.39,65.88 12.78,66.27 12.78,68.83 12.1,69.51 12.1,74.67 13.19,75.76 v1(13.64,75.76)
MCR_LED_PWR_CTL_2: length 119.9
  TOP w0.14: v1(13.11,76.16) 12.99,76.04 12.34,76.04 12.19,76.18 U4.17 ; Q50.2 71,13.88 R588.2 71.27,14.52 v1(71.01,14.77)
  IN3 w0.089: v1(71.01,14.77) 71.01,14.75 70.36,14.09 68.38,14.09 67.1,15.38 64.03,15.38 63.76,15.65 63.76,16.79 64.01,17.03 64.02,17.03 64.09,17.1 65.8,17.1 66.9,18.2 66.9,20.54 65.72,21.73 65.72,22.88 64.86,23.74 63.47,23.74 63.04,24.17 62.68,24.17 62.05,23.54 61.59,23.54 61.2,23.92 60.3,23.92 58.86,25.36 56.68,25.36 55.21,26.83 54.3,26.83 53.36,27.77 53.36,29.45 52.45,30.36 51.34,30.36 51.11,30.59 50.53,30.59 48.83,32.28 46.65,32.28 45.7,33.23 43.33,33.23 41.59,34.97 39.5,34.97 38.59,35.89 36.98,35.89 32.89,39.98 31.47,39.98 29.42,37.94 28.44,37.94 27.45,38.93 26.79,38.93 25.99,38.14 22.75,38.14 22.31,38.58 21.98,38.58 20.16,40.4 20.16,43.21 19.38,43.99 19.38,44.92 19.74,45.27 19.74,45.5 18.25,46.99 18.25,47.67 16.67,49.25 16.67,50.75 15.98,51.45 15.98,53.93 14.65,55.26 13.05,55.26 11.84,56.47 11.84,60.62 12.2,60.98 12.2,66.07 12.53,66.4 12.53,68.82 11.91,69.43 11.91,74.96 v1(13.11,76.16)
MCR_LED_PWR_CTL_3: length 117.9
  TOP w0.14: v1(12.62,76.58) 12.31,76.89 11.52,76.89 11.31,76.68 U4.18 ; Q50.5 67.34,13.88 R582.2 67.02,13.57 67.02,12.93 v1(66.86,12.76) 66.68,12.59 64.2,12.59 63.2,13.59 v1(63.2,15.7)
  IN3 w0.089: v1(63.2,15.7) 63.57,16.07 63.57,16.87 64,17.29 65.72,17.29 66.2,17.77 66.2,20.97 65.14,22.03 62.82,22.03 62.26,22.6 61.35,22.6 59.43,24.52 57.25,24.52 55.19,26.58 54.09,26.58 53.17,27.5 53.17,29.37 52.37,30.17 51.26,30.17 51.03,30.39 50.45,30.39 48.75,32.09 46.57,32.09 45.62,33.04 43.26,33.04 42.24,34.06 40.87,34.06 40.15,34.78 38.54,34.78 37.62,35.7 36.9,35.7 32.81,39.79 31.55,39.79 29.5,37.75 28.36,37.75 27.37,38.74 26.86,38.74 26.07,37.95 22.67,37.95 22.23,38.39 21.9,38.39 19.97,40.32 19.97,43.13 19.19,43.91 19.19,44.39 17.94,45.64 17.94,46.03 17.28,46.68 17.28,48.37 16.48,49.17 16.48,50.64 15.71,51.41 15.71,53.72 14.36,55.07 12.97,55.07 11.65,56.39 11.65,60.59 11.03,61.21 11.03,62.01 12.01,62.98 12.01,66.26 12.34,66.59 12.34,68.74 11.72,69.35 11.72,75.83 12.48,76.58 v1(12.62,76.58)
MCR_LED_PWR_CTL_P: length 115
  TOP w0.14: U4.15 13.2,75.08 v1(13.31,75.19) ; v1(64.16,15.81) 63.8,15.45 v1(63.8,14.92) 63.8,13.39 64.32,12.87 65.46,12.87 65.69,13.1 R596.2 65.42,13.64 Q45.2
  IN3 w0.089: v1(64.16,15.81) 65.19,15.81 67.28,17.91 67.28,20.7 66.1,21.89 66.1,23.01 66.6,23.51 66.6,24.59 65.1,26.09 64.41,26.09 63.93,26.57 60.62,26.57 59.46,27.72 59.46,27.91 58.85,28.52 56.39,28.52 53.27,31.63 53.27,32.32 52.57,33.02 49.3,33.02 48.52,33.8 46.92,33.8 46.73,33.61 46.42,33.61 45.46,34.58 45.46,35.02 44.77,35.71 42.29,35.71 41.94,35.36 39.66,35.36 38.74,36.27 37.14,36.27 32.12,41.29 28.6,41.29 25.84,38.52 22.9,38.52 22.46,38.96 22.19,38.96 20.54,40.61 20.54,43.37 19.76,44.15 19.76,44.73 20.12,45.09 20.12,45.66 18.64,47.15 18.64,47.94 17.05,49.53 17.05,50.91 16.36,51.6 16.36,54.09 14.62,55.82 13.56,55.82 13.05,56.33 13.05,56.8 12.22,57.64 12.22,60.42 12.58,60.79 12.58,65.8 12.97,66.19 12.97,68.91 12.29,69.59 12.29,74.3 13.18,75.19 v1(13.31,75.19)
MCR_LED_PWR_CTL_T: length 92.7
  TOP w0.14: U4.22 9.71,77.04 v1(9.92,77.26) ; Q36.2 51.29,20.42 50.82,20.9 49.67,20.9 R462.2 48.97,20.68 48.23,19.93 v1(48.23,19.55)
  IN3 w0.089: v1(47.95,30.11) 47.21,30.11 46.56,30.76 45.68,30.76 45.29,31.15 45.29,31.81 44.87,32.23 42.99,32.23 41.92,33.3 40.56,33.3 39.83,34.02 38.22,34.02 37.31,34.94 36.58,34.94 34.72,36.8 29.88,36.8 29.69,36.99 28.05,36.99 27.84,37.19 22.35,37.19 21.91,37.63 21.58,37.63 19.21,40 19.21,42.82 18.43,43.59 18.43,44.07 17.18,45.32 17.18,45.71 16.19,46.7 16.11,46.7 15,47.81 15,48.35 15.35,48.7 15.35,50.5 14.83,51.02 14.83,53.44 13.98,54.29 12.67,54.29 10.88,56.08 10.88,60.28 10.27,60.89 10.27,64.34 9.95,64.66 9.95,70 10.19,70.23 10.19,73.61 10.96,74.39 10.96,76.22 v1(9.92,77.26)
  IN4 w0.086: v1(47.95,30.11) 47.95,28.62 47.74,28.41 47.74,20.57 48.23,20.08 v1(48.23,19.55)
MCR_LED_PWR_P: length 9.9
  TOP w0.254: v1(67.3,15.73) 67.73,15.73 68.09,16.09 D60.1 67,16.25 66.75,16 66.75,15.75 66.5,15.5 65.12,15.5 64.77,15.84 Q45.6
  BOTTOM w0.254: CN19.39 69.65,18.14 67.3,15.79 v1(67.3,15.73)
MCR_LED_PWR_T: length 36.7
  TOP w0.254: R472.1 53.3,19.46 Q36.3 53.57,18.75 52.14,17.31 v1(51.83,17.31) ; v1(71.88,15.43) 71.88,15.98 D64.1
  IN4 w0.254: v1(51.83,17.31) 51.83,16.81 52.44,16.2 57.3,16.2 57.83,16.73 57.83,18.21 58.13,18.52 58.53,18.52 58.54,18.51 59.84,18.51 60.17,18.18 60.17,17.29 62.23,15.22 67.16,15.22 67.62,14.75 70.23,14.75 70.68,15.21 70.68,15.76 70.86,15.94 71.37,15.94 v1(71.88,15.43)
  BOTTOM w0.254: v1(71.88,15.43) 71.88,16.38 71.57,16.7 71.57,18.38 71.65,18.46 CN19.35
MCR_LED_T_CTL_B: length 95.2
  TOP w0.14: Q44.2 55.15,17.82 R506.2 55.42,18.68 v1(55.42,20.88) ; U4.25 7.14,75.48 v1(6.83,75.18)
  IN2 w0.089: v1(55.42,20.88) 55.64,21.11 55.64,22.38 55.51,22.51 54.18,22.51 53.55,23.15 53.55,24.84 52.56,25.82 51.45,25.82 51.19,26.08 48.18,26.08 44.68,29.57 44.68,29.83 44.16,30.36 42.63,30.36 42.11,30.88 38.8,30.88 37.48,32.2 33.95,32.2 33.47,32.68 29.45,32.68 28.78,33.34 26.07,33.34 25.38,34.03 25.1,34.03 23.03,36.1 23.03,36.76 19.58,40.21 19.58,42.62 17.6,44.6 17.6,46.21 18.25,46.87 18.25,47.94 17.11,49.09 17.11,53.42 15.35,55.18 13.06,55.18 12.45,55.79 11.86,55.79 10.81,56.84 10.81,60.35 9.34,61.82 9.34,64.39 9.21,64.51 9.21,69.53 9.42,69.74 9.42,71.31 7.37,73.35 7.37,74.64 v1(6.83,75.18)
MCR_LED_T_CTL_G: length 128.1
  TOP w0.14: v1(6.82,75.87) 7.08,75.87 7.1,75.85 8.27,75.85 8.6,76.18 U4.24 ; Q52.2 80.79,13.76 81.18,14.15 R592.2 81.43,14.52 81.71,14.8 81.71,15.24 82.15,15.69 v1(82.7,15.69)
  IN2 w0.089: v1(82.7,15.69) 82.51,15.5 81.82,15.5 80.58,16.74 69.57,16.74 69.45,16.61 67.8,16.61 67.55,16.37 65.23,16.37 64.04,17.56 63.39,17.56 62.85,18.09 60.84,18.09 59.51,19.42 57.07,19.42 55.9,20.59 55.9,22.39 55.59,22.7 54.26,22.7 53.74,23.23 53.74,24.92 52.64,26.01 51.53,26.01 51.27,26.27 48.26,26.27 44.88,29.65 44.88,29.91 44.24,30.55 42.71,30.55 41.82,31.44 40.38,31.44 38.75,33.07 36.25,33.07 35.28,34.04 33.9,34.04 33.66,33.8 32.96,33.8 32.02,32.87 29.53,32.87 28.86,33.53 26.15,33.53 25.83,33.85 25.83,35.26 25.75,35.33 25.75,36.76 25.08,37.44 22.62,37.44 19.77,40.29 19.77,42.7 17.79,44.68 17.79,46.13 18.44,46.79 18.44,48.02 17.3,49.16 17.3,53.5 15.43,55.37 13.14,55.37 12.52,55.98 11.94,55.98 11,56.92 11,60.43 9.53,61.9 9.53,64.46 9.4,64.59 9.4,69.45 9.61,69.66 9.61,71.38 7.56,73.43 7.56,75.73 7.43,75.87 v1(6.82,75.87)
MCR_LED_T_CTL_R: length 131.3
  TOP w0.14: U4.23 9.31,76.68 9.05,76.93 8.72,76.93 8.57,76.79 7.7,76.79 v1(7.46,76.54) 6.82,76.54 v1(6.81,76.53) ; R591.2 77.75,13.76 Q52.5 79.24,13.76 79.5,14.01 79.5,14.85 80.3,15.66 80.31,15.66 80.34,15.69 81.76,15.69 v1(82.24,16.17)
  IN2 w0.089: v1(6.81,76.53) 7.03,76.53 7.75,75.81 7.75,73.51 9.8,71.46 9.8,69.58 9.59,69.37 9.59,64.67 9.72,64.54 9.72,61.98 11.68,60.02 11.68,56.58 12.08,56.18 12.34,56.18 12.34,56.17 12.6,56.17 13.22,55.56 15.51,55.56 17.49,53.58 17.49,52.7 17.49,52.7 17.82,52.37 17.82,50.92 18.33,50.41 18.33,48.4 18.63,48.1 18.63,46.71 17.98,46.05 17.98,44.76 19.96,42.78 19.96,40.37 22.7,37.63 25.16,37.63 25.94,36.84 25.94,35.41 26.02,35.34 26.02,33.93 26.22,33.72 28.94,33.72 29.6,33.06 31.94,33.06 32.88,34 33.57,34 33.81,34.23 35.36,34.23 36.33,33.26 38.83,33.26 40.46,31.63 41.9,31.63 42.79,30.74 44.32,30.74 45.07,29.99 45.07,29.73 48.34,26.46 51.35,26.46 51.61,26.2 52.72,26.2 53.93,25 53.93,23.31 54.34,22.89 55.67,22.89 56.13,22.43 56.13,20.67 57.18,19.61 59.59,19.61 60.92,18.28 62.93,18.28 63.47,17.75 64.15,17.75 65.34,16.56 67.47,16.56 67.72,16.8 69.37,16.8 69.49,16.93 80.77,16.93 81.53,16.17 v1(82.24,16.17)
MCR_LED_T_EN_B: length 31.1
  TOP w0.508: Q44.3 56.46,15.79 v1(56.38,15.71) ; v1(78.12,15.21) 78.12,16.13 D70.1
  IN2 w0.508: v1(78.12,15.21) 78.12,14.49 77.62,13.99 68.08,13.99 67.81,14.27 59.51,14.27 58.7,15.08 58.52,15.08 58.09,15.51 57.58,15.51 57.3,15.79 56.46,15.79 v1(56.38,15.71)
  BOTTOM w0.254: CN19.29 74.65,18.78 74.96,18.46 75.35,18.46 76.12,17.69 76.19,17.69
  BOTTOM w0.508: 76.19,17.69 78.12,15.76 v1(78.12,15.21)
MCR_LED_T_EN_G: length 10.5
  TOP w0.508: Q52.6 78.18,12.69 v1(77.64,12.69) ; v1(77.41,15.1) 77.39,15.13 77.39,15.74 77.23,15.89 D69.1
  BOTTOM w0.254: CN19.30 74.15,18.57 74.69,18.02 74.92,18.02 75.3,17.64
  BOTTOM w0.508: 75.3,17.64 77.39,15.56 77.39,15.13 v1(77.41,15.1) 77.41,15 77.64,14.77 v1(77.64,12.69)
MCR_LED_T_EN_R: length 11.8
  TOP w0.508: v1(80.54,15.23) 80.19,14.89 Q52.3 ; v1(76.57,15.43) 76.57,15.51 76.22,15.87 D68.1
  IN2 w0.508: v1(76.57,15.43) 76.6,15.46 76.6,15.56 77.11,16.07 80.03,16.07 80.54,15.56 v1(80.54,15.23)
  BOTTOM w0.254: CN19.31 73.65,18.51 73.88,18.28 73.88,18.03 74.26,17.64
  BOTTOM w0.508: 74.26,17.64 74.58,17.33 74.7,17.33 76.57,15.46 v1(76.57,15.43)
MCU_INT#: length 104.4
  TOP w0.14: U18.113 77.03,34.28 v1(76.45,33.7) ; v1(8.31,70.68) 8.7,70.28 R118.2 9.04,70.31 9.04,70.61 9.71,71.28 U4.3
  IN3 w0.089: v1(14.22,64.68) 14.24,64.66 14.24,63.92 14.64,63.52 14.64,61.87 15.46,61.06 15.46,60.17 15.72,59.9 15.73,59.9 15.99,59.64 15.99,59.64 17.11,58.51 17.11,55.85 17.69,55.27 17.69,52.16 18.2,51.65 18.96,51.65 20.68,49.93 20.68,48.1 22.27,46.5 25.81,46.5 27.08,45.24 27.96,45.24 28.47,45.75 28.47,46.89 27.49,47.87 27.49,48.36 27.87,48.74 28.38,48.74 28.73,48.39 28.73,47.97 29.23,47.47 29.23,46.56 31.18,44.62 31.28,44.62 32.28,43.62 32.28,43.46 36.6,39.14 38.13,39.14 38.74,38.53 41.62,38.53 41.74,38.65 45.31,38.65 45.44,38.79 46.95,38.79 47.23,39.06 47.23,39.47 47.55,39.79 48.23,39.79 50.14,37.88 53.58,37.88 54.25,37.21 57.29,37.21 57.95,36.55 59.35,36.55 59.89,36.02 61.41,36.02 61.77,35.66 63.37,35.66 64.13,36.41 66.1,36.41 67.29,35.22 67.87,35.22 67.92,35.17 68.62,35.17 68.93,34.86 71.42,34.86 71.95,34.33 74.66,34.33 74.85,34.14 76.01,34.14 v1(76.45,33.7)
  BOTTOM w0.14: v1(14.22,64.68) 13.33,64.68 12.93,65.08 12.93,66 12.45,66.48 10.86,66.48 8.91,68.43 8.91,70.08 v1(8.31,70.68)
ME_WR#: length 162.7
  TOP w0.14: v1(206.56,18.41) 206.1,17.95 205.63,17.95 205.28,18.3 R493.2 ; v1(182.59,40.96) 184.47,40.96 185.36,40.07 185.36,39.46 185.92,38.9 185.92,34.24 187.08,33.08 187.08,29.74 186.61,29.27 186.61,26.33 189.29,23.64 189.29,19.58 190.77,18.1 v1(190.77,17.87) ; v1(79.61,38.97) 79.58,38.95 79.58,38.37 79.44,38.23 79.44,37.04 79.28,36.88 79.28,36.37 79.05,36.14 78.95,36.14 78.63,35.83 U18.109
  IN1 w0.086: v1(206.56,18.41) 205.59,17.44 204.59,17.44 202.24,15.09 192.35,15.09 190.77,16.67 v1(190.77,17.87)
  IN3 w0.089: v1(182.59,40.96) 178.93,40.96 176.06,38.08 100.43,38.08 100.09,38.42 96.87,38.42 95.93,39.36 92.09,39.36 91.83,39.62 91.53,39.62 91.33,39.82 90.04,39.82 89.63,39.41 87.61,39.41 87.2,39.82 86.63,39.82 86.46,39.65 85.91,39.65 85.42,40.14 82.2,40.14 80.44,38.37 79.97,38.37 79.61,38.74 v1(79.61,38.97)
  BOTTOM w0.14: R1088.2 207.13,17.16 207.08,17.11 R1053.1 206.59,17.11 206.37,17.33 206.37,18.22 v1(206.56,18.41)
MEM_VDD_CTRL: length 107.5
  TOP w0.102: v2(39.39,95.6) 39.23,95.76 39.23,95.77 39.05,95.95 UG1.BH4
  TOP w0.14: v1(11.58,171.44) 11.58,171.53 11.44,171.67 PR12.2
  IN2 w0.089: v2(39.39,95.6) 39.08,95.29 35.76,95.29 35.34,94.86 31.58,94.86 29.46,96.99 26.13,96.99 24.77,98.35 23.5,98.35 22.53,99.32 21.6,99.32 20.58,100.33 19.56,100.33 18.91,100.98 17.67,100.98 17.55,101.09 17.25,101.09 17.05,100.89 16.05,100.89 14.79,102.16 v1(13.67,102.16)
  IN3 w0.089: v1(13.67,102.16) 13.41,101.89 10.75,101.89 8.52,104.13 8.52,108.39 6.9,110.01 6.9,165.99 11.02,170.11 11.02,171.04 11.43,171.46 11.56,171.46 v1(11.58,171.44)
  BOTTOM w0.14: v2(39.39,95.6) 39.97,95.01 RG163.2
