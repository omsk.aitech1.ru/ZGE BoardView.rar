# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A6: length 76.8
  TOP w0.089: U3.AN7 143.02,108.8 v1(142.82,109)
  TOP w0.102: JDIM1.127 141.57,57.58 140.94,56.94 140.72,56.94 139.61,55.82 139.61,55.03 139.85,54.79 140.31,54.79 v1(140.74,55.22)
  IN1 w0.079: 142.31,96.77 142.07,97 142.07,104.48 143.55,105.96 143.55,108.07 142.82,108.8 v1(142.82,109)
  IN1 w0.152: 142.31,96.77 144.26,94.81 144.26,91.94 145.67,90.53 145.67,84.17 144.91,83.41 144.91,73.95 145.06,73.79 145.51,73.79 145.68,73.62 145.68,73.29 145.53,73.13 144.94,73.13 144.79,72.98 144.79,72.63 144.96,72.46 145.61,72.46 145.76,72.31 145.76,71.98 145.6,71.81 144.94,71.81 144.79,71.66 144.79,71.34 144.94,71.18 145.58,71.18 145.73,71.03 145.73,70.68 145.58,70.52 144.98,70.52 144.79,70.34 144.79,69.98 144.94,69.83 145.68,69.83 145.84,69.68 145.84,69.36 145.65,69.17 144.94,69.17 144.79,69.02 144.79,68.23 143.19,66.63 143.19,63.99 140.73,61.53 140.73,58.55 140.62,58.45 140.41,58.45 140.25,58.29 140.25,57.75 140.36,57.64 140.36,56.76 140.25,56.65 140.25,55.71 v1(140.74,55.22)
  BOTTOM w0.102: JDIM3.127 139.67,51.32 140.14,51.79 140.14,52.66 141.16,53.68 141.16,54.79 v1(140.74,55.22)
M_B_A7: length 75.8
  TOP w0.089: v1(142.83,111.67) 142.83,111.43 143.28,110.98 U3.AN10
  TOP w0.102: v1(140.74,55.99) 140.74,55.79 141.14,55.39 141.14,54.45 141.34,54.26 141.34,53.21 141.57,52.98 141.57,52.58 142.82,51.32 JDIM1.122
  IN1 w0.079: v1(142.83,111.67) 143.15,111.35 143.15,110.15 143.06,110.07 143.06,109.46 143.2,109.33 143.2,108.66 143.72,108.14 143.72,105.86 142.25,104.4 142.25,97.33 142.45,97.13
  IN1 w0.152: 142.45,97.13 144.76,94.83 144.76,92.14 146.17,90.73 146.17,83.96 145.41,83.21 145.41,74.6 146.33,73.67 146.33,69.07 143.68,66.42 143.68,63.78 141.22,61.32 141.22,57.48 140.85,57.11 140.85,56.1 v1(140.74,55.99)
  BOTTOM w0.102: v1(140.74,55.99) 140.74,55.8 140.23,55.29 140.06,55.29 139.56,55.79 139.56,56.01 139.68,56.13 140.11,56.13 140.3,56.32 140.3,56.55 140.18,56.68 139.66,56.68 139.56,56.78 139.56,56.96 139.87,57.27 140.62,57.27 140.92,57.57 JDIM3.122
M_B_A8: length 76.1
  TOP w0.089: U3.AN8 143.61,109.78 v1(143.68,109.78)
  TOP w0.102: v1(141.72,55.35) 141.72,55.54 141.6,55.66 141.45,55.66 141.36,55.57 141.25,55.57 141.15,55.67 141.15,55.98 141.32,56.15 141.32,56.31 141.22,56.42 140.84,56.42 140.74,56.52 140.74,56.66 140.81,56.73 141.02,56.73 141.06,56.78 141.3,56.78 141.43,56.91 141.43,57.15 141.61,57.33 141.71,57.33 141.78,57.25 141.78,57.21 141.88,57.11 142.06,57.11 142.19,57.24 142.19,57.46 142.07,57.57 JDIM1.125
  IN1 w0.079: v1(143.68,109.78) 143.74,109.72 143.74,108.64 144.09,108.29 144.09,105.38 143.28,104.57 143.28,101.29 143.74,100.83 143.74,97
  IN1 w0.152: 143.74,97 145.75,95 145.75,92.55 147.32,90.98 147.32,83.72 146.55,82.94 146.55,79.38 146.73,79.2 147.09,79.2 147.32,78.96 147.32,78.57 147.17,78.42 146.56,78.42 146.4,78.25 146.4,77.91 146.55,77.76 147.17,77.76 147.32,77.61 147.32,77.25 147.17,77.1 146.57,77.1 146.4,76.92 146.4,76.58 146.55,76.43 147.17,76.43 147.32,76.27 147.32,75.93 147.17,75.78 146.56,75.78 146.4,75.61 146.4,75.27 146.55,75.12 147.17,75.12 147.32,74.96 147.32,68.66 144.67,66.01 144.67,63.37 143.41,62.11 143.41,59.68 142.21,58.48 142.21,55.84 v1(141.72,55.35)
  BOTTOM w0.102: JDIM3.125 140.17,51.22 141.06,52.59 141.92,54.16 142.04,54.54 142.03,54.88 v1(141.72,55.35)
M_B_A9: length 75.9
  TOP w0.089: v1(144.65,111.83) 145.08,111.4 U3.AR11
  TOP w0.102: JDIM1.121 143.07,57.06 142.94,56.92 142.76,56.92 142.66,56.83 142.66,56.62 142.78,56.5 143.02,56.5 143.37,56.15 143.37,55.41 142.99,55.03 142.4,55.03 142.12,55.3 142.12,55.64 v1(141.72,56.05)
  IN1 w0.079: 143.52,96.63 143.52,100.78 143.08,101.22 143.08,104.75 143.92,105.59 143.92,108.2 143.41,108.72 143.41,109.42 143.23,109.59 143.23,109.96 143.31,110.05 143.31,111.99 143.55,112.23 144.24,112.23 v1(144.65,111.83)
  IN1 w0.152: 143.52,96.63 145.25,94.9 145.25,92.35 146.83,90.77 146.83,83.92 145.9,83 145.9,74.8 146.83,73.88 146.83,68.87 144.18,66.22 144.18,63.58 142.92,62.32 142.92,59.89 141.72,58.69 141.72,57.27 141.35,56.9 141.35,56.42 v1(141.72,56.05)
  BOTTOM w0.102: JDIM3.121 141.17,51.53 141.89,52.88 142.22,54.07 142.3,54.61 142.27,54.92 142.11,55.53 v1(141.72,56.05)
M_B_A10: length 76.7
  TOP w0.089: U3.AH7 139.44,108.8 v1(139.18,109.05)
  TOP w0.102: v1(133.85,53.93) 134.23,54.32 134.67,54.32 135.1,53.89 135.1,51.55 134.82,51.28 JDIM1.146
  IN1 w0.079: 138.02,98.22 138.33,98.54 138.33,105.85 138.74,106.26 138.74,108.32 138.96,108.54 138.96,108.67 138.86,108.77 138.86,108.98 138.93,109.05 v1(139.18,109.05)
  IN1 w0.152: v1(133.85,53.93) 134.1,53.93 134.28,53.75 134.28,53 134.45,52.84 135.05,52.84 135.24,53.03 135.24,53.5 133.85,54.89 133.85,55.27 133.48,55.64 133.48,59 132.51,59.97 132.51,60.49 131.29,61.72 131.29,67.25 134.22,70.18 134.22,81.81 134.07,81.96 133.76,81.96 133.57,82.15 133.57,82.41 133.72,82.57 134.07,82.57 134.22,82.72 134.22,83.02 134.02,83.22 133.73,83.22 133.58,83.38 133.58,83.68 133.73,83.83 134.07,83.83 134.22,83.99 134.22,85.81 135.59,87.18 135.59,94.29 137.52,96.23
  IN1 w0.165: 137.52,96.23 137.52,97.73 138.02,98.22
  BOTTOM w0.102: JDIM3.146 132.92,57.58 133.54,56.96 133.54,56.91 134.38,56.07 134.38,55.51 133.85,54.98 v1(133.85,53.93)
M_B_A11: length 77.1
  TOP w0.089: v1(143.75,111.74) 143.41,111.4 U3.AN11
  TOP w0.102: JDIM1.120 143.32,51.18 141.84,52.67 141.84,53.01 141.63,53.21 v1(141.63,54.65)
  IN1 w0.079: v1(143.75,111.74) 144.21,111.29 144.21,110.9 144.15,110.85 144.15,110.07 144.08,110 144.08,109.57 143.91,109.4 143.91,108.72 144.26,108.37 144.26,105.07 143.47,104.28 143.47,101.38 143.97,100.88 143.97,97.28
  IN1 w0.152: v1(141.63,54.65) 142.17,54.65 142.71,55.19 142.71,58.28 143.91,59.48 143.91,61.91 145.17,63.16 145.17,65.81 147.82,68.46 147.82,79.69 147.66,79.84 147.2,79.84 147.04,80 147.04,80.3 147.2,80.45 147.66,80.45 147.82,80.61 147.82,80.91 147.66,81.06 147.2,81.06 147.04,81.22 147.04,81.52 147.2,81.67 147.66,81.67 147.82,81.83 147.82,82.13 147.66,82.28 147.2,82.28 147.04,82.44 147.04,82.74 147.2,82.89 147.66,82.89 147.82,83.05 147.82,91.18 146.24,92.76 146.24,95.01 143.97,97.28
  BOTTOM w0.102: v1(141.63,54.65) 141.31,54.97 141.31,56.35 141.19,56.47 140.73,56.47 140.63,56.57 140.63,56.93 140.71,57.01 141.23,57.01 141.42,57.2 JDIM3.120
M_B_A12: length 78.5
  TOP w0.089: v1(144.7,111.1) 145.05,110.75 U3.AR10
  TOP w0.102: JDIM1.119 143.57,54.8 142.79,54.01 142.79,52.59 v1(143.22,52.16)
  IN1 w0.079: 144.17,97.6 144.17,102.72 144.23,102.78 144.23,103.3 143.83,103.71 143.83,104.32 144.42,104.92 144.42,108.46 144.1,108.79 144.1,109.35 144.25,109.5 144.25,109.93 144.32,110 144.32,110.72 v1(144.7,111.1)
  IN1 w0.152: v1(143.22,52.16) 143.11,52.16 142.22,53.06 142.22,53.88 143.2,54.86 143.2,57.98 145.46,60.24 145.46,62.76 145.66,62.96 145.66,65.6 148.31,68.25 148.31,91.39 146.74,92.96 146.74,95.03 144.17,97.6
  BOTTOM w0.102: v1(143.22,52.16) 143.22,52.02 143.07,51.87 142.89,51.87 142.71,52.05 142.71,53.01 142.61,53.11 142.51,53.11 142.38,52.99 142.38,52.3 142.23,52.15 141.96,52.15 141.82,52.02 141.82,51.87 141.92,51.77 142.55,51.77 142.65,51.67 142.65,51.55 142.48,51.39 141.83,51.39 141.67,51.23 JDIM3.119
M_B_A13: length 79.5
  TOP w0.089: U3.AF9 137.86,110.17 137.86,110.31 137.7,110.47 v1(137.29,110.47)
  TOP w0.102: v1(130.6,55.13) 130.79,55.13 131.35,54.58 131.35,52.02 131.82,51.54 JDIM1.158
  IN1 w0.079: 134.94,98.77 135.36,99.2 135.36,100.61 136.15,101.4 136.15,105.64 136.76,106.25 136.76,108.55 136.94,108.73 136.94,109.25 137.05,109.36 137.05,109.47 136.94,109.59 136.94,109.94 137.03,110.04 137.03,110.14 136.99,110.19 136.89,110.19 136.84,110.24 136.84,110.61 136.73,110.72 136.73,110.8 136.78,110.85 136.78,110.94 136.84,111 136.91,111 137.1,110.8 137.1,110.66 v1(137.29,110.47)
  IN1 w0.152: 134.94,97.4 131.9,94.36 131.9,89.42 129.08,86.6 129.08,83.5 129.24,83.34 129.72,83.34 129.88,83.19 129.88,82.93 129.72,82.78 129.24,82.78 129.08,82.63 129.08,82.34 129.24,82.19 129.72,82.19 129.88,82.04 129.88,71.07 127.22,68.41 127.22,62.58 127.53,62.26 127.53,61.66 127.69,61.51 127.82,61.51 127.98,61.35 127.98,61.05 127.82,60.9 127.4,60.9 127.24,60.75 127.24,60.45 127.43,60.27 127.89,60.27 127.99,60.17 127.99,59.71 129.71,57.99 129.71,57.5 129.86,57.34 130.02,57.34 130.18,57.19 130.18,56.89 130.02,56.73 129.86,56.73 129.7,56.57 129.7,56.1 129.92,55.88 129.92,54.8 130.07,54.65 130.39,54.65 130.6,54.85 v1(130.6,55.13)
  IN1 w0.165: 134.94,98.77 134.94,97.4
  BOTTOM w0.102: v1(130.6,55.13) 130.45,55.13 129.52,56.06 129.52,56.37 129.65,56.5 130.57,56.5 130.7,56.63 130.7,56.92 130.54,57.08 130.05,57.08 129.92,57.21 JDIM3.158
M_B_A14: length 76.6
  TOP w0.089: U3.AH11 v1(139.16,111.72)
  TOP w0.102: JDIM1.151 133.57,57.29 133.33,57.04 133.33,54.71 132.97,54.35 132.97,53.64 v1(132.38,53.06)
  IN1 w0.079: 136.48,98.58 136.48,98.73 136.48,100.42 137.13,101.07 137.13,104.5 137.61,104.99 137.61,108.1 138.31,108.79 138.31,109.22 138.65,109.56 138.65,111.21 v1(139.16,111.72)
  IN1 w0.152: v1(132.38,53.06) 132.25,53.06 131.86,53.45 131.86,54.09 131.99,54.22 131.99,58.38 129.8,60.57 129.8,67.87 132.73,70.8 132.73,80.77 132.09,81.42 132.09,85.78 134.11,87.8 134.11,94.29 136.48,96.66
  IN1 w0.165: 136.48,98.58 136.48,96.66
  BOTTOM w0.102: JDIM3.151 131.67,51.78 130.54,52.92 130.54,53.45 130.78,53.7 131.07,53.7 131.71,53.06 v1(132.38,53.06)
M_B_A15: length 80.1
  TOP w0.089: v1(137.32,109.79) 137.4,109.86 137.61,109.86 137.79,109.68 U3.AF8
  TOP w0.102: JDIM1.156 132.32,51.22 132.2,51.35 132.2,51.46 131.55,52.1 131.55,54.28 132.23,54.96 132.23,55.43 131.89,55.78 v1(130.63,55.78)
  IN1 w0.079: v1(137.32,109.79) 137.21,109.68 137.21,109.59 137.32,109.48 137.46,109.48 137.71,109.23 137.71,108.91 137.13,108.33 137.13,105.25 136.5,104.63 136.5,101.22 135.82,100.54 135.82,98.96 135.54,98.67 135.54,98.51
  IN1 w0.152: v1(130.63,55.78) 130.63,55.92 130.67,55.96 130.67,57.82 128.48,60.01 128.48,61.55 128.05,61.98 128.05,62.4 128.48,62.83 128.48,68.42 130.77,70.7 130.77,71.34 130.92,71.5 131.26,71.5 131.41,71.65 131.41,71.95 131.26,72.11 130.92,72.11 130.77,72.26 130.77,72.56 130.92,72.72 131.26,72.72 131.41,72.87 131.41,73.17 131.26,73.32 130.92,73.32 130.77,73.48 130.77,73.78 130.92,73.93 131.26,73.93 131.41,74.09 131.41,74.39 131.26,74.54 130.92,74.54 130.77,74.7 130.77,75 130.92,75.15 131.26,75.15 131.41,75.31 131.41,75.61 131.26,75.76 130.92,75.76 130.77,75.92 130.77,76.22 130.92,76.37 131.26,76.37 131.41,76.53 131.41,76.83 131.26,76.98 130.92,76.98 130.77,77.13 130.77,86.32 132.79,88.34 132.79,94.35 135.54,97.11
  IN1 w0.165: 135.54,98.51 135.54,97.11
  BOTTOM w0.102: v1(130.63,55.78) 130.97,55.78 131.24,55.5 131.24,54.52 131.42,54.34 131.85,54.34 132.02,54.51 132.02,56.46 131.02,57.47 130.53,57.47 130.42,57.57 JDIM3.156
M_B_A16: length 78
  TOP w0.089: U3.AH10 v1(139.16,111.07)
  TOP w0.102: v1(132.35,53.7) 132.35,54.05 132.21,54.2 131.9,54.2 131.75,54.05 131.75,52.19 131.94,52 132.78,52 133.32,51.45 JDIM1.152
  IN1 w0.079: v1(139.16,111.07) 139.03,111.2 138.95,111.2 138.82,111.07 138.82,110.27 138.91,110.17 138.91,110.01 138.82,109.91 138.82,109.49 138.48,109.15 138.48,108.68 137.78,107.98 137.78,106.22 137.93,106.08 137.93,105.08 137.35,104.5 137.35,98.85 136.82,98.32 136.82,98.27
  IN1 w0.152: 136.82,96.54 134.6,94.32 134.6,87.59 133.23,86.22 133.23,85.76 133.09,85.62 132.74,85.62 132.58,85.47 132.58,85.25 132.73,85.1 133.07,85.1 133.22,84.95 133.22,84.73 133.07,84.58 132.73,84.58 132.58,84.42 132.58,81.62 133.23,80.98 133.23,70.59 130.3,67.66 130.3,61.31 130.42,61.19 130.42,61.04 130.31,60.93 130.31,60.77 130.56,60.51 130.69,60.51 130.8,60.62 130.97,60.62 131.14,60.45 131.14,59.93 132.49,58.58 132.49,54.47 132.63,54.33 132.73,54.33 132.86,54.2 132.86,53.86 132.7,53.7 v1(132.35,53.7)
  IN1 w0.165: 136.82,98.27 136.82,96.54
  BOTTOM w0.102: v1(132.35,53.7) 132.35,55.51 132.46,55.61 132.82,55.61 132.95,55.74 132.95,55.9 132.82,56.03 132.46,56.03 132.35,56.13 132.35,56.44 131.42,57.37 JDIM3.152
M_B_BG#0: length 72.5
  TOP w0.089: v1(144.71,110.44) 145.06,110.1 U3.AR9
  TOP w0.102: v1(144.69,54.63) 144.69,54.63 144.87,54.81 144.87,55.23 144.77,55.33 144.57,55.33 144.47,55.43 144.47,55.63 144.57,55.73 144.77,55.73 144.87,55.84 144.87,56.04 144.77,56.14 144.57,56.14 144.47,56.24 144.47,56.44 144.57,56.55 144.77,56.55 144.87,56.65 144.87,56.87 144.8,56.95 144.59,56.95 144.52,57.03 144.52,57.25 144.57,57.31 JDIM1.115
  IN1 w0.079: v1(144.71,110.44) 145.01,110.14 145.01,108.87 145.15,108.72 145.15,103.82 144.76,103.43 144.76,102.24 144.69,102.17 144.69,98.65 145.29,98.05
  IN1 w0.152: v1(144.69,54.63) 144.69,56.87 147.74,59.91 147.74,65.57 149.8,67.63 149.8,87.92 151.01,89.13 151.01,90.83 148.22,93.61 148.22,95.11 145.29,98.05
  BOTTOM w0.102: JDIM3.115 142.67,51.22 143.04,51.59 143.22,51.59 143.68,52.04 143.68,53.62 144.69,54.63 v1(144.69,54.63)
M_B_BG#1: length 75.2
  TOP w0.089: v1(144.63,109.1) 144.93,108.8 U3.AR7
  TOP w0.102: JDIM1.113 145.07,57.16 145.2,57.04 145.2,53.77 v1(144.75,53.32)
  IN1 w0.079: v1(144.63,109.1) 144.63,108.89 144.94,108.58 144.94,103.89 144.58,103.53 144.58,102.41 144.53,102.35 144.53,98.31 144.95,97.89
  IN1 w0.152: v1(144.75,53.32) 144.19,53.87 144.19,57.57 146.45,59.83 146.45,62.35 147.13,63.02 147.13,65.66 149.3,67.84 149.3,88.89 149.46,89.05 150.22,89.05 150.42,89.24 150.42,89.53 150.27,89.68 149.46,89.68 149.3,89.83 149.3,90.11 149.46,90.26 150.14,90.26 150.32,90.44 150.32,90.72 150.17,90.87 149.46,90.87 149.3,91.03 149.3,91.83 147.73,93.41 147.73,95.11 144.95,97.89
  BOTTOM w0.102: JDIM3.113 143.17,51.22 143.42,51.46 143.77,51.46 143.96,51.65 143.96,52.5 144.06,52.6 144.2,52.6 144.34,52.74 144.34,52.99 143.91,53.41 143.91,53.55 144.14,53.78 144.28,53.78 v1(144.75,53.32)
M_B_BS#0: length 76.1
  TOP w0.089: v1(139.19,109.71) 139.28,109.73 139.62,109.48 U3.AH8
  TOP w0.102: JDIM1.150 133.82,51.23 133.59,51.46 133.59,51.47 133.11,51.95 133.11,52.2 133.28,52.37 133.45,52.37 133.59,52.23 133.89,52.23 134.03,52.09 134.03,51.57 134.15,51.44 134.43,51.44 134.51,51.51 134.51,52.69 134.37,52.83 v1(133.66,52.83)
  IN1 w0.079: 137.74,98.43 138.16,98.85 138.16,105.92 138.57,106.33 138.57,108.51 138.67,108.61 138.67,109.11 139.01,109.44 139.01,109.53 v1(139.19,109.71)
  IN1 w0.152: v1(133.66,52.83) 133.34,52.83 133.13,53.04 133.13,53.38 133.35,53.6 133.35,55.07 132.98,55.44 132.98,58.8 132.02,59.76 132.02,60.29 130.79,61.51 130.79,67.46 133.72,70.39 133.72,81.18 133.08,81.83 133.08,83.88 133.72,84.53 133.72,86.01 135.1,87.39 135.1,94.29 137.17,96.36
  IN1 w0.165: 137.17,96.36 137.17,97.86 137.74,98.43
  BOTTOM w0.102: v1(133.66,52.83) 133.2,53.29 133.2,54.55 133.42,54.77 133.42,55.85 131.92,57.35 JDIM3.150
M_B_BS#1: length 79.8
  TOP w0.089: v1(139.2,110.42) 139.62,110.12 U3.AH9
  TOP w0.102: JDIM1.145 135.07,57.48 135.35,57.21 135.35,56.88 135.25,56.78 134.36,56.78 134.26,56.68 134.26,56.44 134.39,56.31 135.27,56.31 135.37,56.21 135.37,55.36 135.2,55.19 134.19,55.19 133.97,55.4 v1(133.97,55.9)
  IN1 w0.079: 138.11,97.88 138.11,97.9 138.52,98.3 138.52,105.8 138.91,106.19 138.91,108.23 139.71,109.04 139.71,109.18 139.52,109.36 139.52,109.55 139.68,109.71 139.68,109.83 139.42,110.09 139.42,110.34 139.34,110.42 v1(139.2,110.42)
  IN1 w0.152: v1(133.97,55.9) 134.09,56.02 134.09,57 133.97,57.12 133.97,57.96 134.09,58.08 134.09,59.09 133.73,59.45 133.73,59.71 133.47,59.97 133.21,59.97 133.01,60.18 133.01,60.7 131.79,61.92 131.79,67.05 134.71,69.98 134.71,72.52 134.9,72.7 134.9,72.84 134.71,73.02 134.71,73.22 134.87,73.37 135.08,73.37 135.24,73.52 135.24,73.83 135.08,73.98 134.87,73.98 134.71,74.13 134.71,74.44 134.87,74.59 134.98,74.59 135.14,74.74 135.14,75.05 134.98,75.2 134.87,75.2 134.71,75.35 134.71,75.66 134.87,75.81 134.98,75.81 135.14,75.96 135.14,76.27 134.98,76.42 134.87,76.42 134.71,76.57 134.71,76.88 134.87,77.03 134.98,77.03 135.14,77.18 135.14,77.48 134.98,77.64 134.87,77.64 134.71,77.79 134.71,78.09 134.87,78.25 134.98,78.25 135.14,78.4 135.14,78.7 134.98,78.86 134.87,78.86 134.71,79.01 134.71,79.31 134.87,79.47 134.98,79.47 135.14,79.62 135.14,79.92 134.98,80.08 134.87,80.08 134.71,80.23 134.71,80.53 134.87,80.69 134.98,80.69 135.14,80.84 135.14,81.14 134.98,81.29 134.87,81.29 134.71,81.45 134.71,81.75 134.87,81.9 134.98,81.9 135.14,82.06 135.14,82.36 134.98,82.51 134.87,82.51 134.71,82.67 134.71,82.97 134.87,83.12 134.98,83.12 135.14,83.28 135.14,83.58 134.98,83.73 134.87,83.73 134.71,83.89 134.71,84.19 134.87,84.34 134.98,84.34 135.14,84.5 135.14,84.8 134.98,84.95 134.87,84.95 134.71,85.1 134.71,85.47 134.85,85.61 135.13,85.61 135.28,85.77 135.28,86.17 135.76,86.65 135.94,86.65 136.09,86.79 136.09,94.33 137.87,96.1
  IN1 w0.165: 137.87,96.1 137.87,97.63 138.11,97.88
  BOTTOM w0.102: JDIM3.145 133.17,51.2 133.76,51.78 134.05,51.78 134.34,52.07 134.34,53.1 134.13,53.31 133.66,53.31 133.4,53.57 133.4,54.46 133.63,54.69 133.63,55.55 v1(133.97,55.9)
M_B_CB0: length 70.5
  TOP w0.089: U3.AW11 v1(147.39,111.72)
  TOP w0.102: JDIM1.105 147.07,57.55 147.31,57.31 147.31,56.92 v1(146.85,56.46)
  IN3 w0.079: 146.5,112.27 147.17,112.27 147.39,112.05 v1(147.39,111.72) ; 144.67,108.68 144.77,108.68 145.13,109.03 145.13,109.21
  IN3 w0.114: 144.67,108.68 144.54,108.68 144.14,108.27 144.14,106.44 143.43,105.73 143.43,104.08 143.1,103.75 143.1,102.4 143.77,101.73 143.77,83.1 143.88,82.99 144.74,82.99 144.86,82.87 144.86,82.65 144.74,82.53 143.88,82.53 143.77,82.42 143.77,82.19 143.88,82.07 144.76,82.07 144.87,81.96 144.87,81.74 144.75,81.62 143.88,81.62 143.77,81.5 143.77,81.16 147.06,77.87 147.06,63.84 148.25,62.65 148.25,59.6 147.31,58.67 147.31,56.92 v1(146.85,56.46) ; 145.13,109.21 145.13,111.37 146.03,112.27 146.5,112.27
  BOTTOM w0.102: JDIM3.100 146.42,56.89 v1(146.85,56.46)
M_B_CB1: length 70.8
  TOP w0.089: v1(148.31,111.72) U3.AY11
  TOP w0.102: JDIM1.92 150.32,51.85 v1(149.98,52.2)
  IN3 w0.079: v1(148.31,111.72) 149.15,110.88 149.15,108.8 148.72,108.37 148.24,108.37 147.79,107.93 147.79,107.51
  IN3 w0.114: v1(149.98,52.2) 150.14,52.2 150.88,52.94 150.88,54.78 151.24,55.15 151.24,57.47 151.74,57.96 151.74,65.86 150.57,67.03 150.57,88.51 149.08,90 149.08,90.57 148.96,90.68 148.47,90.68 148.35,90.8 148.35,91.02 148.47,91.14 148.96,91.14 149.08,91.25 149.08,91.48 148.96,91.6 148.65,91.6 148.54,91.71 148.54,91.94 148.65,92.05 148.96,92.05 149.08,92.17 149.08,92.4 148.96,92.51 148.65,92.51 148.54,92.62 148.54,92.85 148.65,92.97 148.96,92.97 149.08,93.08 149.08,93.49 147.75,94.82 147.75,103.27 147.79,103.31 147.79,107.51
  BOTTOM w0.102: JDIM3.87 149.67,51.59 149.98,51.9 v1(149.98,52.2)
M_B_CB2: length 71.8
  TOP w0.089: v1(148.37,109.77) 148.44,109.77 U3.AY8
  TOP w0.102: JDIM1.87 151.57,57.41 151.18,57.02 151.18,56.03 150.17,55.01 v1(150.04,55.01)
  IN3 w0.079: 147.1,107.51 147.1,107.69 148.15,108.73 148.63,108.73 148.82,108.91 148.82,109.32 v1(148.37,109.77)
  IN3 w0.114: 147.1,107.51 147.1,103.62 147.06,103.57 147.06,91.04 149.84,88.26 149.84,87.92 149.73,87.81 149.01,87.81 148.88,87.67 148.88,87.46 148.99,87.35 149.73,87.35 149.84,87.24 149.84,87.01 149.73,86.89 149.01,86.89 148.88,86.76 148.88,86.55 148.99,86.44 149.73,86.44 149.84,86.32 149.84,86.09 149.73,85.98 149.01,85.98 148.88,85.84 148.88,85.64 148.99,85.52 149.73,85.52 149.84,85.41 149.84,66.79 151.05,65.58 151.05,58.34 150.56,57.85 150.56,55.44 150.12,55.01 v1(150.04,55.01)
  BOTTOM w0.102: JDIM3.92 148.42,56.65 150.04,55.03 v1(150.04,55.01)
M_B_CB3: length 72.8
  TOP w0.089: v1(147.43,109.76) 147.74,109.45 U3.AW8
  TOP w0.102: JDIM1.100 148.32,51.89 147.4,52.81 v1(146.87,52.81)
  IN3 w0.079: v1(147.43,109.76) 147.28,109.76 146.09,108.57 145.43,108.57 144.96,108.11 144.96,107.73
  IN3 w0.114: v1(146.87,52.81) 147.09,52.81 147.32,53.04 147.32,55.17 147.64,55.5 147.64,56.28 148.01,56.66 148.01,58.3 148.93,59.22 148.93,62.93 147.82,64.05 147.82,80.88 144.46,84.25 144.46,84.63 144.57,84.74 145.38,84.74 145.52,84.89 145.52,85.08 145.41,85.2 144.57,85.2 144.46,85.31 144.46,85.54 144.57,85.66 145.44,85.66 145.57,85.79 145.57,86 145.46,86.11 144.57,86.11 144.46,86.23 144.46,103.54 144.96,104.04 144.96,107.73
  BOTTOM w0.102: JDIM3.105 145.17,51.5 146.49,52.81 v1(146.87,52.81)
M_B_CB4: length 72
  TOP w0.089: U3.AY10 v1(148.31,111.07)
  TOP w0.102: JDIM1.88 151.32,52.21 v1(150.07,53.47)
  IN3 w0.079: v1(148.31,111.07) 148.42,111.18 148.57,111.18 148.98,110.77 148.98,108.86 148.7,108.57 148.21,108.57 147.45,107.81 147.45,107.51
  IN3 w0.114: v1(150.07,53.47) 150.54,53.94 150.54,54.93 150.9,55.29 150.9,57.71 151.4,58.2 151.4,65.72 150.23,66.89 150.23,88.36 147.4,91.19 147.4,91.64 147.52,91.75 147.85,91.75 147.99,91.88 147.99,92.09 147.87,92.21 147.52,92.21 147.4,92.32 147.4,92.55 147.52,92.66 147.85,92.66 147.99,92.8 147.99,93.01 147.87,93.12 147.52,93.12 147.4,93.24 147.4,93.46 147.52,93.58 147.85,93.58 147.99,93.71 147.99,93.92 147.87,94.04 147.52,94.04 147.4,94.15 147.4,103.41 147.45,103.45 147.45,107.51
  BOTTOM w0.102: v1(150.07,53.47) 149.06,52.46 148.67,51.76 JDIM3.91
M_B_CB5: length 73.6
  TOP w0.089: v1(147.39,111.07) 147.72,110.75 U3.AW10
  TOP w0.102: v1(146.85,55.19) 148.07,56.42 JDIM1.101
  IN3 w0.079: 144.67,108.12 145.28,108.73 145.97,108.73 147.04,109.8 147.04,110.72 v1(147.39,111.07)
  IN3 w0.114: v1(146.85,55.19) 147.3,55.64 147.3,56.42 147.66,56.79 147.66,58.48 148.59,59.41 148.59,62.79 147.47,63.92 147.47,80.75 147.17,81.04 146.98,81.04 146.26,80.32 146.09,80.32 145.97,80.44 145.97,80.65 146.69,81.37 146.69,81.53 146.53,81.69 146.36,81.69 145.58,80.9 145.41,80.9 145.28,81.04 145.28,81.25 146.04,82.02 146.04,82.18 144.11,84.1 144.11,101.87 143.44,102.54 143.44,103.52 143.77,103.85 143.77,105.59 144.62,106.44 144.62,108.07 144.67,108.12
  BOTTOM w0.102: v1(146.85,55.19) 146.39,55.65 145.8,56.43 145.58,56.77 145.42,56.93 JDIM3.104
M_B_CB6: length 69.6
  TOP w0.089: U3.AY7 148.68,108.8 v1(148.36,109.12)
  TOP w0.102: JDIM1.91 150.57,56.83 v1(150.05,56.3)
  IN3 w0.079: v1(148.36,109.12) 148.32,109.12 147.61,108.42 147.33,108.42 146.76,107.85 146.76,107.51
  IN3 w0.114: v1(150.05,56.3) 149.98,56.3 149.59,56.69 149.59,57.87 150.22,58.5 150.22,63.47 149.5,64.18 149.5,83.89 146.72,86.67 146.72,87.03 146.85,87.17 148.18,87.17 148.29,87.28 148.29,87.5 148.17,87.62 146.83,87.62 146.72,87.74 146.72,87.95 146.85,88.08 148.18,88.08 148.29,88.19 148.29,88.41 148.17,88.54 146.83,88.54 146.72,88.65 146.72,88.86 146.85,88.99 148.18,88.99 148.29,89.11 148.29,89.33 148.17,89.45 146.83,89.45 146.72,89.57 146.72,103.72 146.76,103.76 146.76,107.51
  BOTTOM w0.102: v1(150.05,56.3) 149.96,56.3 149.42,56.84 JDIM3.88
M_B_CB7: length 70.1
  TOP w0.089: v1(147.34,109.12) 147.66,108.8 U3.AW7
  TOP w0.102: v1(146.87,51.58) 147.32,51.58 147.44,51.46 147.44,51.26 147.32,51.15 JDIM1.104
  IN3 w0.079: 145.31,107.51 145.31,108.11 145.5,108.3 146.12,108.3 146.94,109.12 v1(147.34,109.12)
  IN3 w0.114: 145.31,107.51 145.31,103.9 144.8,103.39 144.8,87.26 146.69,85.37 146.69,85.21 146.11,84.63 146.11,84.47 146.27,84.31 146.44,84.31 147.01,84.88 147.17,84.88 147.34,84.72 147.34,84.56 146.73,83.95 146.73,83.79 146.89,83.63 147.05,83.63 147.66,84.24 147.82,84.24 148.45,83.61 148.45,63.9 149.28,63.08 149.28,59.03 148.36,58.11 148.36,56.39 147.98,56.02 147.98,55.36 147.75,55.13 147.75,52.47 v1(146.87,51.58)
  BOTTOM w0.102: v1(146.87,51.58) 146.51,51.58 146.17,51.25 JDIM3.101
M_B_CKE0: length 71.7
  TOP w0.089: U3.AT8 145.69,109.78 v1(145.56,109.78)
  TOP w0.102: v1(146.86,57.1) 146.46,57.1 146.07,57.48 JDIM1.109
  IN1 w0.079: 146.4,107.65 146.4,108.2 146.18,108.42 146.18,109.05 145.76,109.47 145.67,109.47 145.56,109.58 v1(145.56,109.78)
  IN1 w0.127: 146.4,107.65 146.4,98.22 149.11,95.5 149.11,94.67 152.38,91.4 152.38,85.14 152.26,85.02 151.32,85.02 151.17,84.86 151.17,84.43 151.3,84.31 152.26,84.31 152.38,84.18 152.38,83.92 152.26,83.8 151.3,83.8 151.17,83.67 151.17,83.42 151.3,83.29 152.26,83.29 152.38,83.16 152.38,82.91 152.26,82.78 151.3,82.78 151.17,82.65 151.17,82.4 151.3,82.27 152.21,82.27 152.34,82.15 152.34,81.89 152.21,81.77 151.3,81.77 151.17,81.64 151.17,81.38 151.3,81.26 152.21,81.26 152.33,81.13 152.33,80.88 152.2,80.75 151.3,80.75 151.17,80.62 151.17,80.38 151.3,80.25 152.19,80.25 152.32,80.13 152.32,79.87 152.19,79.75 151.31,79.75 151.17,79.61 151.17,67.07 149.11,65 149.11,64.57 149.23,64.45 149.39,64.45 149.52,64.32 149.52,63.94 149.39,63.81 149.23,63.81 149.11,63.68 149.11,59.34 v1(146.86,57.1)
M_B_CKE1: length 70.3
  TOP w0.089: U3.AT10 145.91,110.75 v1(145.56,111.09)
  TOP w0.102: JDIM1.110 145.82,51.49 145.58,51.74 v1(144.78,51.74)
  IN1 w0.079: v1(145.56,111.09) 145.66,111.2 145.94,111.2 146,111.14 146,110.89 145.94,110.83 145.94,109.55 146.43,109.07 146.43,108.51 146.7,108.23
  IN1 w0.127: v1(144.78,51.74) 145.11,51.41 145.53,51.41 146.27,52.15 146.27,54.26 146.59,54.59 147.09,54.59 147.36,54.85 147.36,55.71 149.54,57.89 149.54,62.79 151.6,64.86 151.6,78.55 152.81,79.76 152.81,91.58 149.54,94.85 149.54,95.51 146.7,98.35 146.7,108.23
M_B_CKE2: length 70.3
  TOP w0.089: U3.AT7 145.88,108.8 v1(145.58,109.1)
  IN1 w0.079: v1(145.58,109.1) 145.58,108.66 146.13,108.11 146.13,107.51
  IN1 w0.127: 146.13,107.51 146.13,98.08 148.91,95.31 148.91,94.26 151.95,91.22 151.95,87.95 151.75,87.75 150.96,87.75 150.74,87.53 150.74,87.1 150.86,86.97 151.82,86.97 151.95,86.85 151.95,86.59 151.82,86.46 150.86,86.46 150.74,86.34 150.74,86.08 150.86,85.96 151.82,85.96 151.95,85.83 151.95,85.58 151.82,85.45 150.86,85.45 150.74,85.32 150.74,67.24 148.68,65.18 148.68,59.52 145.84,56.68 145.84,52.88 145.33,52.37 v1(144.73,52.37)
  BOTTOM w0.102: v1(144.73,52.37) 144.21,51.85 144.21,51.34 144.17,51.3 JDIM3.109
M_B_CKE3: length 70
  TOP w0.089: v1(146.48,111.12) 146.2,111.4 U3.AT11
  IN1 w0.079: 146.99,108.41 146.8,108.6 146.8,108.93 146.11,109.62 146.11,110.76 v1(146.48,111.12)
  IN1 w0.127: v1(146.86,53.46) 147.79,54.4 147.79,55.53 149.97,57.71 149.97,62.62 152.03,64.68 152.03,78.11 153.25,79.32 153.25,91.75 149.98,95.02 149.98,95.45 146.99,98.44 146.99,108.41
  BOTTOM w0.102: JDIM3.110 143.92,57.3 145.52,55.26 145.89,54.67 v1(146.86,53.46)
M_B_CS#0: length 72.6
  TOP w0.089: v1(137.34,111.77) 137.79,111.45 U3.AF11
  TOP w0.102: v1(132.4,52.41) 133.17,53.18 133.17,54.27 133.53,54.63 133.53,56.71 134.07,57.26 JDIM1.149
  IN1 w0.079: 136.11,98.31 136.11,98.54 136.26,98.68 136.26,100.47 136.93,101.14 136.93,104.53 137.44,105.04 137.44,108.18 138.07,108.8 138.07,109.34 137.87,109.53 137.87,110.18 137.85,110.2 137.85,111.26 v1(137.34,111.77)
  IN1 w0.127: 136.11,98.31 136.11,96.72 133.66,94.27 133.66,87.98 131.64,85.96 131.64,81.23 132.29,80.59 132.29,70.98 129.36,68.05 129.36,60.38 131.55,58.2 131.55,54.41 131.41,54.27 131.41,53.23 132.23,52.41 v1(132.4,52.41)
M_B_CS#1: length 70.9
  TOP w0.089: v1(136.38,109.13) 136.48,109.03 136.48,108.54 136.61,108.41 136.72,108.41 136.88,108.56 U3.AE7
  TOP w0.216: v1(126.6,61.74) 127.04,62.17 v1(128.21,62.17) 130.19,62.17 132.12,60.24 132.12,59.65 132.07,59.6 JDIM1.157
  IN1 w0.079: 134.31,98.93 134.94,99.56 134.94,100.7 135.83,101.59 135.83,105.04 135.75,105.11 135.32,105.11 135.23,105.21 135.23,105.4 135.31,105.49 135.75,105.49 135.83,105.57 135.83,105.74 135.75,105.82 135.75,106.04 135.83,106.12 136.18,106.12 136.26,106.2 136.26,106.6 136.18,106.68 136.13,106.68 136.05,106.76 136.05,106.91 136.13,106.99 136.18,106.99 136.26,107.07 136.26,108.64 136.38,108.77 v1(136.38,109.13)
  IN1 w0.127: 134.31,98.93 134.21,98.82 134.21,98.64 134.35,98.5 134.35,98.18 134.23,98.06 134.05,98.06 133.87,98.24 133.69,98.24 133.57,98.12 133.57,97.84 133.97,97.43 133.97,97.25 133.84,97.11 133.57,97.11 133.45,96.99 133.45,96.72 133.34,96.62 133.02,96.62 132.89,96.49 132.89,96.17 131.02,94.3 131.02,89.78 128.21,86.96 128.21,76.26 128.33,76.13 128.87,76.13 129,76 129,75.75 128.87,75.62 128.33,75.62 128.21,75.49 128.21,75.25 128.34,75.11 128.87,75.11 129,74.99 129,74.73 128.87,74.61 128.33,74.61 128.21,74.48 128.21,74.22 128.33,74.1 128.87,74.1 129,73.97 129,73.72 128.87,73.59 128.33,73.59 128.21,73.46 128.21,73.21 128.33,73.08 128.87,73.08 129,72.95 129,72.7 128.87,72.57 128.33,72.57 128.21,72.45 128.21,72.19 128.33,72.07 128.87,72.07 129,71.94 129,71.68 128.87,71.56 128.34,71.56 128.21,71.43 128.21,71.25 128.44,71.02 128.44,70.86 126.34,68.77 126.34,62 v1(126.6,61.74)
M_B_CS#2: length 70.7
  TOP w0.089: v1(137.33,111.11) 137.42,111.11 U3.AF10
  IN1 w0.079: 135.86,98.63 136.04,98.82 136.04,100.51 136.69,101.16 136.69,104.54 137.29,105.14 137.29,108.25 137.9,108.87 137.9,109.27 137.71,109.47 137.71,110.11 137.68,110.13 137.68,110.77 v1(137.33,111.11)
  IN1 w0.127: v1(130.94,53.09) 130.94,53.32 130.8,53.46 130.8,53.7 130.98,53.88 130.98,54.45 131.12,54.59 131.12,58.02 128.93,60.21 128.93,68.23 131.86,71.16 131.86,77.28 131.73,77.41 131.39,77.41 131.21,77.58 131.21,77.82 131.34,77.95 131.73,77.95 131.86,78.08 131.86,78.33 131.73,78.46 131.34,78.46 131.21,78.59 131.21,78.88 131.34,79.01 131.73,79.01 131.86,79.14 131.86,79.39 131.73,79.52 131.34,79.52 131.21,79.65 131.21,79.9 131.34,80.03 131.73,80.03 131.86,80.15 131.86,80.41 131.73,80.54 131.34,80.54 131.21,80.66 131.21,86.14 133.23,88.16 133.23,94.32 135.86,96.95 135.86,98.63
  BOTTOM w0.102: v1(130.94,53.09) 130.97,53.09 132.17,51.88 JDIM3.149
M_B_CS#3: length 74.8
  TOP w0.089: U3.AE10 136.79,110.75 v1(136.43,111.1)
  IN1 w0.079: v1(136.43,111.1) 136.2,110.87 136.2,110.75 135.76,110.31 135.76,108.2 134.82,107.25 134.82,101.93 132.28,99.4 132.28,99.09
  IN1 w0.127: v1(129.4,52.97) 128.82,53.56 128.82,57.63 125.48,60.97 125.48,69.13 126.81,70.46 126.81,71 126.94,71.12 127.22,71.12 127.34,71.25 127.34,71.5 127.22,71.63 126.94,71.63 126.81,71.76 126.81,72.01 126.94,72.14 127.22,72.14 127.34,72.27 127.34,72.52 127.22,72.65 126.94,72.65 126.81,72.77 126.81,73.03 126.94,73.15 127.22,73.15 127.34,73.28 127.34,73.54 127.22,73.66 126.94,73.66 126.81,73.79 126.81,74.04 126.94,74.17 127.22,74.17 127.34,74.3 127.34,74.55 127.22,74.68 126.94,74.68 126.81,74.81 126.81,75.06 126.94,75.19 127.22,75.19 127.34,75.31 127.34,75.57 127.22,75.69 126.94,75.69 126.81,75.82 126.81,76.08 126.94,76.2 127.22,76.2 127.34,76.33 127.34,76.58 127.22,76.71 126.94,76.71 126.81,76.84 126.81,77.09 126.94,77.22 127.22,77.22 127.34,77.35 127.34,77.6 127.22,77.73 126.94,77.73 126.81,77.85 126.81,78.11 126.94,78.23 127.22,78.23 127.34,78.36 127.34,78.62 127.22,78.74 126.94,78.74 126.81,78.87 126.81,79.12 126.94,79.25 127.22,79.25 127.34,79.38 127.34,79.63 127.22,79.76 126.94,79.76 126.81,79.89 126.81,86.79 130.16,90.14 130.16,94.24 132.28,96.37 132.28,99.09
  BOTTOM w0.102: v1(129.4,52.97) 130.24,52.13 130.24,51.36 130.17,51.3 JDIM3.157
M_B_DIM0_CLKN0: length 67.1
  TOP w0.089: U3.AN9 143.11,110.1 v1(142.76,110.45)
  TOP w0.114: JDIM1.139 138.57,59.35 138.69,59.47 138.81,59.47 138.86,59.52 138.86,60.15 138.53,60.48 138.53,63.06 138.39,63.2 137.65,63.2 137.5,63.06 v1(137.5,62.92)
  IN1 w0.079: 141.72,93.82 141.69,93.85 141.69,94.93 141.27,95.35 141.27,104.78 141.7,105.22 141.7,108.25 141.82,108.37 142.17,108.37 142.36,108.56 142.36,109.15 142.74,109.53 142.74,109.88 142.51,110.11 142.51,110.2 v1(142.76,110.45)
  IN1 w0.089: 141.72,93.82 141.72,93.4 141.65,93.33 141.65,93.1 141.74,93.01 141.95,93.01 142.15,92.81 142.15,92.25 141.91,92.02 141.91,91.15 142.15,90.92 142.15,90.53 142.58,90.09 142.58,89.65 142.81,89.43 142.81,88.71 142.58,88.48 142.58,87.79 142.8,87.57 143.23,87.57 143.56,87.24 143.56,85.91 143.24,85.59 142.87,85.59 142.58,85.3 142.58,85.02 141.91,84.35 141.91,83.91 142.15,83.68 142.15,83.05 141.91,82.81 141.91,82.34 142.15,82.11 142.15,81.47 141.91,81.24 141.91,80.76 142.15,80.53 142.15,79.9 141.91,79.66 141.91,79.19 142.15,78.96 142.15,78.32 141.91,78.09 141.91,77.61 142.15,77.38 142.15,76.75 141.91,76.52 141.91,76.04 142.15,75.81 142.15,75.17 141.91,74.94 141.91,74.46 142.15,74.23 142.15,73.6 141.91,73.37 141.91,72.89 142.15,72.66 142.15,72.02 141.91,71.79 141.91,71.32 142.15,71.08 142.15,70.45 141.91,70.22 141.91,69.67 142.15,69.43 142.15,68.64 139.83,66.32 139.83,65.29 139.57,65.03 138.32,65.03 138.04,64.76 138.04,64.19 138.16,64.07 138.5,64.07 138.94,64.51 139.49,64.51 139.85,64.15 139.85,63.64 138.83,62.62 138.25,62.62 138.05,62.82 138.05,63.04 137.96,63.13 137.61,63.13 137.5,63.03 v1(137.5,62.92)
M_B_DIM0_CLKN1: length 68.4
  TOP w0.089: U3.AM8 142.04,109.77 v1(141.82,109.77)
  TOP w0.102: v1(138.13,51.8) 138.13,52.09 138.28,52.25 138.47,52.25 138.67,52.05 138.67,51.55 138.62,51.5 138.62,51.39 138.52,51.29 138.42,51.29 138.32,51.2 JDIM1.140
  IN1 w0.079: v1(141.82,109.77) 141.82,109.65 141.43,109.25 141.43,108.77 141.14,108.48 141.14,107.06 141.03,106.95 141.03,105.47 140.75,105.19 140.75,99.96 140.17,99.38 140.17,98.81 140.64,98.35 140.64,93.85 140.62,93.84 140.62,93.82
  IN1 w0.089: 140.62,93.82 140.62,92.27 141.04,91.85 141.04,90.4 141.71,89.73 141.71,87.1 141.91,86.9 142.24,86.9 142.41,86.73 142.41,86.37 142.24,86.2 141.82,86.2 141.62,86 141.62,85.29 141.04,84.71 141.04,68.99 140.52,68.47 140.52,68.25 139.78,67.52 139.56,67.52 138.74,66.69 138.74,66.39 138.87,66.26 138.87,66.13 138.65,65.91 137.95,65.91 136.81,64.76 136.81,62.12 137.92,61 137.92,54.53 137.73,54.34 137.47,54.34 137.25,54.11 137.25,52.89 137.08,52.72 137.08,52.33 137.41,52.01 137.92,52.01 v1(138.13,51.8)
M_B_DIM0_CLKP0: length 67.1
  TOP w0.089: v1(141.92,110.41) 142.19,110.41 142.36,110.24 U3.AM9
  TOP w0.114: v1(137.51,63.63) 137.51,63.59 137.68,63.42 138.47,63.42 138.75,63.14 138.75,60.57 139.07,60.24 JDIM1.137
  IN1 w0.079: v1(141.92,110.41) 142.12,110.41 142.35,110.18 142.35,110.05 142.58,109.81 142.58,109.59 142.21,109.21 142.21,108.62 142.11,108.53 141.76,108.53 141.55,108.32 141.55,105.28 141.11,104.85 141.11,95.28 141.53,94.86 141.53,93.84 141.53,93.83 141.53,93.82
  IN1 w0.089: 141.53,93.82 141.53,93.48 141.46,93.41 141.46,93.02 141.66,92.82 141.87,92.82 141.96,92.73 141.96,92.33 141.72,92.09 141.72,91.07 141.96,90.84 141.96,90.45 142.39,90.01 142.39,89.57 142.62,89.35 142.62,88.79 142.39,88.56 142.39,87.71 142.72,87.38 143.15,87.38 143.37,87.17 143.37,85.99 143.16,85.78 142.8,85.78 142.39,85.38 142.39,85.09 141.72,84.43 141.72,83.83 141.96,83.6 141.96,83.13 141.72,82.89 141.72,82.26 141.96,82.03 141.96,81.55 141.72,81.32 141.72,80.69 141.96,80.45 141.96,79.98 141.72,79.74 141.72,79.11 141.96,78.88 141.96,78.4 141.72,78.17 141.72,77.54 141.96,77.3 141.96,76.83 141.72,76.59 141.72,75.96 141.96,75.73 141.96,75.25 141.72,75.02 141.72,74.39 141.96,74.15 141.96,73.68 141.72,73.44 141.72,72.81 141.96,72.58 141.96,72.1 141.72,71.87 141.72,71.24 141.96,71 141.96,70.53 141.72,70.3 141.72,69.59 141.96,69.36 141.96,68.72 139.64,66.4 139.64,65.37 139.49,65.22 138.24,65.22 137.85,64.84 137.85,64.11 138.08,63.88 138.58,63.88 139.01,64.32 139.41,64.32 139.66,64.07 139.66,63.72 138.75,62.81 138.33,62.81 138.24,62.9 138.24,63.12 138.04,63.32 137.58,63.32 137.49,63.41 137.49,63.62 v1(137.51,63.63)
M_B_DIM0_CLKP1: length 68.4
  TOP w0.089: U3.AM7 142.04,109.12 v1(141.82,109.12)
  TOP w0.102: JDIM1.138 138.82,51.41 138.87,51.46 138.87,52.13 138.56,52.45 138.36,52.45 138.13,52.68 v1(138.13,52.79)
  IN1 w0.079: v1(141.82,109.12) 141.8,109.15 141.69,109.15 141.59,109.04 141.59,108.7 141.3,108.42 141.3,107 141.18,106.88 141.18,105.4 140.9,105.12 140.9,99.89 140.33,99.32 140.33,98.87 140.79,98.41 140.79,93.85 140.81,93.84 140.81,93.82
  IN1 w0.089: 140.81,93.82 140.81,92.35 141.23,91.93 141.23,90.48 141.9,89.81 141.9,87.18 141.99,87.09 142.32,87.09 142.6,86.8 142.6,86.29 142.32,86.01 141.9,86.01 141.81,85.92 141.81,85.22 141.23,84.63 141.23,68.91 140.71,68.39 140.71,68.17 139.86,67.33 139.64,67.33 138.93,66.61 138.93,66.47 139.06,66.33 139.06,66.05 138.73,65.72 138.03,65.72 137,64.68 137,62.2 138.11,61.08 138.11,54.45 137.81,54.15 137.55,54.15 137.44,54.03 137.44,52.81 137.27,52.64 137.27,52.41 137.49,52.2 138.29,52.2 138.46,52.36 138.46,52.59 138.27,52.79 v1(138.13,52.79)
M_B_DIM1_CLKN0: length 68.6
  TOP w0.089: U3.AM10 142.36,110.83 142.13,111.07 v1(141.91,111.07)
  IN1 w0.079: v1(141.91,111.07) 141.8,111.18 141.65,111.18 141.53,111.06 141.53,110.8 140.65,109.93 140.65,108.7 139.75,107.8 139.75,105.65 139.36,105.25 139.36,97.61 138.92,97.17 138.92,96.84 138.95,96.8 138.95,96.76
  IN1 w0.089: v1(136.14,52.61) 136.14,52.71 136.3,52.86 136.51,52.86 136.75,53.11 136.75,53.96 136.55,54.17 135.81,54.17 135.7,54.27 135.7,55.13 135.41,55.42 135.41,60.34 135.15,60.59 134.71,60.59 134.56,60.75 134.56,66.62 136.98,69.04 136.98,71.58 137.5,72.1 137.5,73.42 138.36,74.27 138.36,93.82 138.34,93.84 138.34,94.9 138.95,95.52 138.95,96.76
  BOTTOM w0.102: v1(136.14,52.61) 136.14,52.68 136.4,52.94 137.02,52.94 137.2,52.76 137.2,51.59 136.97,51.36 136.78,51.36 136.67,51.26 JDIM3.139
M_B_DIM1_CLKN1: length 71.6
  TOP w0.089: U3.AJ11 140.25,111.11 v1(140.09,111.11)
  IN1 w0.079: 138.11,97.36 138.11,97.51 138.7,98.1 138.7,105.73 139.08,106.11 139.08,108.15 139.87,108.93 139.87,109.87 139.7,110.04 139.66,110.08 139.57,110.16 139.57,110.7 139.77,110.9 139.88,110.9 v1(140.09,111.11)
  IN1 w0.089: 138.11,97.36 138.11,95.93 136.74,94.56 136.74,93.84 136.72,93.82 136.72,86.2 136.54,86.02 136.22,86.02 136.01,85.81 136.01,85.1 136.1,85.01 136.11,85.01 136.21,84.91 136.63,84.91 136.72,84.82 136.72,84.4 136.63,84.31 135.97,84.31 135.77,84.11 135.77,83.54 135.97,83.33 136.63,83.33 136.72,83.25 136.72,82.83 136.63,82.74 136.04,82.74 135.94,82.64 135.93,82.64 135.84,82.54 135.84,81.97 136.04,81.76 136.63,81.76 136.72,81.67 136.72,81.25 136.63,81.16 135.97,81.16 135.77,80.96 135.77,80.39 135.97,80.18 136.63,80.18 136.72,80.1 136.72,79.68 136.63,79.59 135.97,79.59 135.77,79.39 135.77,78.81 135.97,78.61 136.63,78.61 136.72,78.52 136.72,78.1 136.63,78.01 135.97,78.01 135.77,77.81 135.77,77.24 135.97,77.04 136.63,77.04 136.72,76.95 136.72,76.53 136.63,76.44 135.97,76.44 135.77,76.24 135.77,75.66 135.97,75.46 136.63,75.46 136.72,75.37 136.72,74.95 136.63,74.86 136.07,74.86 135.86,74.66 135.86,72.78 135.34,72.26 135.34,69.71 132.41,66.79 132.41,64.79 132.61,64.59 132.84,64.59 132.92,64.51 132.92,64.08 132.83,63.99 132.61,63.99 132.41,63.79 132.41,62.18 132.77,61.83 132.84,61.83 133.06,61.6 v1(133.06,61.53)
  BOTTOM w0.114: v1(133.06,61.53) 133.06,61.88 133.24,62.05 134.46,62.05 136.59,59.92 136.59,59.63 136.42,59.47 JDIM3.140
M_B_DIM1_CLKP0: length 68.5
  TOP w0.089: U3.AM11 142.19,111.4 v1(141.88,111.71)
  IN1 w0.079: 138.76,96.76 138.76,97.24 139.2,97.68 139.2,105.31 139.6,105.71 139.6,107.86 140.5,108.76 140.5,109.99 141.37,110.86 141.37,111.13 141.88,111.63 v1(141.88,111.71)
  IN1 w0.089: v1(136.14,53.25) 136.14,53.18 136.27,53.06 136.43,53.06 136.56,53.19 136.56,53.89 136.47,53.97 135.73,53.97 135.51,54.19 135.51,55.05 135.22,55.34 135.22,60.26 135.07,60.4 134.63,60.4 134.37,60.67 134.37,66.7 136.79,69.11 136.79,71.66 137.31,72.18 137.31,73.5 138.17,74.35 138.17,94.97 138.78,95.59 138.78,96.74 138.76,96.76
  BOTTOM w0.102: v1(136.14,53.25) 136.25,53.14 137.1,53.14 137.4,52.84 137.4,51.51 137.17,51.28 JDIM3.137
M_B_DIM1_CLKP1: length 71.6
  TOP w0.089: v1(140.12,110.46) 140.33,110.46 140.53,110.66 U3.AJ10
  IN1 w0.079: 138.27,97.36 138.27,97.45 138.85,98.03 138.85,105.66 139.24,106.05 139.24,108.08 140.02,108.86 140.02,109.93 139.73,110.22 139.73,110.63 139.84,110.74 140.04,110.74 140.17,110.62 140.17,110.5 v1(140.12,110.46)
  IN1 w0.089: 138.27,97.36 138.27,95.86 136.9,94.49 136.9,93.82 136.91,93.82 136.91,86.12 136.62,85.83 136.29,85.83 136.2,85.73 136.2,85.19 136.29,85.1 136.71,85.1 136.91,84.9 136.91,84.32 136.71,84.12 136.04,84.12 135.96,84.03 135.96,83.62 136.05,83.52 136.71,83.52 136.91,83.32 136.91,82.75 136.71,82.55 136.12,82.55 136.03,82.46 136.03,82.04 136.12,81.95 136.71,81.95 136.91,81.75 136.91,81.17 136.71,80.97 136.04,80.97 135.96,80.88 135.96,80.46 136.04,80.38 136.71,80.38 136.91,80.17 136.91,79.6 136.71,79.4 136.04,79.4 135.96,79.31 135.96,78.89 136.04,78.8 136.71,78.8 136.91,78.6 136.91,78.02 136.71,77.82 136.04,77.82 135.96,77.73 135.96,77.31 136.04,77.23 136.71,77.23 136.91,77.03 136.91,76.45 136.71,76.25 136.04,76.25 135.96,76.16 135.96,75.74 136.04,75.65 136.71,75.65 136.91,75.45 136.91,74.87 136.71,74.67 136.14,74.67 136.06,74.58 136.06,72.7 135.53,72.18 135.53,69.64 132.6,66.71 132.6,64.87 132.69,64.78 132.92,64.78 133.11,64.59 133.11,64 132.91,63.8 132.69,63.8 132.6,63.71 132.6,62.26 132.85,62.02 133.02,62.02 133.11,62.11 133.11,62.47 v1(133.07,62.51)
  BOTTOM w0.114: JDIM3.138 136.92,59.47 136.8,59.59 136.8,60.01 134.55,62.27 133.31,62.27 v1(133.07,62.51)
M_B_DQ0: length 80.4
  TOP w0.089: U3.BT11 160.86,111.34 161.71,110.49 162.42,110.49 162.81,110.88 v1(162.82,110.88)
  TOP w0.102: JDIM1.4 172.32,51.26 172.1,51.48 172.1,53.01 172,53.11 v1(171.36,53.11)
  IN1 w0.114: v1(171.36,53.11) 170.81,53.67 170.81,56.73 171.08,57 171.35,57 171.66,57.31 171.66,60.13 171.54,60.24 170.92,60.24 170.81,60.36 170.81,60.59 170.92,60.7 171.54,60.7 171.66,60.81 171.66,61.04 171.54,61.16 170.92,61.16 170.81,61.27 170.81,64.93 168.43,67.3 168.43,91.25 172.8,95.62 172.8,104.29 166.21,110.88 164.78,110.88 164.29,111.36 163.31,111.36 v1(162.82,110.88)
  BOTTOM w0.102: v1(171.36,53.11) 171.22,53.11 169.67,51.57 JDIM3.7
M_B_DQ1: length 80.4
  TOP w0.089: U3.BR11 159.8,111.34 159.95,111.18 159.95,111.18 160.09,111.04 160.88,111.04 161.66,110.27 162.88,110.27 v1(163.49,110.88)
  TOP w0.102: v1(171.34,52.43) 171.39,52.43 171.9,51.92 171.9,51.64 171.32,51.07 JDIM1.8
  IN1 w0.114: v1(163.49,110.88) 163.86,110.5 165.24,110.5 165.83,109.91 166.69,109.91 172.46,104.15 172.46,95.77 168.09,91.4 168.09,67.11 170.47,64.73 170.47,59.89 170.58,59.78 171.15,59.78 171.27,59.66 171.27,59.43 171.15,59.32 170.58,59.32 170.47,59.21 170.47,58.98 170.58,58.86 171.15,58.86 171.27,58.75 171.27,58.52 171.15,58.41 170.58,58.41 170.47,58.29 170.47,58.06 170.58,57.95 171.15,57.95 171.27,57.83 171.27,57.61 171.15,57.49 170.58,57.49 170.47,57.38 170.47,53.3 v1(171.34,52.43)
  BOTTOM w0.102: v1(171.34,52.43) 171.28,52.43 170.67,51.82 JDIM3.3
M_B_DQ2: length 77
  TOP w0.089: v1(160.9,110.48) U3.BT9
  TOP w0.102: JDIM1.20 168.32,51.65 v1(167.77,52.21)
  IN1 w0.079: 164.3,109.56 162.83,109.56 162.47,109.92 161.69,109.92 161.13,110.48 v1(160.9,110.48)
  IN1 w0.114: 164.3,109.56 164.6,109.56 165.47,108.69 165.47,108.51 165.27,108.31 165.27,108.09 165.4,107.96 165.56,107.96 165.88,108.28 166.04,108.28 166.21,108.11 166.21,107.95 165.86,107.61 165.86,107.44 166.02,107.28 166.18,107.28 166.53,107.63 166.69,107.63 166.85,107.47 166.85,107.31 166.53,106.99 166.53,106.8 166.68,106.65 166.84,106.65 167.18,106.98 167.34,106.98 167.5,106.82 167.5,106.66 167.18,106.34 167.18,106.14 167.33,106 167.49,106 167.82,106.34 167.98,106.34 171.37,102.95 171.37,96.28 167,91.91 167,66.64 169.12,64.52 169.12,55.69 168.54,55.11 168.54,52.98 v1(167.77,52.21)
  BOTTOM w0.102: v1(167.77,52.21) 167.17,51.61 JDIM3.17
M_B_DQ3: length 79.7
  TOP w0.089: v1(163.14,109.11) 162.86,108.83 162.33,108.83 162.21,108.95 161.33,108.95 160.45,109.83 160.09,109.83 160.03,109.76 U3.BR8
  TOP w0.102: v1(167.76,53.46) 168.39,52.83 169.32,51.68 JDIM1.16
  IN1 w0.114: v1(167.76,53.46) 168.2,53.9 168.2,55.27 168.77,55.85 168.77,64.38 166.65,66.5 166.65,92.05 171,96.39 171,101.71 170.44,102.27 170.44,102.43 170.77,102.76 170.77,102.94 170.61,103.09 170.45,103.09 170.11,102.76 169.95,102.76 169.79,102.92 169.79,103.08 170.14,103.43 170.14,103.59 169.98,103.75 169.82,103.75 169.47,103.4 169.31,103.4 169.14,103.57 169.14,103.73 169.51,104.1 169.51,104.26 169.36,104.41 169.18,104.41 168.82,104.05 168.66,104.05 168.5,104.21 168.5,104.37 168.82,104.7 168.82,104.86 168.68,105.01 168.48,105.01 168.17,104.7 168.01,104.7 167.85,104.86 167.85,105.02 168.07,105.24 168.07,105.42 167.92,105.57 167.75,105.57 167.53,105.34 167.37,105.34 165.39,107.31 164.45,107.31 163.14,108.62 v1(163.14,109.11)
  BOTTOM w0.102: v1(167.76,53.46) 166.81,52.5 166.43,51.93 166.17,51.44 JDIM3.21
M_B_DQ4: length 80.7
  TOP w0.089: U3.BP11 159.15,111.34 159.44,111.63 160.84,111.63 161.25,111.22 161.65,111.22 v1(161.94,111.51)
  TOP w0.102: JDIM1.7 171.57,57.46 171.32,57.2 171.16,57.2 171.01,57.05 171.01,56.9 171.16,56.75 171.79,56.75 v1(172,56.54)
  IN1 w0.114: v1(172,56.54) 172,61.69 171.88,61.8 171.27,61.8 171.15,61.91 171.15,62.14 171.27,62.26 172.23,62.26 172.37,62.39 172.37,62.6 172.25,62.71 171.27,62.71 171.15,62.83 171.15,63.06 171.27,63.17 172.23,63.17 172.37,63.31 172.37,63.51 172.25,63.63 171.27,63.63 171.15,63.74 171.15,63.97 171.27,64.09 171.88,64.09 172,64.2 172,64.44 171.88,64.56 171.37,64.56 171.15,64.78 171.15,65.2 168.78,67.57 168.78,91.11 173.15,95.48 173.15,104.43 166.29,111.28 165.05,111.28 164.63,111.71 162.14,111.71 v1(161.94,111.51)
  BOTTOM w0.102: v1(172,56.54) 171.49,56.54 170.42,57.6 JDIM3.4
M_B_DQ5: length 81.8
  TOP w0.089: v1(161.29,111.77) 161.02,111.77 160.95,111.83 159.36,111.83 159.15,111.62 158.79,111.62 158.5,111.34 U3.BN11
  TOP w0.102: JDIM1.3 172.57,57.52 172.84,57.26 172.84,56.39 172.35,55.91 171.74,55.91 v1(171.57,56.08)
  IN1 w0.114: v1(161.29,111.77) 161.57,112.05 164.88,112.05 165.28,111.64 166.42,111.64 173.49,104.57 173.49,95.34 169.12,90.97 169.12,67.81 172.83,64.1 172.83,61.37 172.72,61.25 172.46,61.25 172.34,61.14 172.34,60.91 172.46,60.8 172.76,60.8 172.89,60.66 172.89,60.45 172.78,60.34 172.46,60.34 172.34,60.22 172.34,60 172.46,59.88 172.76,59.88 172.89,59.75 172.89,59.54 172.78,59.42 172.46,59.42 172.34,59.31 172.34,59.08 172.46,58.97 172.76,58.97 172.89,58.83 172.89,58.62 172.78,58.51 172.46,58.51 172.34,58.4 172.34,58.17 172.46,58.05 172.72,58.05 172.83,57.94 172.83,56.79 172.13,56.08 v1(171.57,56.08)
  BOTTOM w0.102: v1(171.57,56.08) 170.14,56.87 169.42,57.59 JDIM3.8
M_B_DQ6: length 80
  TOP w0.089: v1(162.5,109.23) 162.41,109.15 161.38,109.15 160.47,110.05 159.21,110.05 U3.BP8
  TOP w0.102: v1(167.78,55.55) 168.26,55.55 169.07,56.37 JDIM1.17
  IN1 w0.079: 165.11,106.62 164.59,107.14 164.04,107.14 162.4,108.79 162.4,109.13 v1(162.5,109.23)
  IN1 w0.114: 165.11,106.62 165.57,106.16 165.57,105.86 165.68,105.75 165.88,105.75 165.99,105.63 165.99,105.37 165.85,105.22 165.68,105.22 165.57,105.11 165.57,104.87 165.73,104.7 167.52,104.7 170.66,101.57 170.66,96.54 166.31,92.19 166.31,66.36 166.53,66.14 166.53,65 166.59,64.94 166.7,64.84 167.61,64.84 167.76,64.69 167.76,64.4 167.67,64.32 166.73,64.32 166.61,64.2 166.61,63.89 166.71,63.79 168.35,63.79 168.43,63.71 168.43,63.39 168.32,63.28 166.65,63.28 166.53,63.17 166.53,62.94 166.65,62.82 168.32,62.82 168.43,62.71 168.43,55.99 167.99,55.55 v1(167.78,55.55)
  BOTTOM w0.102: v1(167.78,55.55) 167.73,55.55 166.63,56.65 166.63,57.27 166.42,57.48 JDIM3.20
M_B_DQ7: length 78.3
  TOP w0.089: U3.BN8 158.32,109.76 158.6,110.05 158.88,110.05 159.09,110.26 160.56,110.26 160.94,109.88 161.2,109.88 v1(161.28,109.8)
  TOP w0.102: v1(167.75,56.89) 168.07,57.21 JDIM1.21
  IN1 w0.079: v1(161.28,109.8) 161.28,109.48 163.91,106.85 164.39,106.85 165.11,106.14
  IN1 w0.114: 165.11,106.14 165.21,106.03 165.21,105.17 165.07,105.04 163.72,105.04 163.53,104.84 163.53,104.51 163.67,104.36 167.38,104.36 170.31,101.42 170.31,96.68 165.97,92.33 165.97,66.21 166.19,65.99 166.19,62.56 166.4,62.35 167.67,62.35 167.8,62.22 167.8,62.01 167.69,61.89 166.55,61.89 166.44,61.78 166.44,61.58 166.58,61.43 167.97,61.43 168.09,61.32 168.09,61.09 167.97,60.98 167.56,60.98 167.45,60.86 167.45,60.63 167.56,60.52 167.97,60.52 168.09,60.41 168.09,60.18 167.97,60.06 167.56,60.06 167.45,59.95 167.45,59.72 167.56,59.61 167.97,59.61 168.09,59.49 168.09,59.26 167.97,59.15 167.56,59.15 167.45,59.03 167.45,58.81 167.56,58.69 167.97,58.69 168.09,58.58 168.09,58.35 167.97,58.23 167.56,58.23 167.45,58.12 167.45,57.89 167.56,57.78 167.97,57.78 168.09,57.66 168.09,57.22 v1(167.75,56.89)
  BOTTOM w0.102: JDIM3.16 167.42,57.36 167.75,57.04 v1(167.75,56.89)
M_B_DQ8: length 76.4
  TOP w0.089: v1(157.29,111.73) 156.96,112.06 U3.BL12
  TOP w0.102: JDIM1.28 166.32,51.88 165.94,52.27 v1(165.8,52.27)
  IN1 w0.079: v1(157.29,111.73) 157.29,111.01 157.83,110.47 159.9,110.47 163.06,107.3 163.06,106.42 162.83,106.18 162.83,105.35
  IN1 w0.114: 162.83,105.35 162.83,104.61 163.5,103.94 167.2,103.94 169.9,101.25 169.9,96.85 165.55,92.51 165.55,66.04 165.77,65.82 165.77,61.66 167.03,60.4 167.03,53.33 165.97,52.27 v1(165.8,52.27)
  BOTTOM w0.102: v1(165.8,52.27) 165.17,51.64 JDIM3.25
M_B_DQ9: length 78.2
  TOP w0.089: v1(156.49,111.72) U3.BL11
  TOP w0.102: JDIM1.24 167.32,51.25 166.76,51.81 166.76,52.31 166.15,52.92 v1(165.79,52.92)
  IN1 w0.079: v1(156.49,111.72) 157.01,111.2 157.01,111.04 157.79,110.26 159.48,110.26 160.18,109.56 160.18,106.66
  IN1 w0.114: v1(165.79,52.92) 165.85,52.92 166.68,53.75 166.68,60.26 165.43,61.52 165.43,65.68 165.21,65.9 165.21,92.65 169.55,96.99 169.55,101.11 167.06,103.6 162.62,103.6 160.18,106.04 160.18,106.66
  BOTTOM w0.102: v1(165.79,52.92) 165.53,52.92 164.17,51.56 JDIM3.29
M_B_DQ10: length 76.1
  TOP w0.089: U3.BL8 v1(157.29,110.16)
  TOP w0.102: v1(165.81,55.11) 166.21,55.11 166.9,55.8 166.9,57.24 167.07,57.41 JDIM1.25
  IN1 w0.079: v1(157.29,110.16) 157.52,109.92 159.37,109.92 159.74,109.56 159.74,106.8
  IN1 w0.114: 159.74,106.8 159.74,105.91 162.39,103.26 166.92,103.26 169.21,100.97 169.21,97.14 164.86,92.79 164.86,65.75 165.08,65.54 165.08,61.04 165.2,60.92 165.53,60.92 165.66,60.8 165.66,60.58 165.54,60.47 165.2,60.47 165.08,60.35 165.08,60.01 165.2,59.89 165.62,59.89 166.26,59.26 166.26,55.41 165.95,55.11 v1(165.81,55.11)
  BOTTOM w0.102: JDIM3.28 164.42,56.43 165.75,55.11 v1(165.81,55.11)
M_B_DQ11: length 76.8
  TOP w0.089: v1(155.62,109.77) U3.BJ8
  TOP w0.102: JDIM1.37 164.07,56.32 163.58,55.83 v1(162.32,55.83)
  IN1 w0.079: 159.68,100.1 159.68,101.14 158.19,102.64 158.19,103.34 156.18,105.34 156.18,108 156.02,108.16 156.02,109.38 v1(155.62,109.77)
  IN1 w0.114: v1(162.32,55.83) 162.32,55.88 162.75,56.31 162.75,64.74 162.74,64.74 162.74,66.49 162.63,66.6 162.08,66.6 161.96,66.71 161.96,66.92 162.1,67.06 162.63,67.06 162.74,67.17 162.74,67.4 162.63,67.51 162.08,67.51 161.96,67.63 161.96,67.84 162.1,67.97 162.63,67.97 162.74,68.09 162.74,68.32 162.63,68.43 162.08,68.43 161.96,68.54 161.96,68.75 162.1,68.89 162.63,68.89 162.74,69 162.74,69.23 162.63,69.34 162.08,69.34 161.96,69.46 161.96,69.67 162.1,69.8 162.63,69.8 162.74,69.92 162.74,70.14 162.63,70.26 162.08,70.26 161.96,70.37 161.96,70.58 162.1,70.72 162.63,70.72 162.74,70.83 162.74,71.06 162.63,71.17 162.08,71.17 161.96,71.29 161.96,71.5 162.1,71.63 162.63,71.63 162.74,71.74 162.74,71.97 162.63,72.09 162.08,72.09 161.96,72.2 161.96,72.41 162.1,72.54 162.63,72.54 162.74,72.66 162.74,73 162.63,73.12 162.08,73.12 161.96,73.23 161.96,73.46 162.08,73.57 162.63,73.57 162.74,73.69 162.74,74.03 162.63,74.14 162.08,74.14 161.96,74.26 161.96,74.49 162.08,74.6 162.63,74.6 162.74,74.72 162.74,75.06 162.63,75.17 162.08,75.17 161.96,75.29 161.96,89.34 161.15,90.15 161.15,95.46 159.68,96.92 159.68,97.42 159.68,100.1
  BOTTOM w0.102: JDIM3.42 160.92,57.22 162.32,55.83 v1(162.32,55.83)
