# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_VREFC: length 56.7
  TOP w0.3: VRAM1.K1 26.65,148.47 v2(26.46,148.47) ; v2(52.56,148.7) 52.35,148.91 VRAM2.K1
  IN2 w0.381: v1(54.05,156.86) 54,156.91 51.95,156.91 51.65,156.62 49.16,156.62 48.85,156.31 45.19,156.31 43.88,157.63 41.84,157.63 41.51,157.3 38.68,157.3 38.1,156.72 31.47,156.72 30.57,155.82 27.93,155.82 27.6,156.15 26.59,156.15 25.49,155.06 v2(24.98,155.06)
  IN4 w0.381: v1(54.05,156.86) 55.01,155.91 55.01,153.03 54.19,152.21 54.19,151.14 54.63,150.69 54.63,149.28 54.06,148.7 v2(52.56,148.7)
  IN4 w0.4: v2(26.46,148.47) 25.46,148.47 24.98,148.95 v2(24.98,155.06)
  BOTTOM w0.254: v2(26.46,148.47) 25.92,147.93 25.92,147.78 25.63,147.49 25.23,147.49 24.85,147.11 RG96.2 24.54,146.57 24.66,146.45 RG98.2 RG99.2 ; v2(52.56,148.7) 52.6,148.75 CG191.1
FBC_ZQ_1_A: length 1.4
  TOP w0.102: v2(37.15,149.32) 37.11,149.32 VRAM1.J14
  BOTTOM w0.14: v2(37.15,149.32) 37.67,148.8 RG87.1
FBC_ZQ_1_B: length 1.5
  TOP w0.102: v2(37.08,148.53) VRAM1.K14
  BOTTOM w0.14: RG94.1 37.76,147.85 v2(37.08,148.53)
FBC_ZQ_2_A: length 2.1
  TOP w0.3: VRAM2.J14 42.14,148.16 v2(41.82,148.48)
  BOTTOM w0.254: RG89.1 41.75,148.41 v2(41.82,148.48)
FBC_ZQ_2_B: length 1.9
  TOP w0.3: v2(41.89,149.28) VRAM2.K14
  BOTTOM w0.254: RG85.1 40.9,149.5 41.68,149.5 v2(41.89,149.28)
FBD_CMD0: length 28.4
  TOP w0.165: v2(17.25,107.76) 17.25,107.38 18.6,106.02 23.4,106.02 27.65,110.28 32.87,110.28 33.22,110.63 33.22,110.71 35.14,112.63 36.42,112.63 36.65,112.39 37.13,112.39 37.49,112.75 UG1.AD2
  TOP w0.178: VRAM7.H3 v2(16.53,110.93)
  IN2 w0.114: v2(16.53,110.93) 16.53,110.89 16.87,110.55 16.87,108.13 v2(17.25,107.76)
FBD_CMD1: length 26
  TOP w0.14: VRAM7.K3 v2(17.26,110.17) 17.25,110.17 VRAM7.J3
  TOP w0.165: UG1.AD1 36.67,112.75 36.53,112.89 34.91,112.89 32.84,110.83 27.43,110.83 23.17,106.57 19.07,106.57 18.5,107.14 v2(18.5,107.57)
  IN2 w0.102: v2(18.5,107.57) 18.5,107.64 17.7,108.44 17.7,108.94 17.59,109.05 17.59,109.84 v2(17.26,110.17)
FBD_CMD2: length 28.8
  TOP w0.165: VRAM7.J1 16.88,108.93 v2(16.5,108.55) 16.91,108.14 18.69,108.14 19.07,107.77 19.07,107.39 19.57,106.88 23.02,106.88 25.67,109.53 25.67,109.85 27.2,111.37 32.92,111.37 34.71,113.16 36.67,113.16 36.73,113.1 38.7,113.1 UG1.AD4
  BOTTOM w0.165: v2(16.5,108.55) 16.27,108.32 16.27,107.74 15.78,107.24 RG119.1
FBD_CMD3: length 26.4
  TOP w0.14: VRAM7.K4 17.63,111.29 v2(17.26,111.66) 16.88,111.29 VRAM7.J4
  TOP w0.165: UG1.AC1 34.44,113.45 32.92,111.92 26.91,111.92 25.22,110.23 25.22,109.53 23.6,107.91 19.9,107.91 v2(19.55,107.56)
  IN2 w0.102: v2(17.26,111.66) 18.74,110.18 18.74,108.37 v2(19.55,107.56)
FBD_CMD4: length 24.1
  TOP w0.102: UG1.AC2 37.44,113.45 37.13,113.75 36.82,113.75 36.79,113.72 36.63,113.72
  TOP w0.165: VRAM7.L3 18.76,110.16 18.76,108.75 19.33,108.18 23.41,108.18 24.75,109.52 24.75,110.6 26.62,112.47 33.03,112.47 34.28,113.72 36.63,113.72
FBD_CMD5: length 21.1
  TOP w0.102: UG1.AC3 38.2,113.45 37.85,113.8 37.45,113.8 37.26,113.99 36.47,113.99
  TOP w0.165: 36.47,113.99 34.13,113.99 33.23,113.1 25.68,113.1 25.46,112.88 19.8,112.88 19.5,112.58 19.5,111.65 VRAM7.M4
FBD_CMD6: length 23.1
  TOP w0.14: VRAM7.K5 17.32,112.35 17.2,112.35 VRAM7.J5
  TOP w0.165: 17.32,112.35 17.5,112.52 17.81,112.52 18.43,113.14 25.17,113.14 25.67,113.64 33.12,113.64 33.73,114.26 36.58,114.26 36.61,114.22 37.25,114.22 37.51,114.49 37.79,114.49 38.16,114.85 38.35,114.85 UG1.AA3
FBD_CMD7: length 25.2
  TOP w0.14: v2(15.87,112.61) 16.13,112.34 VRAM7.H5 ; v2(18.57,112.64) 18.38,112.45 VRAM7.L5
  TOP w0.165: UG1.AA2 37.5,114.85 37.14,114.49 36.72,114.49 36.69,114.52 33.39,114.52 33.06,114.19 25.61,114.19 24.83,113.41 18.29,113.41 17.84,112.96 v2(17.47,112.96)
  IN2 w0.089: v2(18.57,112.64) 17.8,112.64 v2(17.47,112.96) 16.96,112.85 16.79,112.81 v2(15.87,112.61)
FBD_CMD8: length 24.4
  TOP w0.165: UG1.AA1 32.63,114.85 32.51,114.74 25.59,114.74 24.53,113.68 18.18,113.68 17.99,113.49 17.18,113.49 16.85,113.16 15.55,113.16 15.01,112.62 15.01,111.66 VRAM7.G4
FBD_CMD9: length 27.3
  TOP w0.165: VRAM7.G11 15.01,116.16 15.01,114.62 15.43,114.19 16.01,114.19 16.05,114.22 17.02,114.22 17.48,113.76 17.88,113.76 18.07,113.94 24.24,113.94 25.58,115.28 32.15,115.28 32.23,115.2 38.7,115.2 UG1.AA4
FBD_CMD10: length 26.9
  TOP w0.135: 36.95,115.55 UG1.Y1
  TOP w0.14: v2(19.37,115.17) 19.13,115.41 VRAM7.M10 ; v2(15.51,115.31) 15.38,115.44 VRAM7.G10
  TOP w0.165: 36.95,115.55 32.47,115.55 32.19,115.83 25.56,115.83 23.94,114.21 17.83,114.21 v2(17.72,114.31)
  IN2 w0.089: v2(15.51,115.31) 16.51,114.31 v2(17.72,114.31) 18.74,114.31 19.37,114.94 v2(19.37,115.17)
  BOTTOM w0.165: v2(17.72,114.31) 18.56,114.31 RG114.2
FBD_CMD11: length 25.5
  TOP w0.14: VRAM7.H10 16.13,115.25 16.41,114.97 17.05,114.97 17.18,114.84 17.33,114.99 18.19,114.99 18.38,115.19 VRAM7.L10
  TOP w0.165: 17.18,114.84 17.29,114.73 18.77,114.73 19.03,114.48 23.69,114.48 25.59,116.37 32.3,116.37 32.86,115.82 36.74,115.82 36.81,115.89 37.09,115.89 37.43,115.55 UG1.Y2
FBD_CMD12: length 22.1
  TOP w0.102: UG1.Y3 38.35,115.55 38.16,115.55 37.81,115.9 37.57,115.9 37.35,116.12 36.72,116.12 36.68,116.08 36.55,116.08
  TOP w0.165: VRAM7.M11 19.51,116.16 19.51,115.62 19.86,115.27 19.86,114.92 20.04,114.74 23.48,114.74 23.81,115.07 23.81,115.29 25.44,116.92 32.37,116.92 33.08,116.2 35.56,116.2 35.68,116.08 36.55,116.08
FBD_CMD13: length 25.2
  TOP w0.102: UG1.V3 38.14,116.95 37.78,116.59 37.56,116.59 37.32,116.36 36.53,116.36
  TOP w0.135: v2(18.02,116.9) 18.08,116.96 18.08,116.97 18.38,117.27 VRAM7.L12
  TOP w0.165: 36.53,116.36 35.96,116.36 35.8,116.51 35.74,116.57 33.28,116.57 32.26,117.58 26.19,117.58 24.15,119.62 18.47,119.62 18.07,119.22 18.06,119.21 v2(18.06,119.21)
  IN4 w0.102: v2(18.02,116.9) 18.07,116.9 18.41,117.25 18.41,118.82 18.06,119.17 v2(18.06,119.21)
FBD_CMD14: length 30
  TOP w0.14: VRAM7.J11 17.2,116.22 v2(17.25,116.22) 17.57,116.53 VRAM7.K11
  TOP w0.165: UG1.V2 37.44,116.95 37.11,116.61 36.81,116.61 36.74,116.68 36.01,116.68 35.77,116.92 33.43,116.92 32.22,118.13 27.28,118.13 25.94,119.47 24.91,119.47 24.49,119.9 18.25,119.9 18.1,119.75 16.84,119.75 v2(16.15,120.44)
  IN2 w0.114: v2(17.25,116.22) 17.65,116.61 17.65,118.64 17.42,118.87 16.34,118.87 16.22,118.98 16.22,120.37 v2(16.15,120.44)
FBD_CMD15: length 29.3
  TOP w0.14: VRAM7.J12 17.23,117.63 v2(17.26,117.63) 17.29,117.63 VRAM7.K12
  TOP w0.165: UG1.V1 36.12,116.95 35.79,117.28 33.7,117.28 32.31,118.67 27.51,118.67 26.17,120.02 24.91,120.02 24.66,120.27 18.42,120.27 17.86,120.82 15.4,120.82 v2(14.98,120.41)
  IN2 w0.114: v2(14.98,120.41) 14.98,119.9 15.41,119.47 15.41,118.16 15.56,118.02 16.88,118.02 v2(17.26,117.63)
FBD_CMD16: length 37
  TOP w0.102: 37.47,122.19 37.74,122.19 38.08,121.85 UG1.L3
  TOP w0.135: v2(16.46,131.43) 16.46,131.5 VRAM5.L3
  TOP w0.165: 37.47,122.19 37.21,122.45 36.13,122.45 35.04,123.54 35.04,127.16 28.69,133.51 27.34,133.51 23.96,136.9 20.7,136.9 19.97,136.17 16.33,136.17 15.37,135.21 v2(15.37,134.88)
  IN2 w0.114: v2(15.37,134.88) 15.37,133.55 15.56,133.37 15.94,133.37 16.12,133.19 16.12,131.78 v2(16.46,131.43)
FBD_CMD17: length 34.6
  TOP w0.14: VRAM5.J3 17.61,131.83 v2(17.27,132.17) 16.94,131.83 VRAM5.K3
  TOP w0.165: UG1.L2 37.43,121.85 37.1,122.19 36.53,122.19 36.52,122.18 36.03,122.18 34.77,123.43 34.77,126.63 28.44,132.97 27.12,132.97 23.68,136.4 20.72,136.4 19.99,135.67 16.72,135.67 15.91,134.86 15.91,134.3 v2(16.41,133.81)
  IN2 w0.114: v2(17.27,132.17) 16.86,132.58 16.86,133.35 v2(16.41,133.81)
FBD_CMD18: length 33.8
  TOP w0.165: VRAM5.J1 17.63,134.57 v1(17.72,134.66) 17.72,135.09 18.03,135.4 23.63,135.4 26.61,132.42 28.2,132.42 34.43,126.19 34.43,123.4 35.98,121.85 UG1.L1
  BOTTOM w0.165: v1(17.72,134.66) 17.28,134.66 16.95,135 15.85,135 15.55,135.3 14.37,135.3 14.31,135.24 RG100.1
FBD_CMD19: length 34.2
  TOP w0.14: VRAM5.K4 16.88,130.95 17.14,130.69 v2(17.28,130.69) 17.45,130.69 17.63,130.88 VRAM5.J4
  TOP w0.165: v2(18.46,134.94) 18.96,134.44 19.46,134.44 19.73,134.7 23.5,134.7 24.96,133.24 24.96,132.74 25.83,131.88 27.91,131.88 34.12,125.67 34.12,123.34 35.95,121.5 38.7,121.5 UG1.M4
  IN2 w0.114: v2(17.28,130.69) 17.64,131.05 17.64,133.89 18.46,134.7 v2(18.46,134.94)
FBD_CMD20: length 28.5
  TOP w0.135: v2(18.04,131.49) 18.04,131.49 VRAM5.H3
  TOP w0.165: v2(18.81,133.7) 18.81,133.77 19.18,134.14 23.49,134.14 24.56,133.07 24.56,132.15 25.37,131.33 27.69,131.33 33.75,125.27 33.75,123.33 35.93,121.15 UG1.M1
  IN2 w0.114: v2(18.04,131.49) 18.18,131.49 18.39,131.69 18.39,133.29 v2(18.81,133.7)
FBD_CMD21: length 26.1
  TOP w0.102: UG1.M2 37.44,121.15 37.13,120.85 36.77,120.85 ; 36.29,120.85 36.29,120.85
  TOP w0.165: 36.29,120.85 36.77,120.85 ; 36.29,120.85 35.85,120.85 33.42,123.28 33.42,124.82 27.52,130.72 24.58,130.72 23.81,129.95 22.37,129.95 21.74,129.32 21.42,129.32 21.15,129.58 19.22,129.58 19.03,129.78 19.03,129.87 18.76,130.14 18.76,130.71 VRAM5.G4
FBD_CMD22: length 28.3
  TOP w0.14: VRAM5.J5 17.63,129.99 v2(17.33,129.68) 17.22,129.68 16.88,130.02 VRAM5.K5
  TOP w0.165: v2(18.61,129.66) 18.96,129.31 21.04,129.31 21.31,129.05 21.85,129.05 22.41,129.61 23.87,129.61 24.44,130.18 27.29,130.18 33.08,124.39 33.08,123.24 35.74,120.58 37.28,120.58 37.51,120.81 37.9,120.81 38.25,121.15 UG1.M3
  IN2 w0.089: v2(17.33,129.68) 18.59,129.68 v2(18.61,129.66)
FBD_CMD23: length 29.3
  TOP w0.14: VRAM5.L5 17.19,129.28 17.47,129.28 17.93,129.73 17.93,129.87 VRAM5.H5
  TOP w0.165: UG1.P3 38.19,119.75 37.85,120.09 37.46,120.09 37.24,120.31 35.63,120.31 32.76,123.19 32.76,123.94 27.06,129.63 24.45,129.63 24.09,129.26 22.44,129.26 21.96,128.78 21.2,128.78 20.93,129.05 18.85,129.05 18.72,129.18 17.45,129.18 17.35,129.28
FBD_CMD24: length 28.4
  TOP w0.102: 36.63,120.04 36.64,120.05 37.16,120.05 37.47,119.75 UG1.P2
  TOP w0.165: 36.63,120.04 35.52,120.04 32.4,123.16 32.4,123.52 26.84,129.09 24.39,129.09 24.18,128.88 22.44,128.88 22.07,128.52 21.08,128.52 20.82,128.78 18.74,128.78 18.64,128.88 16.38,128.88 16.15,129.12 16.15,129.79 15.77,130.17 15.77,130.7 VRAM5.M4
FBD_CMD25: length 28.4
  TOP w0.102: 36.92,119.72 UG1.P1
  TOP w0.165: VRAM5.M11 15.38,126.06 15,126.44 15,126.76 14.85,126.91 14.85,127.28 16.19,128.62 18.39,128.62 18.49,128.51 20.71,128.51 20.97,128.25 22.18,128.25 22.47,128.54 26.61,128.54 31.56,123.59 31.77,123.59 32.13,123.23 32.13,123.06 35.47,119.72 36.92,119.72
FBD_CMD26: length 36.3
  TOP w0.14: VRAM5.G10 19.13,127.13 v2(18.72,127.54) ; v2(15.26,127.07) 15.38,126.95 VRAM5.M10
  TOP w0.165: UG1.R4 38.71,119.39 36.85,119.39 36.78,119.46 35.36,119.46 31.77,123.04 31.34,123.04 30.79,123.59 30.55,123.59 30.45,123.49 30.22,123.49 29.97,123.73 29.97,123.96 30.08,124.07 30.08,124.3 29.84,124.54 29.6,124.54 29.5,124.44 29.26,124.44 29.02,124.68 29.02,124.91 29.13,125.02 29.13,125.25 28.88,125.5 28.65,125.5 28.55,125.39 28.31,125.39 28.07,125.63 28.07,125.87 28.17,125.97 28.17,126.21 27.93,126.45 27.7,126.45 27.59,126.34 27.36,126.34 27.12,126.59 27.12,126.82 27.22,126.92 27.22,127.16 26.39,127.99 24.87,127.99 24.74,128.13 22.67,128.13 22.53,127.98 20.86,127.98 20.6,128.25 18.33,128.25 18.22,128.35 16.72,128.35 16.57,128.2 16.57,127.88 v2(16.76,127.69)
  IN2 w0.089: v2(15.26,127.07) 15.01,127.32 15.01,127.68 15.12,127.78 16.67,127.78 v2(16.76,127.69) 16.79,127.7 17.53,127.36 17.74,127.36 18.68,127.49 v2(18.72,127.54)
  BOTTOM w0.165: RG103.2 15.29,127.1 v2(15.26,127.07)
FBD_CMD27: length 27.7
  TOP w0.14: VRAM5.L10 16.03,126.68 16.03,127.11 16.23,127.31 18.12,127.31 18.38,127.05 VRAM5.H10
  TOP w0.165: UG1.R1 36.81,119.05 36.67,119.19 35.08,119.19 31.77,122.5 30.43,122.5 25.48,127.45 24.68,127.45 24.43,127.7 20.69,127.7 20.41,127.98 18.14,127.98 18.04,128.08 17.4,128.08 17.18,127.86 17.18,127.31
FBD_CMD28: length 23.2
  TOP w0.102: 36.68,118.81 36.71,118.81 36.77,118.75 37.15,118.75 37.45,119.05 UG1.R2
  TOP w0.135: 24.75,126.85 24.15,127.45 20.24,127.45 19.51,126.72 19.51,126.2 VRAM5.G11
  TOP w0.165: 24.75,126.85 25.31,126.85 30.21,121.95 31.77,121.95 34.8,118.92 36.56,118.92 36.68,118.81
FBD_CMD29: length 25.3
  TOP w0.102: 36.57,118.54 37.35,118.54 37.51,118.7 38,118.7 UG1.R3
  TOP w0.135: 19.05,122.74 18.66,123.14 18.23,123.14 18.01,123.36 18.01,124.7 VRAM5.H12
  TOP w0.165: 36.57,118.54 36.45,118.66 34.69,118.66 31.94,121.41 28.89,121.41 27.55,122.75 24.28,122.75 23.19,121.67 20.72,121.67 19.64,122.74 19.05,122.74
FBD_CMD30: length 26.8
  TOP w0.14: VRAM5.J12 v2(17.26,124.7) VRAM5.K12
  TOP w0.165: UG1.U3 38.2,117.8 38,117.8 37.82,117.99 37.47,117.99 37.18,118.28 36.41,118.28 36.3,118.39 34.53,118.39 32.06,120.86 28.67,120.86 27.32,122.2 24.48,122.2 23.68,121.4 20.25,121.4 19.68,121.96 18.27,121.96 v2(17.83,122.4)
  IN1 w0.102: v2(17.83,122.4) 17.7,122.54 17.7,124.27 v2(17.26,124.7)
FBD_CMD31: length 28.4
  TOP w0.14: VRAM5.J11 17.63,125.99 17.46,126.16 v2(17.26,126.16) 17.08,126.16 16.88,125.97 VRAM5.K11
  TOP w0.165: UG1.U2 37.43,117.65 37.07,118.01 36.24,118.01 36.12,118.12 34.29,118.12 32.1,120.31 28.37,120.31 27.02,121.66 24.58,121.66 24.06,121.13 19.83,121.13 19.26,121.7 17.47,121.7 v2(16.83,122.34)
  IN1 w0.102: v2(16.83,122.34) 16.88,122.39 16.88,125.79 v2(17.26,126.16)
FBD_CMD32: length 33.9
  TOP w0.135: v2(16.48,116.88) 16.48,116.9 16.13,117.25 VRAM7.H12
  TOP w0.165: UG1.V4 38.71,117.29 36.18,117.29 35.9,117.56 33.94,117.56 32.27,119.22 27.74,119.22 26.39,120.56 18.88,120.56 18.33,121.12 14.46,121.12 v2(13.84,120.5)
  IN2 w0.114: v2(16.48,116.88) 16.45,116.88 16.08,116.5 14.88,116.5 14.65,116.73 14.65,119.38 13.84,120.19 v2(13.84,120.5)
FBD_CMD33: length 27.3
  TOP w0.135: v2(16.51,125.45) VRAM5.L12
  TOP w0.165: v2(15.73,122.38) 16.72,121.39 18.85,121.39 19.4,120.84 24.37,120.84 24.64,121.11 26.62,121.11 27.96,119.77 32.23,119.77 34.17,117.83 36.04,117.83 36.22,117.65 UG1.U1
  IN1 w0.102: v2(15.73,122.38) 16.12,122.77 16.12,125.07 v2(16.51,125.45)
FBD_DBI0: length 25.7
  TOP w0.102: v2(35.49,109.91) 35.61,109.91 35.91,109.62 35.95,109.58 36.62,109.58 UG1.AJ1
  TOP w0.178: VRAM7.D2 13.13,109.81 v2(12.74,110.2)
  IN4 w0.127: v2(12.74,110.2) 13.09,110.55 24.54,110.55 24.85,110.24 25.98,110.02 26.03,110.01 29.66,110.01 29.89,109.77 34.13,109.77 34.38,109.53 35.1,109.53 v2(35.49,109.91)
FBD_DBI1: length 31.3
  TOP w0.102: v2(34.89,110.75) 34.89,110.8 35.34,111.25 36.35,111.25 36.95,110.65 UG1.AG1
  TOP w0.168: v2(13.51,118.41) VRAM7.D13
  IN4 w0.127: v2(13.51,118.41) 13.17,118.07 12.58,118.07 12.38,117.87 12.38,115.94 12.27,115.82 12.27,115.06 13.76,113.57 15.74,112.24 17.52,112.24 18.8,112.04 24.45,112.04 24.63,111.87 25.51,111.51 30.1,111.28 33.78,111.19 34.21,110.75 v2(34.89,110.75)
FBD_DBI2: length 23.5
  TOP w0.168: UG1.AA7 41.42,114.6 41.42,114.58 v2(41.49,114.52) ; VRAM7.R13 21.73,118.38 v2(21.78,118.38)
  IN2 w0.14: v2(21.78,118.38) 21.73,118.38 21.39,118.04 21.39,117.45 21.57,117.27 24.58,117.27 24.65,117.34 35.04,117.34 37.27,115.11 38.44,115.11 38.83,114.72 40.9,114.72 41.01,114.7 41.36,114.59 41.39,114.55 v2(41.49,114.52)
FBD_DBI3: length 22.2
  TOP w0.168: v2(21.75,109.42) VRAM7.R2 ; UG1.AD5 39.42,112.42 v2(39.42,112.37)
  IN1 w0.127: v2(39.42,112.37) 39.42,112.49 39.21,112.69 37.68,112.69 37.18,113.19 35.34,113.19 34.92,113.61 25.95,113.61 24.73,112.39 24.37,112.03 22.37,112.03 22.15,111.81 22.15,109.81 v2(21.75,109.42)
FBD_DBI4: length 21.5
  TOP w0.168: VRAM5.D2 21,132.97 v2(21,132.97) ; UG1.D3 38.35,126.75 38.64,127.06 v2(38.69,127.06)
  IN2 w0.14: v2(21,132.97) 21.29,132.67 21.39,132.67 21.49,132.57 22.67,132.57 22.73,132.63 23.05,132.63 23.11,132.57 23.43,132.57 23.47,132.61 23.82,132.61 23.85,132.58 24.16,132.58 24.2,132.61 24.7,132.61 28.32,128.16 34.52,128.16 34.89,128.11 35.39,128.04 36.37,128.04 36.8,127.61 37.46,127.61 37.62,127.45 38.3,127.45 v2(38.69,127.06)
FBD_DBI5: length 21.1
  TOP w0.168: UG1.H3 v2(37.99,123.59) ; v2(21.02,123.94) 21.02,123.97 VRAM5.D13
  IN1 w0.127: v2(21.02,123.94) 21.03,123.94 21.4,124.31 21.91,124.31 22.13,124.53 22.13,124.54 22.13,124.55 22.13,124.86 22.13,124.86 22.13,125.63 22.33,125.83 29.54,125.83 31.15,124.21 33.97,124.21 35.49,122.69 36.89,122.69 37.79,123.59 v2(37.99,123.59)
FBD_DBI6: length 33.4
  TOP w0.168: v2(12.76,124.68) 12.78,124.68 VRAM5.R13 ; v2(40.05,117.3) 40.01,117.35 40.01,117.39 UG1.U5
  IN2 w0.14: v2(40.05,117.3) 40.01,117.35 40.01,117.39 39.72,117.68 39.21,117.68 38.73,117.21 38.05,117.21 35.34,119.92 18.38,119.92 17.55,120.74 17.03,120.74 16.35,121.43 15.29,121.43 14.98,121.74 13.36,121.74 12.39,122.71 12.39,124.31 12.69,124.61 v2(12.76,124.68)
FBD_DBI7: length 39.8
  TOP w0.168: v2(42.88,121.5) 42.88,121.48 UG1.M9 ; v2(13.51,132.95) 13.34,132.79 VRAM5.R2
  IN2 w0.14: v2(13.51,132.95) 13.88,132.58 14.1,132.58 15.23,132.58 15.38,132.43 15.38,131.26 16.43,130.21 18.73,130.21 18.9,130.39 20.57,130.39 20.75,130.21 20.75,129.89 21.12,129.09 21.37,128.49 21.37,125.27 21.57,125.07 24.48,125.07 25.23,125.82 33.6,125.82 33.79,125.64 34.35,125.64 35.04,124.95 36.36,124.95 36.76,124.55 37.72,124.08 38.23,124.02 38.91,124.02 39.06,123.87 39.06,123.38 39.4,123.04 39.6,123.04 39.79,123.23 41.06,123.23 41.2,123.09 41.2,122.89 41.32,122.77 41.43,122.66 42.26,122.66 42.57,122.35 42.57,121.82 v2(42.88,121.5)
FBD_DEBUG0: length 7.1
  TOP w0.102: UG1.AD3 38.12,112.75 37.78,112.41 37.48,112.41 37.23,112.16 36.55,112.16 36.32,112.39
  TOP w0.109: 36.32,112.39 35.4,112.39 34.34,111.34 v2(34.34,111.29)
  BOTTOM w0.165: TPG59.1 34.42,111.36 v2(34.34,111.29)
FBD_DEBUG1: length 4.8
  TOP w0.102: v2(35.89,123.55) 35.89,123.14 36.33,122.7 37.23,122.7 37.44,122.91 37.83,122.91 38.17,123.25 38.35,123.25 UG1.J3
  BOTTOM w0.165: TPG48.1 35.89,122.94 v2(35.89,123.55)
FBD_EDC0: length 32.2
  TOP w0.168: v2(37.96,109.6) 38.05,109.51 38.07,109.51 38.35,109.25 UG1.AJ3
  TOP w0.178: v2(11.99,109.42) 12.36,109.78 VRAM7.C2
  IN2 w0.14: v2(11.99,109.42) 12.39,109.81 12.96,109.81 13.12,109.97 13.12,110.38 13.29,110.55 15.91,110.55 16.11,110.35 16.11,107.97 16.99,107.09 20.34,107.09 20.9,107.65 23.36,107.65 26.06,110.34 36.57,110.34 36.6,110.31 36.94,109.97 37.58,109.97 v2(37.96,109.6)
FBD_EDC1: length 29.4
  TOP w0.102: v2(36.14,110.75) 36.26,110.75 36.65,110.36 36.73,110.29 37.29,110.29 UG1.AG2
  TOP w0.168: v2(12.76,117.66) VRAM7.C13
  IN4 w0.127: v2(12.76,117.66) 13.14,117.28 13.14,115.22 14.62,113.74 15.77,113.42 17.41,113.42 19.15,112.89 24.29,112.89 25.61,112.31 31.23,111.88 34.49,111.8 35.27,111.8 36.14,110.92 v2(36.14,110.75)
FBD_EDC2: length 23.1
  TOP w0.168: VRAM7.T13 22.49,117.68 v2(22.49,117.63) ; v2(42.9,115.15) 42.82,115.08 42.78,115.08 UG1.AA9
  IN2 w0.14: v2(42.9,115.15) 42.82,115.08 42.78,115.08 42.44,114.74 41.95,114.74 41.13,115.57 37.59,115.57 35.14,118.02 22.87,118.02 v2(22.49,117.63)
FBD_EDC3: length 21.7
  TOP w0.102: v2(38.12,112.17) 38.22,112.17 38.45,111.95 38.64,111.95 39.05,111.54 UG1.AF4
  TOP w0.168: VRAM7.T2 22.51,110.16 v2(22.58,110.16)
  IN1 w0.127: v2(22.58,110.16) 22.75,110.16 22.89,110.3 22.89,111.15 23.03,111.29 24.59,111.29 25.3,112 26.38,113.08 26.91,113.08 27.04,112.95 27.04,112.44 27.19,112.28 27.55,112.28 27.67,112.41 27.67,112.95 27.8,113.08 34.77,113.08 34.95,112.9 34.95,112.57 35.14,112.38 35.75,112.38 35.92,112.54 35.92,112.72 36.04,112.85 36.92,112.85 37.08,112.68 37.08,112.38 37.29,112.17 v2(38.12,112.17)
FBD_EDC4: length 20.7
  TOP w0.168: v2(38.01,126.44) 38.01,126.35 38.31,126.05 UG1.E3 ; v2(21.8,132.18) 21.8,132.2 21.81,132.21 21.81,132.26 VRAM5.C2
  IN2 w0.14: v2(21.8,132.18) 22.15,131.83 22.15,130.39 22.38,130.16 27,127.81 27.77,127.5 33.95,127.5 35.37,127.28 36.02,127.28 36.29,127.01 36.67,127.01 36.9,126.78 36.9,126.24 37.09,126.06 37.71,126.06 38.01,126.36 v2(38.01,126.44)
FBD_EDC5: length 21.1
  TOP w0.122: v2(35.55,124.57) 35.55,124.41 35.84,124.12 36.41,124.12 36.64,124.34 37.25,124.34 37.65,123.95 UG1.H2
  TOP w0.168: VRAM5.C13 21.78,124.68 v2(21.74,124.68)
  IN1 w0.127: v2(21.74,124.68) 21.74,124.73 21.39,125.08 21.39,125.3 21.38,125.65 21.56,125.83 21.95,125.83 22.13,126 22.13,127.09 22.54,127.5 29.81,127.5 32.03,125.28 34.69,125.28 35.4,124.57 v2(35.55,124.57)
FBD_EDC6: length 36.3
  TOP w0.168: VRAM5.T13 v2(12.01,123.95) ; v2(40.87,118.02) 40.82,117.97 40.77,117.97 UG1.U6
  IN2 w0.14: v2(12.01,123.95) 11.63,124.33 11.63,124.87 11.83,125.07 12.92,125.07 13.15,124.84 13.15,122.81 13.7,122.25 15.23,122.25 15.55,121.94 16.34,121.94 17.13,121.14 17.76,121.14 18.43,120.46 35.84,120.46 37.47,118.83 37.47,118.3 38.22,117.56 38.75,117.56 39.11,117.93 40.77,117.93 v2(40.87,118.02)
FBD_EDC7: length 33
  TOP w0.168: VRAM5.T2 12.61,132.36 v2(12.76,132.2) ; UG1.M5 v2(39.4,120.8)
  IN4 w0.127: v2(12.76,132.2) 13.13,131.84 13.13,131.3 13.34,131.08 13.72,131.08 13.88,130.93 13.88,130.56 14.12,130.32 15.59,130.32 16.21,129.7 16.77,129.7 17.18,129.29 18.86,129.29 20.47,127.69 20.93,127.69 21.38,127.23 21.38,126.74 21.53,126.59 21.95,126.59 22.15,126.39 22.15,125.97 22.3,125.82 24.23,125.82 25,125.05 26.16,125.05 27.98,123.23 28.8,123.23 29.45,122.58 31.52,121.65 33.72,121.06 34.69,120.8 v2(39.4,120.8)
FBD_VREFC: length 57.2
  TOP w0.254: VRAM5.K1 17.14,133.59 v2(17.14,133.78)
  TOP w0.3: v2(17.33,108.6) 17.33,108.6 17.63,108.9 VRAM7.K1
  IN2 w0.3: v1(9.51,135) 10.06,135 10.66,135.6 13.07,135.6 14.6,137.12 15.69,137.12 17.14,135.68 v2(17.14,133.78)
  BOTTOM w0.25: v2(17.33,108.6) 17.33,108.56 16.78,108.02 16.78,107.22 CG702.1 16.82,106.12 RG126.2 15.08,106.01 14.33,106.76 RG118.2 13.44,106.76 12.87,106.19 10.61,106.19 v1(9.76,107.04) 9.57,107.23 9.57,107.97 7,110.53 7,134.39 7.62,135 v1(9.51,135)
  BOTTOM w0.381: RG101.2 16.67,134.34 17.14,133.87 v2(17.14,133.78)
FBD_ZQ_1_A: length 1.4
  TOP w0.102: VRAM7.J14 16.88,118.96 v2(16.61,119.23)
  BOTTOM w0.14: v2(16.61,119.23) 16.56,119.23 16.07,119.72 RG109.1
FBD_ZQ_1_B: length 1.7
  TOP w0.102: VRAM7.K14 17.3,119.12 v2(17.3,119.24)
  BOTTOM w0.14: RG108.1 17.91,119.8 17.35,119.24 v2(17.3,119.24)
FBD_ZQ_2_A: length 2.7
  TOP w0.3: v2(17.31,123.14) 17.48,123.31 17.63,123.46 VRAM5.J14
  BOTTOM w0.225: v2(17.31,123.14) 17.31,122.15 17.86,121.6 RG106.1
FBD_ZQ_2_B: length 2.1
  TOP w0.3: v2(16.51,123.09) 16.88,123.47 VRAM5.K14
  BOTTOM w0.225: v2(16.51,123.09) 16.23,122.81 16.23,121.85 RG104.1
FBVDD_EN: length 131
  TOP w0.14: PR8.2 13.73,173.19 v1(13.2,173.73)
  IN2 w0.089: v1(43.9,82.55) 43.9,83.34 43.48,83.76 41.66,83.76 39.77,81.87 39.77,81.42 39.36,81.02 37.99,81.02 37.36,81.65 34.96,81.65 34.45,82.16 33.69,82.16 32.04,83.81 27.42,83.81 27.13,84.1 27.13,84.67 25.72,86.07 25.72,89.27 23.7,91.29 23.7,92.09 22.68,93.11 22.68,93.8 22.3,94.18 20.39,94.18 19.57,93.36 17.85,93.36 17.67,93.18 16.3,93.18 v1(16.23,93.26)
  IN3 w0.089: v1(13.2,173.73) 13.2,173.07 12.27,172.13 12.27,170.79 7.09,165.61 7.09,110.09 8.71,108.47 8.71,104.71 10.11,103.31 13.63,103.31 14.76,102.19 14.76,98.93 15.1,98.59 15.1,94.39 v1(16.23,93.26)
  BOTTOM w0.14: v1(43.9,82.55) 43.77,82.42 43.77,80.83 UG9.4
FBVDD_PSI: length 107.3
  TOP w0.102: 31.77,102.51 32.18,102.51 RG17.2 33.84,102.02 35.36,100.51 35.97,100.51 36.64,99.84 37.34,99.84 UG1.BB2
  TOP w0.14: v1(10.43,173.9) 10.66,173.9 11.4,173.17 PR5.2 ; v1(29.13,100.92) 29.3,101.09 29.3,101.35 29.69,101.74 30.93,101.74 31.7,102.51 31.77,102.51
  IN2 w0.089: v1(7.44,107.76) 7.44,105.76 9.68,103.51 13.97,103.51 15.28,102.21 18.98,102.21 19.8,103.02 23.02,103.02 25.06,100.98 29.08,100.98 v1(29.13,100.92)
  IN3 w0.089: v1(10.43,173.9) 10.31,173.78 9.95,173.78 9.44,173.27 9.44,171.9 7.28,169.74 7.28,167.5 6.1,166.32 6.1,108.62 6.95,107.76 v1(7.44,107.76)
FBVDDQ_MEM: length 130.7
  TOP w0.25: v2(72.46,143.29) 72.33,143.16 72.33,142.68 v2(72.46,142.54) ; VRAM6.N11 90.14,118.81 v2(90.14,118.8)
  TOP w0.28: VRAM3.L14 67.33,147.41 v2(67.71,147.03)
  TOP w0.3: v2(57.17,144.78) 57.2,144.78 57.57,145.16 VRAM3.P1 ; v2(83,155.28) VRAM4.V1 ; VRAM1.T11 v2(34.83,144.03) ; VRAM4.E1 82.63,145.13 v2(82.99,144.77) ; v2(41.85,152.32) VRAM2.P14 ; VRAM6.C4 v2(97.64,124.06) VRAM6.B5 ; v2(52.4,144.77) 52.39,144.77 52.39,144.78 52.39,144.78 52.39,144.78 52.01,145.16 VRAM2.E1 ; v2(26.58,153.78) VRAM1.C1 ; v2(60.17,151.51) VRAM3.E5 ; VRAM1.P1 26.95,145.16 v2(26.58,144.78) ; v2(67.7,153.78) VRAM3.C14 ; VRAM6.P10 89.02,119.89 v2(89.41,119.5) 89.72,119.18 VRAM6.N11 ; VRAM7.P14 20.63,118.78 v2(20.25,119.16) ; v2(57.17,141.86) 57.47,142.16 57.57,142.16 VRAM3.V1 ; v2(57.95,149.28) VRAM3.H1 v2(57.2,150.03) ; v2(57.95,149.28) VRAM3.H2 ; v2(57.95,149.28) VRAM3.J2 v2(57.95,148.53) VRAM3.K2 v2(57.95,147.78) ; v2(37.08,153.78) VRAM1.C14 ; v2(83,141.78) 82.63,142.16 VRAM4.A1 ; 87.52,103.18 v2(87.89,102.81) ; 87.52,103.18 v2(87.14,103.56) VRAM8.B5 ; 87.52,103.18 VRAM8.C4 ; v2(83,152.28) VRAM4.P1 ; v2(37.09,143.28) 36.71,143.66 VRAM1.T14 ; VRAM5.J13 v2(17.26,123.95) ; VRAM1.P5 29.58,145.53 v2(29.58,145.53) 29.58,145.53 VRAM1.N4 ; v2(57.2,153.78) VRAM3.C1 ; v2(97.64,116.56) VRAM6.C14 ; v2(41.84,144.79) 41.9,144.79 42.26,145.16 VRAM2.E14 ; v2(89.39,100.56) VRAM8.E1 88.99,100.93 v2(88.63,100.57) ; VRAM3.C4 v2(60.2,153.78) VRAM3.B5 v2(61,154.58) ; VRAM2.H1 v2(51.64,147.78) ; v2(51.64,147.78) VRAM2.J2 ; v2(51.64,147.78) VRAM2.H2 ; VRAM4.E14 72.88,145.16 72.86,145.16 v2(72.45,144.75) ; VRAM6.N4 89.39,124.06 v2(89.38,124.06) 89.38,124.05 VRAM6.P5 ; v2(57.17,143.28) 57.2,143.28 VRAM3.T1 ; VRAM2.C11 44.89,143.28 v2(44.89,143.28) 44.89,143.28 VRAM2.B10 v2(45.67,142.5) ; v2(86.39,123.31) VRAM6.U5 ; v2(67.7,155.28) VRAM3.A14 ; v2(50.14,146.28) 49.96,146.11 VRAM2.F4 v2(49.39,145.53) 49.01,145.16 VRAM2.E5 ; v2(41.84,142.54) 41.88,142.54 VRAM2.A14 42.26,142.04 v2(42.54,141.76) ; v2(80.77,144.05) VRAM4.C4 v2(80,143.28) VRAM4.B5 ; v2(27.3,141.81) VRAM1.V1 ; VRAM1.C11 34.14,153.73 v2(34.14,153.77) ; VRAM4.E10 75.81,145.16 v2(75.43,145.53) 75.13,145.84 VRAM4.F11 ; v2(79.25,154.53) VRAM4.U5 v2(80,153.78) VRAM4.T4 ; v2(95.38,124.07) VRAM6.F4 ; VRAM4.E5 79.63,145.16 v2(80,145.53) VRAM4.F4 ; VRAM2.E10 45.26,145.16 v2(44.88,145.54) VRAM2.F11 ; v2(57.2,152.28) VRAM3.E1 ; v2(33.24,154.72) 33.7,154.25 VRAM1.B10 ; v2(67.71,143.28) 67.33,143.66 VRAM3.T14 ; VRAM8.E14 88.65,111.05 v2(88.65,111.1) ; v2(85.61,116.52) 86.02,116.92 VRAM6.V14 ; v2(41.84,143.29) 41.9,143.29 VRAM2.C14 ; VRAM3.P14 67.32,145.16 67.7,144.78 v2(67.73,144.78) ; v2(21.76,131.43) 22.11,131.08 VRAM5.C4 v2(22.53,130.68) ; v2(64.74,144.04) 64.75,144.04 65.07,143.72 VRAM3.T11 ; v2(29.58,153.78) VRAM1.C4 ; v2(30.33,142.53) VRAM1.U5 29.93,142.91 29.58,142.56 v2(29.58,142.53) ; v2(37.08,155.28) VRAM1.A14 ; VRAM3.P10 64.32,145.16 64.36,145.16 64.72,145.52 64.73,145.52 v2(64.74,145.53) 64.76,145.55 64.76,145.56 65.07,145.87 VRAM3.N11 ; VRAM6.P14 88.64,116.55 v2(88.64,116.53) ; VRAM1.U10 33.55,143.06 33.22,143.06 33.17,143.12 33.12,143.12 v2(33.1,143.14) ; VRAM8.C11 87.52,108.38 87.2,108.06 v2(87.19,108.06) 87.14,108.06 VRAM8.B10 v2(86.39,107.31) ; v2(51.64,149.28) VRAM2.L2 ; v2(51.64,149.28) VRAM2.K2 ; v2(51.64,149.28) VRAM2.L1 52.36,150.01 v2(52.41,150.01) ; VRAM6.U10 86.92,120.09 v2(86.92,120.53) ; v2(52.39,152.28) VRAM2.P1 ; v2(80,150.78) VRAM4.N4 v2(80,151.53) VRAM4.P5 ; VRAM8.E5 v2(89.39,103.56) 89.48,103.47 89.77,103.18 ; v2(72.46,142.54) 72.49,142.54 VRAM4.A14 73.21,141.83 v2(73.21,141.79) ; v2(97.64,100.56) VRAM8.T1 ; VRAM1.T4 29.53,143.99 v2(29.58,143.99) ; v2(19.54,131.42) VRAM5.F4 ; v2(87.15,111.1) 87.15,111.05 VRAM8.C14 ; v2(72.46,143.29) 72.51,143.29 72.88,143.66 VRAM4.C14 ; v2(87.14,100.56) VRAM8.C1 ; VRAM3.P5 60.57,145.16 v2(60.2,145.53) VRAM3.N4 ; VRAM8.A14 85.79,110.68 v2(85.57,110.46) ; v2(90.14,102.81) 89.77,103.18 ; 89.77,103.18 VRAM8.F4 ; v2(88.64,127.06) VRAM6.P1 ; v2(57.95,147.78) VRAM3.L2 ; v2(57.95,147.78) VRAM3.L1 57.48,147.41 57.22,147.67 v2(57.05,147.67) ; v2(50.14,144.03) VRAM2.C4 v2(49.39,143.28) VRAM2.B5 ; v2(26.58,143.28) VRAM1.T1 ; v2(23.2,108.65) 23.25,108.65 VRAM7.V1 ; v2(60.95,142.53) VRAM3.U5 v2(60.2,142.53) ; v2(37.08,152.28) VRAM1.E14 ; v2(57.2,155.28) VRAM3.A1 ; v2(30.38,154.58) VRAM1.B5 ; VRAM8.H13 v2(90.89,110.31) VRAM8.H14 ; VRAM6.T14 87.52,116.92 v2(87.14,116.55) ; VRAM4.C11 75.16,143.66 75.48,143.34 v2(75.48,143.33) 75.5,143.3 75.5,143.26 75.86,142.91 VRAM4.B10 ; VRAM1.V14 36.7,142.16 36.71,142.16 v2(37.12,141.75) ; v2(52.39,155.28) VRAM2.V1 ; v2(87.91,119.52) 87.57,119.18 VRAM6.T11 ; VRAM8.N11 v2(95.39,108.06) VRAM8.P10 ; VRAM1.N11 v2(34.09,145.55) 33.7,145.16 VRAM1.P10 ; v2(87.14,127.06) VRAM6.T1 ; v2(67.74,141.75) 67.33,142.16 67.32,142.16 VRAM3.V14 ; VRAM3.T4 v2(60.2,144.03) ; v2(63.78,143.06) 64.17,143.06 VRAM3.U10 ; v2(88.64,107.3) VRAM8.E10 v2(89.39,108.06) VRAM8.F11 ; v2(37.11,144.78) 37.08,144.78 36.7,145.16 VRAM1.P14 ; VRAM6.T4 v2(87.89,124.06) ; VRAM2.C1 52.39,143.28 v2(52.42,143.28) ; v2(52.42,141.78) 52.39,141.78 52.01,142.16 VRAM2.A1 ; v2(52.39,153.78) VRAM2.T1 ; v2(23.26,126.95) VRAM5.B10 22.88,126.51 22.57,126.2 v2(22.52,126.2) ; v2(85.64,100.56) VRAM8.A1 ; v2(83,143.28) VRAM4.C1
  TOP w0.305: VRAM5.E14 20.63,123.53 20.97,123.19 v2(20.97,123.17) ; VRAM5.E5 20.25,130.72 v2(20.25,130.76) ; VRAM1.B10 33.71,154.16 34.09,153.77 v2(34.14,153.77) ; VRAM5.A14 23.69,123.58 v2(24.02,123.91) ; v2(21.76,111.67) 21.76,111.66 22.13,111.29 VRAM7.T4 ; v2(23.23,112.41) 23.23,112.38 VRAM7.U5 23.22,111.69 23.26,111.69 v2(23.29,111.66) ; v2(18.11,108.59) 18.38,108.87 VRAM7.L1 ; v2(22.53,130.68) VRAM5.B5 ; v2(13.51,119.16) VRAM7.E14 ; VRAM2.L2 v2(50.89,149.28) VRAM2.K2 ; VRAM5.F11 v2(20.26,126.2) VRAM5.E10 20.66,126.58 v2(21.01,126.93) ; VRAM8.J13 92.02,109.93 v2(92.39,110.31) ; VRAM7.V14 23.32,119.09 23.32,119.09 v2(23.25,119.16) ; VRAM7.T1 22.13,109.03 v2(21.76,108.66) ; VRAM5.C1 22.13,133.34 v2(21.77,133.71) ; VRAM7.L2 18.34,109.78 v2(17.99,109.43) ; VRAM7.T14 21.78,119.14 v2(21.78,119.16) ; VRAM5.C11 22.15,125.83 v2(22.52,126.2) ; VRAM5.H14 v2(18.76,123.95) 18.38,124.33 VRAM5.H13 ; v2(72.39,145.49) 72.54,145.49 VRAM4.E14 ; VRAM7.B5 11.63,112.01 v2(12,111.64) 12.36,111.28 VRAM7.C4 ; VRAM7.P10 20.26,116.16 v2(20.26,116.19) 19.92,116.53 VRAM7.N11 ; v2(22.5,123.15) 22.5,123.16 22.13,123.52 VRAM5.C14 ; v2(21.79,116.88) VRAM7.T11 ; VRAM8.L2 93.52,101.68 ; VRAM7.N4 19.88,111.29 20.21,111.61 v2(20.21,111.67) 20.27,111.67 VRAM7.P5 ; v2(20.26,108.66) VRAM7.P1 ; VRAM5.A1 23.28,133.68 v2(23.28,133.7) ; VRAM7.U10 22.75,115.65 v2(22.75,115.21) ; VRAM1.B5 v2(29.58,153.78) ; v2(20.27,133.69) VRAM5.E1
  TOP w0.381: v1(88.66,133.39) 88.66,132.75 89.05,132.37 RG5.1 ; RG1.1 v1(87.41,134.1)
  IN2 w0.508: v1(18.31,163.46) 18.95,163.46 21.02,161.38 21.02,156.3 20.42,155.7 v3(20.42,154.13)
  BOTTOM w0.508: PR444.1 12.12,165.02 12.72,165.62 16.93,165.62 17.57,164.99 17.57,164.2 v1(18.31,163.46)
  vias: v1(8.48,115.76) v1(41.67,162.44) v1(70.33,139.16) v1(92.91,134.1) v1(99.56,114.63) v2(8.4,114.09) v2(9.46,112.59) v2(9.62,129.82) v2(10.23,134.22) v2(10.36,123.2) v2(10.45,108.81) v2(10.51,133.7) v2(10.51,119.16) v2(10.97,115.26) v2(11.07,129.88) v2(11.64,128.2) v2(11.63,127.41) v2(11.98,123.21) v2(11.99,108.68) v2(12.01,133.7) v2(12.03,130.72) v2(12.01,126.2) v2(12.01,119.16) v2(12.01,116.16) v2(13.49,108.68) v2(13.51,133.7) v2(13.51,129.85) v2(13.51,123.18) v2(13.51,115.41) v2(13.54,112.67) v2(14.26,130.7) v2(14.26,126.2) v2(14.28,116.89) v2(14.25,111.61) v2(14.39,120.47) v2(14.31,116.17) v2(15.01,130.7) v2(15.03,116.88) v2(15.59,120.39) v2(15.53,114.72) v2(15.78,133.73) v2(15.76,123.2) v2(15.78,118.38) v2(15.74,108.68) v2(15.8,119.18) v2(16.47,132.95) v2(16.47,132.19) v2(16.49,124.72) v2(16.48,118.39) v2(16.49,109.43) v2(16.51,123.95) v2(16.52,117.64) v2(16.51,110.18) v2(17.26,132.97) v2(17.23,131.46) v2(17.28,118.38) v2(17.26,116.9) v2(17.24,110.93) v2(17.24,109.43) v2(17.3,120.26) v2(17.67,127.7) v2(17.96,115.37) v2(18.07,133.76) v2(18.01,133.02) v2(18,132.21) v2(18.03,118.38) v2(18.06,117.64) v2(18.03,110.16) v2(18.78,119.17) v2(18.77,117.64) v2(19.11,134.88) v2(19.63,127.38) v2(26.49,147.66) v2(26.58,155.28) v2(26.58,152.28) v2(26.58,150.03) v2(27.34,149.27) v2(27.33,148.53) v2(27.33,147.78) v2(28.08,149.28) v2(28.08,147.77) v2(28.83,148.53) v2(29.56,151.49) v2(30.65,152.29) v2(31.67,156.07) v2(31.73,148.89) v2(32.01,151.73) v2(32.66,152.92) v2(32.64,150.26) v2(32.96,152.42) v2(33.33,147.78) v2(34.05,151.52) v2(34.83,148.54) v2(35.57,149.29) v2(35.57,147.79) v2(35.57,147.07) v2(36.33,150.03) v2(36.33,149.29) v2(36.33,148.53) v2(36.33,147.78) v2(37.08,150.03) v2(37.08,146.29) v2(37.8,129.83) v2(38.01,127.06) v2(38.69,127.76) v2(38.67,123.61) v2(39.15,156.27) v2(39.39,117.31) v2(39.68,151.94) v2(40.15,151.19) v2(40.11,123.63) v2(40.1,115.15) v2(41.88,155.44) v2(41.89,153.81) v2(41.89,150.03) v2(42.15,129.2) v2(42.23,128.5) v2(42.25,127.1) v2(42.21,119.4) v2(42.67,156.66) v2(42.64,149.28) v2(42.64,148.53) v2(42.61,147.06) v2(43.4,149.3) v2(43.61,117.26) v2(43.61,108.91) v2(43.72,121.09) v2(43.73,120.29) v2(43.86,112.28) v2(44.27,122.83) v2(44.24,118.56) v2(44.24,118.05) v2(44.28,117.32) v2(44.2,116.11) v2(44.27,115.21) v2(44.27,110.32) v2(44.25,109.78) v2(44.33,113.17) v2(44.41,114) v2(44.89,153.78) v2(44.89,151.53) v2(44.86,122.13) v2(45.3,121.8) v2(45.71,122.19) v2(46.03,154.03) v2(46.43,148.19) v2(47.21,121.89) v2(47.34,121.37) v2(47.5,151.27) v2(48.05,149.25) v2(48.53,152.03) v2(48.55,122.2) v2(48.64,154.53) v2(49.21,122.15) v2(49.39,153.78) v2(49.39,151.53) v2(49.39,146.28) v2(49.9,122.19) v2(50.14,148.53) v2(50.57,124.31) v2(50.89,147.79) v2(51.33,122.13) v2(51.64,148.53) v2(52.35,121.39) v2(53.28,121.42) v2(53.72,121.88) v2(54.13,122.2) v2(56.28,156.03) v2(56.61,156.56) v2(56.85,123.6) v2(56.92,124.99) v2(56.9,122.23) v2(58.24,122.18) v2(58.7,149.28) v2(58.7,147.81) v2(58.95,125.7) v2(59.45,148.53) v2(59.51,156.27) v2(59.67,121.51) v2(61.79,152.05) v2(62.01,122.08) v2(63.17,125.68) v2(63.81,154.77) v2(63.9,151.47) v2(63.92,147.84) v2(64.53,122.13) v2(64.55,121.52) v2(64.7,153.78) v2(64.7,151.53) v2(65.15,113.03) v2(65.2,120.3) v2(65.29,107.51) v2(65.29,106.8) v2(65.3,115.2) v2(65.38,114.21) v2(65.34,108.9) v2(65.45,148.53) v2(65.47,120.75) v2(65.41,109.71) v2(65.61,116.17) v2(65.64,105.78) v2(65.89,114.2) v2(65.89,112.02) v2(65.99,113.15) v2(65.99,110.35) v2(66.01,117.33) v2(66.01,116.6) v2(66.04,115.18) v2(66.03,106.12) v2(66,104.03) v2(66.18,147.78) v2(66.21,149.25) v2(66.25,122.16) v2(66.27,121.64) v2(66.95,150.06) v2(66.94,149.28) v2(66.95,148.53) v2(66.95,147.78) v2(67.72,150.05) v2(67.8,152.39) v2(68.09,115.22) v2(68.09,106.78) v2(68.11,119.39) v2(69.03,149.53) v2(69.46,119.4) v2(69.53,115.2) v2(69.55,106.8) v2(69.5,102.55) v2(71.55,117.31) v2(72.48,152.28) v2(72.53,155.6) v2(72.51,153.81) v2(72.5,150.03) v2(73.25,149.28) v2(73.25,148.53) v2(73.25,147.03) v2(74.02,149.3) v2(74.42,105.12) v2(75.5,153.78) v2(75.5,151.53) v2(76.21,152.28) v2(76.72,153.96) v2(78.11,155.42) v2(78.98,156.28) v2(80.75,148.53) v2(81.48,147.78) v2(81.5,149.28) v2(82.2,149.3) v2(82.25,147.78) v2(83,153.78) v2(83.01,147.78) v2(83.11,150.07) v2(83.53,101.45) v2(83.71,149.87) v2(85.74,127.09) v2(89.19,114.99) v2(90.16,128.32) v2(90.1,106.89) v2(90.89,116.55) v2(91.52,127.15) v2(91.64,126.31) v2(91.64,120.31) v2(91.64,117.31) v2(91.65,102.09) v2(91.64,101.31) v2(91.64,100.56) v2(92.03,106.54) v2(92.39,126.31) v2(92.39,124.81) v2(92.39,118.81) v2(92.39,117.31) v2(92.38,108.83) v2(92.39,102.81) v2(92.39,101.3) v2(93.14,126.3) v2(93.14,125.56) v2(93.12,118.06) v2(93.15,117.36) v2(93.14,110.31) v2(93.16,109.55) v2(93.14,102.06) v2(93.14,101.31) v2(93.57,128.36) v2(93.89,127.06) v2(93.89,116.56) v2(93.89,111.06) v2(93.9,117.31) v2(93.92,100.42) v2(94.12,120.99) v2(94.84,133.82) v2(95.2,128.75) v2(95.39,127.06) v2(95.36,119.52) v2(95.39,103.56) v2(95.45,133.82) v2(95.53,123.02) v2(95.77,104.6) v2(96.01,133.85) v2(96.14,127.06) v2(96.11,122.91) v2(96.14,116.56) v2(96.14,111.09) v2(96.14,100.56) v2(97.66,127.06) v2(97.64,119.55) v2(97.67,111.05) v2(97.64,108.06) v2(97.64,103.56) v2(98,106.62) v2(98.39,104.31) v2(98.41,120.32) v2(99.18,127.96) v2(99.14,116.56) v2(99.14,100.56) v2(99.23,127.29) v2(99.3,111.07) v2(99.54,115.57) v2(99.96,123.09) v2(100.12,115.61) v2(100.27,127.47) v2(100.27,126.91) v2(100.26,123.8) v2(100.22,108.5) v3(14.45,151.32) v3(14.45,150.44) v3(14.45,149.55) v3(14.45,148.66) v3(14.45,147.77) v3(15.11,151.76) v3(15.11,150.87) v3(16.02,153.58) v3(16.02,152.82) v3(16.02,152.06) v3(16.02,151.3) v3(16.02,150.54) v3(16.02,149.77) v3(16.02,149.01) v3(16.02,148.25) v3(16.02,147.49) v3(16.97,153.78) v3(16.99,153.03) v3(16.91,147.74) v3(20.41,153.25) v3(21.02,147.03) v3(33.67,165.52) v3(33.65,164.58) v3(34.44,166.29) v3(34.44,165.53) v3(34.44,164.77) v3(34.44,164.01) v3(35.2,166.29) v3(35.2,165.53) v3(35.2,164.77) v3(35.2,164.01) v3(35.96,166.29) v3(35.96,165.53) v3(35.96,164.77) v3(35.96,164.01) v3(36.85,166.29) v3(36.85,165.53) v3(36.85,164.77) v3(36.85,164.01) v3(37.61,166.29) v3(37.61,165.53) v3(37.61,164.77) v3(37.61,164.01) v3(41.41,167.33) v3(41.41,166.57) v3(41.41,165.8) v3(41.41,165.04) v3(41.41,164.28) v3(42.17,167.33) v3(42.17,166.57) v3(42.17,165.8) v3(42.17,165.04) v3(42.17,164.28)
FBVDDQ_SENSE: length 106.9
  TOP w0.254: UG1.E52 73.34,126.74 74.9,126.74 82.51,134.34 v1(84.98,134.34)
  IN2 w0.254: v1(26.23,159.33) 28.1,157.46 30.72,157.46 31.04,157.78 35.5,157.78 36.41,158.69 38.54,158.69 38.92,159.08 42.01,159.08 42.41,158.68 44.31,158.68 45.63,157.36 48.36,157.36 49.41,158.41 55.11,158.41 55.25,158.55 58.67,158.55 58.8,158.67 60.49,158.67 60.81,158.36 61.58,158.36 62.11,157.83 64.21,157.83 64.8,157.24 68.5,157.24 70.21,158.95 71.59,158.95 72.32,159.68 73.66,159.68 74.4,158.95 77.02,158.95 77.74,158.23 79.68,158.23 80.41,157.5 84.1,157.5 86.39,155.21 86.39,151.12 85.58,150.3 85.58,149.59 86.33,148.84 86.33,135.69 v1(84.98,134.34)
  BOTTOM w0.254: PR459.2 28.06,157.78 27.69,158.15 27.69,158.54 v1(27.52,158.71) 27.25,158.98 26.58,158.98 v1(26.23,159.33)
FLIP_DP: length 6.9
  TOP w0.14: v1(88.6,150.82) 88.6,150.81 90.17,149.25 90.17,148.37 R24.2 89.05,147.25 v1(89.05,146.79)
  BOTTOM w0.14: U39.21 88.84,151.3 88.6,151.06 v1(88.6,150.82) ; R672.2 v1(89.05,146.79)
FLIP_EDP: length 7.5
  BOTTOM w0.14: U41.21 173.92,90.84 172.43,89.36 172.43,88.84 R715.2 172.02,87.81 v1(171.28,87.07) 170.41,87.07 170.07,87.41 170.07,88.21 R716.2
FLIP_TBT_CLK: length 4.8
  TOP w0.14: R208.2 239.79,43.86 241.05,43.86 241.19,44 v1(241.19,44.03) 241.24,43.98 241.68,43.98 241.82,44.12 U10.21
  BOTTOM w0.14: R823.2 240.94,43.77 v1(241.19,44.03)
FP_FUSE_GPU: length 29.9
  TOP w0.254: UG1.BD14 46.05,98.75 45.72,99.08 v2(45.69,99.08)
  IN4 w0.254: v2(45.69,99.08) 45.69,99.03 44.79,98.14 43.83,98.14 43.22,98.74 43.22,100.27 41.88,101.62 41.88,102.07 41.57,102.38 36.95,102.38 34.77,104.56 v1(34.77,104.94)
  BOTTOM w0.254: v1(34.77,104.94) 32.68,107.03 30.52,107.03 29.59,106.09 27.68,106.09 27.25,105.66 25.49,105.66 25.37,105.77 CG713.2 23.61,105.77 RG124.1 23.24,105.78 UG4.8
FRM_LCK#: length 194.4
  TOP w0.102: UG1.BG2 37.51,96.65 37.19,96.97 35.23,96.97 v1(34.82,96.56)
  TOP w0.14: v1(176.89,107.77) 177.25,107.77 Q14.3 ; v1(96.56,83.83) 97.55,83.83 100.28,86.56 105.42,86.56 105.56,86.42 165.65,86.42 167.32,84.75 171.56,84.75 v1(173.47,82.84) ; RG27.2 33.07,96.18 33.68,96.18 34.06,96.56 v1(34.82,96.56)
  IN2 w0.089: v1(42.25,89.41) 42.56,89.41 44.32,87.65 47.98,87.65 49.85,85.77 49.85,85.4 50.93,84.32 54.75,84.32 56.4,82.67 60.84,82.67 61.62,81.89 82.62,81.89 88,87.27 93.78,87.27 96.56,84.49 v1(96.56,83.83)
  IN3 w0.089: v1(176.89,107.77) 176.33,107.21 176.33,96.45 176.9,95.87 176.9,91.2 176.42,90.72 176.42,88.25 175.84,87.67 175.84,86.87 175.75,86.78 175.75,86.45 173.47,84.18 v1(173.47,82.84)
  IN4 w0.086: v1(42.25,89.41) 42.47,89.63 42.47,90.8 41.93,91.33 41.93,92.93 42.1,93.1 42.1,97.81 41.81,98.09 41.38,98.09 41.37,98.09 41.16,98.09 40.46,98.8 40.46,100.06 40.32,100.2 39.22,100.2 39.02,100 39.02,99.54 38.3,98.82 37.07,98.82 v1(34.82,96.56)
FRM_LCK#_PANEL: length 16
  TOP w0.14: v1(178.96,109.82) 178.96,109.16 179.1,109.02 Q14.1
  IN2 w0.089: v1(178.96,109.82) 179.08,109.94 179.08,111.93 177.13,113.88 177.13,119.68 176.52,120.29 176.52,121.64 v1(176.41,121.75)
  BOTTOM w0.14: CN10.20 v1(176.41,121.75)
FRONT_L_SPK: length 14.6
  TOP w0.203: U17.23 26.87,29.16 26.81,29.1 25.88,29.1 v1(25.82,29.04)
  TOP w0.381: C381.2 v1(35.55,25.31)
  BOTTOM w0.381: v1(25.82,29.04) 25.92,28.95 26.73,28.95 27.11,28.57 27.11,26.8 27.94,25.97 v1(28.3,25.97) 33.3,25.97 34,25.27 35.4,25.27 35.45,25.31 v1(35.55,25.31)
FRONT_R_SPK: length 13.8
  TOP w0.203: U17.22 26.79,29.56 26.7,29.46 26.41,29.46 v1(26.28,29.59)
  TOP w0.381: C361.2 35.82,26.08 v1(35.45,26.08)
  BOTTOM w0.381: v1(35.45,26.08) 35.35,25.97 34.29,25.97 33.66,26.6 28.3,26.6 27.75,27.16 v1(27.75,27.39) 27.75,28.83 26.99,29.59 v1(26.28,29.59)
FVDDQ_SENSE_I: length 28.6
  TOP w0.127: v1(41.94,29.06) 42.13,29.25 42.13,29.44 41.82,29.75 PR359.1 ; PR294.2 30.06,47.44 30.24,47.26 30.24,47.08 30.42,46.91 30.42,46.73 v1(30.27,46.57)
  BOTTOM w0.127: v1(30.27,46.57) 30.43,46.41 30.43,46.23 29.27,45.07 29.27,43.66 30.84,42.09 32.01,42.09 35.2,38.91 35.2,36.79 36.4,35.59 36.4,34.27 37.13,33.54 37.13,31.74 37.71,31.16 38.1,31.16 38.66,30.6 41.7,30.6 42.21,30.09 42.21,29.33 v1(41.94,29.06)
FVDDQ_SENSE_V: length 29.6
  TOP w0.127: v1(30.93,46.6) 30.68,46.86 30.68,47.01 30.5,47.19 30.5,47.31 PR295.2 ; PR357.1 43.36,30.3 PR360.2 42.67,29.75 42.38,29.46 42.38,29.23 42.54,29.08 v1(42.59,29.08)
  BOTTOM w0.127: v1(30.93,46.6) 30.73,46.39 30.73,46.17 29.52,44.96 29.52,43.77 30.94,42.34 32.12,42.34 35.45,39.01 35.45,36.9 36.66,35.69 36.66,34.37 37.38,33.65 37.38,31.84 37.82,31.41 38.21,31.41 38.77,30.85 41.81,30.85 42.46,30.2 42.46,29.34 42.59,29.21 v1(42.59,29.08)
G1_FRONT: length 5.5
  TOP w0.14: v1(41.39,24.38) 41.39,25.06 41.61,25.28 U20.11
  BOTTOM w0.14: v1(41.39,24.38) 41.49,24.47 v1(41.49,25.24) 41.27,25.24 40.64,25.86 R953.1 42.26,25.95 R952.2
G1_REAR: length 5.4
  TOP w0.14: U22.11 15.36,24.47 15.82,24.92 15.82,25.21 v1(15.83,25.23)
  BOTTOM w0.14: R999.2 14.89,22.83 v1(15.79,23.73) 16.39,24.33 R971.1 16.39,25.09 16.25,25.23 v1(15.83,25.23)
G1_SUB: length 5.7
  TOP w0.14: v1(21.43,22.01) 21.24,22.01 R443.1 21.44,21.03 22.48,21.03 22.67,20.83 U25.11
  BOTTOM w0.14: R1039.2 22.32,21.12 v1(21.43,22.01)
G2_FRONT: length 4
  TOP w0.14: U20.12 42.23,24.27 v1(42.28,24.23)
  BOTTOM w0.14: R968.2 42.42,24.36 v1(42.28,24.23) 41.91,23.86 41.2,23.86 40.64,24.42 R969.1
G2_REAR: length 4.4
  TOP w0.14: U22.12 15.22,24.92 15.35,25.06 15.35,25.25 v1(15.15,25.46)
  BOTTOM w0.14: R982.2 14.51,24.35 v1(14.91,24.75) 15.15,24.99 v1(15.15,25.46) 15.3,25.46 15.53,25.69 16.13,25.69 R954.1
G2_SUB: length 6.7
  TOP w0.14: v1(19.14,21.94) 19.46,21.62 R442.1 20.51,20.95 21.08,20.95 21.71,20.31 U25.12
  BOTTOM w0.14: v1(19.14,21.94) 19.46,21.94 R1038.2
GC6_1V8_MAIN_EN: length 35.3
  TOP w0.102: UG1.BE1 35.49,98.05 v1(35.32,98.21) 33.43,98.21 RG21.2
  IN4 w0.086: v1(35.32,98.21) 34.42,97.31 34.42,94.57 33.85,94 33.85,93.22 34.29,92.78 34.29,91.22 35.37,90.14 35.37,86.73 35.16,86.52 35.16,84.98 36.54,83.61 37.38,83.61 37.87,83.12 v1(37.87,82.42)
  BOTTOM w0.14: UG8.2 35.35,81.86 35.58,82.08 36.34,82.08 37.4,83.14 37.6,83.14 37.87,82.87 v1(37.87,82.42) 38.19,82.1 38.72,82.1 39.03,82.41 39.03,83.5 RG179.1 39.5,83.54 39.98,83.07 39.98,82.67 39.67,82.36 39.67,81.31 39.96,81.01 40.68,81.01 40.88,81.21 UG6.2
GC6FBEN: length 61.5
  TOP w0.102: UG1.BB5 39.78,100.15 v2(40.11,99.82)
  TOP w0.14: v1(31.46,80.13) 31.14,80.45 RG68.1
  IN1 w0.086: v1(31.46,80.13) 33.84,80.13 34.75,81.04 37.43,81.04 37.59,80.89 40.29,80.89 41.05,81.65 43.4,81.65 43.79,81.26 43.79,80.67 43.49,80.37 42.42,80.37 41.78,79.73 v1(41.78,78.58) 42.28,79.09 44.29,79.09 44.77,79.57 46.02,79.57 47.42,80.97 v1(47.42,81.15)
  IN4 w0.086: v1(47.42,81.15) 45.97,82.6 44.67,82.6 43.33,83.93 42.6,83.93 41.62,84.91 41.62,88.46 39.25,90.83 39.25,91.8 40.63,93.18 40.63,95.93 40.18,96.38 40.18,97.03 39.78,97.42 39.78,98.1 39.74,98.14 39.74,99.46 v2(40.11,99.82)
  BOTTOM w0.14: v1(41.78,78.58) 42.02,78.82 UG9.1 40.9,79.17 v1(40.86,79.21) 40.6,79.48 40.6,79.61 40.24,79.97 UG11.1 ; v1(31.46,80.13) 30.87,80.72 QG22.2 30.72,81.04 30.72,81.85 30.78,81.91 30.78,83.48 31.29,83.99 RG178.2 ; v1(47.42,81.15) 47.42,80.94 47.14,80.66 47.14,80.13 47.54,79.72 47.54,79.7 47.72,79.52 QG23.2
GC6FBEN_Q: length 285
  IN2 w0.089: v1(28.14,48.15) 28.14,51.48 25.87,53.75 25.87,54.16 25.48,54.56 23.29,54.56 22.79,55.05 21.95,55.05 21.83,55.18 21.69,55.18 19.97,56.91 19.97,57.95 18.63,59.29 17.72,59.29 16.9,60.1 16.9,60.12 16.75,60.27 16.75,60.76 15.74,61.77 15.74,70.99 15.48,71.24 15.48,77.35 15.81,77.68 22.99,77.68 23.91,78.6 24.35,78.6 24.71,78.25 27.22,78.25 v1(27.71,77.76)
  IN3 w0.089: v1(28.14,48.15) 28.35,47.94 28.35,47.81 28.85,47.31 28.85,46.36 30.97,44.24 31.12,44.24 31.9,43.46 31.9,43.3 36.44,38.76 37.97,38.76 38.59,38.15 41.78,38.15 41.9,38.27 44.02,38.27 45.01,37.28 45.3,37.28 45.37,37.35 45.78,37.35 46.25,37.82 47.18,37.82 47.85,37.15 47.85,35.73 48.25,35.33 49.15,35.33 49.93,34.54 53.21,34.54 54.8,32.95 54.8,32.28 56.9,30.18 59.05,30.18 59.38,30.51 61.52,30.51 62.04,29.99 63.09,29.99 63.81,30.71 65.35,30.71 65.47,30.59 66.72,30.59 66.83,30.69 67.5,30.69 67.95,31.14 68.92,31.14 69.3,30.76 69.3,29.38 70.41,28.27 70.41,25.75 70.99,25.18 72.16,25.18 72.84,24.49 72.84,23.75 73.07,23.52 73.07,22.23 73.43,21.86 74.72,21.86 74.81,21.78 76.19,21.78 77.42,20.54 78.99,20.54 79.95,21.5 79.95,22.27 80.31,22.62 81.81,22.62 82.41,22.02 82.73,22.02 83.1,21.65 83.1,21.19 83.43,20.87 83.43,20.55 84.74,19.24 88.57,19.24 88.95,19.62 91.28,19.62 91.92,20.26 93.96,20.26 95.56,18.66 97,18.66 97.61,18.05 99.14,18.05 100.6,19.52 100.6,20.59 104.48,24.47 111.16,24.47 111.67,23.97 114.84,23.97 116.35,22.46 116.35,21.85 118.27,19.93 131.33,19.93 133.84,22.44 143.93,22.44 144.29,22.8 148.95,22.8 151.55,20.2 158.96,20.2 160.2,18.96 165.28,18.96 165.95,19.64 171.31,19.64 171.51,19.83 174.98,19.83 175.95,18.86 177.34,18.86 178.25,19.77 183.52,19.77 184,19.29 185.31,19.29 190.06,14.54 190.26,14.54 191.19,13.61 195.55,13.61 196.12,13.04 197.82,13.04 199.27,11.59 206.06,11.59 206.33,11.87 207.71,11.87 208.19,12.34 209.97,12.34 210.22,12.6 218.16,12.6 218.36,12.79 v1(218.36,13.1)
  BOTTOM w0.14: QG24.3 28.31,78.36 v1(27.71,77.76) ; v1(218.36,13.1) 218.36,13.18 R1163.2 219,13.66 219.35,14.01 219.35,14.88 219.53,15.05 220.64,15.05 220.65,15.06 220.66,15.06 220.78,15.18 220.78,15.19 220.92,15.33 R1164.1 220.92,15.62 220.49,16.04 220.25,16.04 220.11,16.18 R1094.1
GC6FBEN_Q_EC: length 104.7
  TOP w0.14: R297.2 68.01,35.13 68.01,36.4 67.86,36.55 67.86,37.8 68.87,38.81 v1(68.87,39.03) 68.87,39.16 68.88,39.17 68.88,40.14 R1165.1 68.92,40.82 v1(69,40.9)
  IN2 w0.089: v1(69,40.9) 68.81,41.1 66.15,41.1 62.05,45.2 59.66,45.2 58.14,46.72 58.14,50.24 56.49,51.9 55.3,51.9 53.42,50.02 49.54,50.02 49.25,49.73 48.39,49.73 48.19,49.94 47.13,49.94 46.76,49.57 46.76,48.38 46.38,48.01 46.38,47.29 46.1,47.01 45.51,47.01 45.09,47.43 45.09,50.05 44.74,50.4 37.34,50.4 36.32,51.43 34.64,51.43 33.02,53.05 31.52,53.05 30.27,54.3 26.63,54.3 26.56,54.36 25.94,54.36 25.56,54.75 23.37,54.75 22.87,55.24 22.03,55.24 21.91,55.37 21.77,55.37 20.16,56.99 20.16,58.03 18.71,59.48 17.8,59.48 17.09,60.18 17.09,60.2 16.94,60.35 16.94,60.84 15.93,61.85 15.93,71.08 15.67,71.33 15.67,77.27 15.89,77.49 23.44,77.49 v1(24,78.05)
  BOTTOM w0.14: QG25.3 24.31,78.36 v1(24,78.05)
GFX_SCL: length 44.9
  TOP w0.102: UG1.BJ8 41.47,94.87 v2(41.45,94.87)
  IN2 w0.089: v1(10.67,102.91) 10.82,103.07 11.79,103.07 15.37,99.48 15.44,99.48 16.43,98.5 20.67,98.5 21.38,97.79 21.97,97.79 23.84,95.92 25.19,95.92 26.6,94.51 27.52,94.51 30.04,91.99 31.39,91.99 32.33,92.93 33.9,92.93 35.76,91.07 37.4,91.07 38.23,91.9 38.47,91.9 39.28,92.7 39.8,92.7 40.99,93.89 41.24,93.89 41.52,94.17 41.52,94.8 v2(41.45,94.87)
  BOTTOM w0.14: v1(10.67,102.91) 10.03,103.56 v1(10.03,103.76) RG128.2 9,105.86 7.77,105.86 7.63,106 QG18.4
GFX_SDA: length 44
  TOP w0.102: v2(41.5,95.56) 41.62,95.68 41.81,95.87 41.81,95.91 UG1.BH8
  IN2 w0.089: v2(41.5,95.56) 41.8,95.26 41.8,94.06 40,92.26 39.46,92.26 38.66,91.45 38.41,91.45 37.58,90.62 35.43,90.62 35.19,90.87 30.54,90.87 27.34,94.07 26.42,94.07 25.01,95.47 23.66,95.47 21.79,97.35 21.2,97.35 20.98,97.56 20.49,98.05 16.24,98.05 15.25,99.04 15.19,99.04 11.83,102.4 v1(11.16,102.4)
  BOTTOM w0.14: QG18.1 8.93,103.54 RG135.2 10.9,102.14 v1(11.16,102.4)
GLS_LED_CTL_B: length 10.8
  TOP w0.14: Q20.2 8.42,64.63 8.42,66.84 v1(8.07,67.19) 7.84,67.42 7.84,68.16 6.95,69.05 6.95,71.39 7.22,71.65 R117.2 7.46,72.86 7.68,73.08 U4.31
GLS_LED_CTL_G: length 16.9
  TOP w0.14: Q21.2 8.15,61.12 8.01,61.26 6.51,61.26 6.37,61.4 6.37,63.36 7.31,64.3 7.31,64.66 v1(7.93,65.28) 8.02,65.37 8.02,66.59 7.56,67.05 7.56,67.61 R121.2 6.6,68.58 6.6,72.61 7.47,73.48 U4.30
GLS_LED_CTL_R: length 23.5
  TOP w0.14: v1(6.8,73.84) 7.1,73.84 7.4,74.14 7.4,74.44 7.64,74.68 U4.27 ; v1(6.79,57.61) 7.32,57.61 8.15,58.44 Q21.5 ; v1(6.8,64.53) 6.8,64.61 6.83,64.63 6.83,65.11 R124.2
  IN1 w0.086: v1(6.79,57.61) 7.06,57.61 7.48,58.03 7.48,61.3 8.38,62.2 8.38,63.73 7.58,64.53 v1(6.8,64.53) 6.78,64.56 6.7,64.56 6.58,64.68 6.58,73.62 v1(6.8,73.84)
GLS_LED_EN_B: length 124.3
  TOP w0.508: Q20.3 9.91,62.59 D16.1 11.15,62.02 v1(11.78,62.02)
  IN4 w0.508: v1(11.78,62.02) 12.59,62.83 12.59,71.85 12.69,71.95 12.69,74.46 arc(12.68,74.53) 12.64,74.59 12.5,74.73 arc(12.45,74.8) 12.44,74.87 12.44,75.63 arc(12.42,75.7) 12.38,75.76 11.84,76.31 arc(11.79,76.37) 11.78,76.45 11.78,77.84 arc(11.79,77.91) 11.84,77.98 11.98,78.12 arc(12.02,78.18) 12.03,78.25 12.03,84.95 arc(12.05,85.02) 12.09,85.09 14.03,87.03 arc(14.1,87.07) 14.17,87.09 14.93,87.09 arc(15,87.1) 15.06,87.14 16.27,88.35 arc(16.31,88.41) 16.33,88.49 16.33,89.04 arc(16.34,89.11) 16.38,89.17 17.66,90.46 arc(17.71,90.52) 17.72,90.59 17.72,91.44 arc(17.71,91.52) 17.66,91.58 17.55,91.7 arc(17.51,91.76) 17.49,91.83 17.49,92.85 arc(17.51,92.92) 17.55,92.99 18.13,93.56 arc(18.17,93.63) 18.18,93.7 18.18,96.39 arc(18.17,96.46) 18.13,96.53 15.44,99.21 arc(15.4,99.28) 15.39,99.35 15.39,102.65 arc(15.37,102.73) 15.33,102.79 14.15,103.97 arc(14.08,104.01) 14.01,104.03 13.71,104.03 arc(13.64,104.04) 13.58,104.09 12.37,105.29 arc(12.33,105.36) 12.31,105.43 12.31,105.68 arc(12.3,105.75) 12.26,105.82 11.58,106.49 arc(11.52,106.53) 11.44,106.55 10.82,106.55 arc(10.74,106.56) 10.68,106.6 9.15,108.13 arc(9.11,108.19) 9.1,108.26 9.1,109.2 arc(9.08,109.27) 9.04,109.33 7.52,110.86 arc(7.48,110.92) 7.46,110.99 7.46,136.56 arc(7.48,136.64) 7.52,136.7 8.32,137.5 arc(8.38,137.54) 8.46,137.56 10.64,137.56 arc(10.71,137.57) 10.77,137.61 11.17,138.01 arc(11.21,138.07) 11.23,138.15 11.23,139.03 arc(11.24,139.11) 11.28,139.17 11.97,139.86 arc(12.02,139.93) 12.03,140 12.03,142.94 arc(12.05,143.01) 12.09,143.08 14.52,145.5 arc(14.58,145.55) 14.65,145.56 17.31,145.56 arc(17.38,145.58) 17.44,145.62 19.37,147.54 arc(19.41,147.6) 19.42,147.68 19.42,154.42 arc(19.44,154.49) 19.48,154.56 20.79,155.86 arc(20.83,155.93) 20.85,156 20.85,156.81 arc(20.83,156.88) 20.79,156.94 20.16,157.58 arc(20.11,157.64) 20.1,157.71 20.1,161.36 arc(20.09,161.44) 20.04,161.5 v1(18.81,162.73)
  BOTTOM w0.254: 19.07,161.97 18.65,161.55 CN9.6
  BOTTOM w0.508: v1(18.81,162.73) 19.07,162.47 19.07,161.97
