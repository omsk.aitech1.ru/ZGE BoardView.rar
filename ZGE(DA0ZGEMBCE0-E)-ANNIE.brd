# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_RT_SSTXN: length 3.2
  TOP w0.165: U15.38 262.64,30.26 262.96,29.94 262.96,29.38 v1(262.83,29.25)
  BOTTOM w0.165: C857.1 263.12,28.46 263.12,28.97 v1(262.83,29.25)
USB3_RT_SSTXP: length 3.2
  TOP w0.165: U15.39 263.04,30.38 263.33,30.09 263.33,29.44 v1(263.52,29.25)
  BOTTOM w0.165: v1(263.52,29.25) 263.49,29.22 263.49,28.5 263.77,28.22 C856.1
USB3_RT_TEST_29: length 2.2
  TOP w0.14: TP32.1 257.45,31.08 258.54,32.17 U15.29
USB3_RT_TEST_30: length 3.3
  TOP w0.14: TP33.1 257.17,29.76 258.11,30.7 258.11,31.15 258.73,31.77 U15.30
USB3_RT_TEST_EN: length 4.1
  TOP w0.14: TP31.1 256.43,30.9 257.5,31.97 257.5,32.6 257.86,32.97 U15.27
USB3_RT_TEST_R: length 1.8
  TOP w0.14: U15.18 260.64,36.92 260.39,37.17 260.39,37.56 TP29.1
USB3_RT_TX1N: length 2.8
  TOP w0.165: U15.15 261.84,38.01 261.74,38.11 261.74,38.41 C239.2
USB3_RT_TX1P: length 2.8
  TOP w0.165: U15.14 262.24,36.73 262.21,36.76 262.21,38.16 262.11,38.26 262.11,38.48 C240.2
USB3_RT_VIN:
  vias: v1(266.77,36.72) v1(266.87,34.84) v1(267.43,36.72)
USB3_RT_VX:
  vias: v1(265.98,34.42)
USB3_RT_XTAL_I: length 7.1
  TOP w0.14: Y2.1 256.03,40.22 256.7,39.55 R247.1 258.57,39.55 C237.2 258.95,38.36 258.95,37.51 259.84,36.61 U15.20
USB3_RT_XTAL_O: length 3.3
  TOP w0.14: U15.21 259.35,35.37 259.46,35.48 259.46,35.69 259.32,35.83 258.71,35.83 258.57,35.97 258.57,36.21 258.71,36.35 258.78,36.35 258.92,36.49 258.92,36.72 258.72,36.92 258.4,36.92 R277.2
USB3_RT_XTAL_O_R: length 3.9
  TOP w0.14: Y2.3 257.77,38.91 257.91,38.77 R247.2 257.32,37.75 C260.2 R277.1
USB3O2_MUX_AUXN: length 5.9
  TOP w0.14: TP47.1 276.37,25.31 275.51,26.18 275.51,28.41 275.13,28.79 275.13,29.35 274.88,29.6 U16.17
USB3O2_MUX_AUXP: length 4.3
  TOP w0.14: TP45.1 275.13,26.93 275.13,28.39 274.85,28.68 274.85,29.24 274.48,29.6 U16.16
USB3O2_MUX_AVDD33: length 4.5
  TOP w0.203: U16.13 273.28,29.54 273.25,29.51
  TOP w0.381: v1(271.95,30.29) 271.95,29.81 271.8,29.66 C351.2 272.48,29.2 272.94,29.2 273.25,29.51
  vias: v1(278.22,29.4) v1(278.43,30.06)
USB3O2_MUX_CABLE_DET: length 2.8
  TOP w0.14: R387.1 273.79,28.54 R386.2 273.79,29.35 273.68,29.46 U16.14
USB3O2_MUX_CC1: length 4.2
  TOP w0.14: U16.21 276.48,29.83 276.75,29.56 276.75,26.97 TP44.1
USB3O2_MUX_CC2: length 4.2
  TOP w0.14: TP43.1 276.47,26.94 276.47,29.44 276.08,29.83 U16.20
USB3O2_MUX_CC_CAP: length 2.8
  TOP w0.14: TP42.1 277.16,27.83 277.16,29.56 276.88,29.83 U16.22
USB3O2_MUX_CFG_SCL: length 4.6
  TOP w0.14: R269.1 279.56,37.89 279.52,37.93 277.54,37.93 276.88,37.27 U16.39
USB3O2_MUX_CFG_SDA: length 4.2
  TOP w0.14: R278.1 279.15,36.87 v1(278.88,37.14) 278.49,37.53 277.7,37.53 277.29,37.12 277.29,37.1 277.28,37.1 U16.38
USB3O2_MUX_DP_LN_0N: length 2.7
  TOP w0.14: v1(271.49,36.08) 271.49,35.6 271.85,35.24 U16.2
  BOTTOM w0.14: v1(271.49,36.08) 271.49,35.56 271.71,35.35 TP86.1
USB3O2_MUX_DP_LN_0P: length 2.6
  TOP w0.14: v1(272.77,36.75) 272.77,36.34 272.38,35.95 U16.1
  BOTTOM w0.14: v1(272.77,36.75) 271.51,36.75 TP82.1
USB3O2_MUX_DP_LN_3N: length 4.4
  TOP w0.14: U16.4 271.81,34.44 271.27,34.99 v1(270.96,34.99)
  BOTTOM w0.14: v1(270.96,34.99) 271.24,34.99 271.67,34.56 272.84,34.56 TP92.1
USB3O2_MUX_DP_LN_3P: length 5.6
  TOP w0.14: U16.3 271.85,34.84 270.81,35.88 v1(270.81,36.08)
  BOTTOM w0.14: v1(270.81,36.08) 270.81,35.82 271.19,35.44 271.2,35.44 271.8,34.84 272.82,34.84 TP85.1
USB3O2_MUX_DRP_EN: length 3.3
  TOP w0.14: v1(279.6,32.5) 279.54,32.44 U16.28
  BOTTOM w0.14: v1(279.6,32.5) 279.6,32.66 278.94,33.32 R890.2 R897.1
USB3O2_MUX_HPD: length 1.8
  TOP w0.14: v1(278.19,37.06) 277.78,37.06 277.68,36.95 U16.37
  BOTTOM w0.14: TP78.1 278.38,37.25 v1(278.19,37.06)
USB3O2_MUX_I2C_ADR0: length 3.8
  TOP w0.14: R249.2 272.31,37.71 v1(272.63,37.39) 272.89,37.39 273.28,36.99 U16.48
  BOTTOM w0.14: v1(272.63,37.39) 272.31,37.71 R249.2
USB3O2_MUX_I2C_ADR1: length 3.2
  TOP w0.14: R250.2 273.32,38.45 v1(272.86,37.99) 272.86,37.87 273.68,37.05 U16.47
  BOTTOM w0.14: v1(272.86,37.99) 273.32,38.45 R250.2
USB3O2_MUX_INTP_OUT: length 2.1
  TOP w0.14: U16.41 276.08,38 276.37,38.28 R253.2
USB3O2_MUX_NC_23: length 1.5
  TOP w0.14: TP37.1 277.64,29.48 277.28,29.84 U16.23
USB3O2_MUX_PU_PWR: length 33.5
  TOP w0.508: R386.1 v1(273.79,27.12) ; R285.1 v1(281.84,36.49)
  IN3 w0.508: v1(281.84,36.49) 281.83,36.49 280.49,35.14 279.34,35.14 278.78,34.59 278.78,31.51 274.39,27.12 v1(273.79,27.12)
  BOTTOM w0.508: R897.2 R904.1 278.01,30.69 274.44,27.12 v1(273.79,27.12) ; v1(281.84,36.49) 281.84,36.92 280.24,38.51 R839.2 R840.2 277.88,38.51 277.1,39.29 R841.1 R842.1
USB3O2_MUX_PWR_EN: length 43.7
  TOP w0.14: D77.1 258.48,11.46 C487.1 R610.2 259.92,11.46 260.62,10.76 264.1,10.76 264.43,11.09 264.97,11.09 265.49,11.61 265.49,11.81 v1(265.22,12.08) ; U16.27 279.45,32.04 v1(279.67,31.82)
  IN4 w0.086: v1(279.67,31.82) 279.67,28.2 278.77,27.3 278.77,23.65 276.6,21.48 276.6,17.59 276.35,17.34 276.35,16.91 274.77,15.33 271.42,15.33 270.66,16.09 269.97,16.09 268.61,14.73 268.61,13.21 268.47,13.07 265.5,13.07 265.22,12.79 v1(265.22,12.08)
  BOTTOM w0.14: v1(279.67,31.82) 279.79,31.7 R903.1 R904.2
USB3O2_MUX_RESET_N: length 61
  TOP w0.14: U16.33 279.08,34.44 279.63,34.99 280.02,34.99 280.17,34.84 R299.1 R285.2 280.93,35.35 281.65,35.35 v1(282.06,35.75) ; R628.1 259.69,9.63 v1(259.43,9.9) 259.43,9.92 258.97,10.38 258.46,10.38 258.16,10.07 257.74,10.07 C493.1 257.04,9.81 257.04,10.13 256.33,10.84 D79.2
  IN2 w0.089: v1(259.43,9.9) 259.64,9.69 265.52,9.69 266.36,10.53 269.41,10.53 269.56,10.38 272.89,10.38 273.04,10.53 276.45,10.53 279.14,13.22 280.17,13.22 280.68,13.73 280.68,15.19 281.3,15.82 281.3,19.3 280.69,19.9 278.89,19.9 278.3,20.49 278.3,21.38 v1(277.84,21.84)
  IN4 w0.086: v1(277.84,21.84) 278.96,22.95 278.96,27.22 280.1,28.36 280.1,29.8 281.32,31.03 281.32,35.02 v1(282.06,35.75)
USB3O2_MUX_SBU1: length 2.9
  TOP w0.14: U16.19 275.68,29.79 276.19,29.28 276.19,27.93 TP41.1
USB3O2_MUX_SBU2: length 1.5
  TOP w0.14: U16.18 275.28,29.71 275.61,29.38 TP36.1
USB3O2_MUX_SSRX1N: length 2.3
  TOP w0.14: U16.32 279.08,34.04 279.56,34.53 v1(279.82,34.53)
  BOTTOM w0.14: TP90.1 279.89,34.46 v1(279.82,34.53)
USB3O2_MUX_SSRX1P: length 2
  TOP w0.14: U16.31 279.29,33.64 v1(279.57,33.93)
  BOTTOM w0.14: TP89.1 279.04,34.46 v1(279.57,33.93)
USB3O2_MUX_SSRX2N: length 2.9
  TOP w0.14: v1(279.79,36.4) 279.71,36.4 279.29,35.98 279.29,35.44 279.09,35.24 U16.35
  BOTTOM w0.14: v1(279.79,36.4) 279.79,36.5 TP79.1
USB3O2_MUX_SSRX2P: length 1.7
  TOP w0.14: U16.36 278.58,35.98 278.33,36.22 278.33,36.25 v1(278.19,36.39)
  BOTTOM w0.14: v1(278.19,36.39) 278.63,35.95 TP83.1
USB3O2_MUX_SSRX_N: length 2.3
  TOP w0.14: U16.5 271.53,34.04 v1(271.21,34.36)
  BOTTOM w0.14: v1(271.21,34.36) 271.34,34.23 271.82,34.23 271.98,34.08 TP93.1
USB3O2_MUX_SSRX_P: length 4.5
  TOP w0.14: U16.6 271.8,33.64 271.69,33.75 271.32,33.75 271.16,33.9 271.01,33.9 v1(270.49,34.42)
  BOTTOM w0.14: v1(270.49,34.42) 270.99,33.93 271.04,33.93 272.05,32.91 TP96.1
USB3O2_MUX_SSRXN: length 16.8
  TOP w0.165: U16.8 271.65,32.84 271.56,32.93 270.98,32.93 v1(270.86,32.81) ; v1(264.28,40.22) 264.22,40.17 264.22,39.76 C242.1
  IN3 w0.114: v1(270.86,32.81) 271.07,33.02 271.38,33.02 272.24,33.89 272.24,36.49 269.13,39.6 264.27,39.6 264.15,39.72 264.15,40.1 v1(264.28,40.22)
USB3O2_MUX_SSRXP: length 16.8
  TOP w0.165: C241.1 263.69,39.55 263.86,39.71 263.86,40.01 263.66,40.2 v1(263.59,40.2) ; v1(270.83,33.47) 271.01,33.3 271.72,33.3 271.77,33.24 U16.7
  IN3 w0.114: v1(270.83,33.47) 270.99,33.32 271.26,33.32 271.95,34.01 271.95,36.36 269,39.31 264.15,39.31 263.86,39.6 263.86,40.04 263.7,40.2 v1(263.59,40.2)
USB3O2_MUX_SSTX1N: length 6.7
  TOP w0.14: R327.1 283.87,33.72 L6.1 283.48,33.72 283.39,33.63 283.05,33.63 280.79,31.37 279.41,31.37 279.14,31.64 U16.26
USB3O2_MUX_SSTX1P: length 6.7
  TOP w0.14: U16.25 279.16,31.24 279.3,31.11 280.9,31.11 283.16,33.37 283.3,33.37 283.5,33.17 L6.4 283.87,33.17 R342.1
USB3O2_MUX_SSTX2N: length 6.2
  TOP w0.14: U16.29 279.18,32.84 279.34,33.01 280.05,33.01 v1(280.21,32.86)
  BOTTOM w0.14: R899.1 284.15,32.07 L34.1 283.46,32.3 283.32,32.44 281.24,32.44 280.64,33.04 280.38,33.04 v1(280.21,32.86)
USB3O2_MUX_SSTX2P: length 6.2
  TOP w0.14: U16.30 279.2,33.24 279.23,33.28 279.96,33.28 v1(280.19,33.51)
  BOTTOM w0.14: R892.1 283.92,32.85 L34.4 283.45,32.85 283.3,32.71 281.35,32.71 280.75,33.3 280.39,33.3 v1(280.19,33.51)
USB3O2_MUX_SSTXN: length 17.3
  TOP w0.165: v1(261.54,40.25) 261.57,40.22 261.57,39.73 C239.1 ; U16.10 271.78,32.04 271.76,32.06 271.3,32.06 270.95,31.7 270.57,31.7 v1(270.43,31.56)
  IN3 w0.114: v1(261.54,40.25) 261.74,40.05 261.74,39.3 262.6,38.44 263.92,38.44 265.23,37.13 265.23,34.72 267.37,32.58 268.11,32.58 268.97,31.72 270.27,31.72 v1(270.43,31.56)
USB3O2_MUX_SSTXP: length 17.3
  TOP w0.165: C240.1 262.1,39.55 261.93,39.71 261.93,39.99 v1(262.22,40.28) ; U16.9 271.76,32.44 271.75,32.43 271.15,32.43 270.8,32.07 270.58,32.07 v1(270.43,32.22)
  IN3 w0.114: v1(262.22,40.28) 262.03,40.08 262.03,39.42 262.72,38.73 264.04,38.73 265.52,37.26 265.52,34.85 267.49,32.87 268.23,32.87 269.1,32.01 270.21,32.01 v1(270.43,32.22)
USB3O2_MUX_TEST_EN: length 2.6
  TOP w0.14: U16.34 279.08,34.84 279.77,35.54 v1(279.77,35.75)
  BOTTOM w0.14: v1(279.77,35.75) 279.85,35.83 TP84.1
USB3O2_MUX_USB_ID: length 2.1
  TOP w0.14: R252.1 275.68,38.19 U16.42
USB3O2_MUX_VBUS_CTRL: length 2.5
  TOP w0.14: U16.43 275.28,37.1 275.33,37.15 275.33,37.76 274.58,38.51 R251.2
USB3O2_MUX_VBUS_DIV6: length 2.8
  TOP w0.14: TP40.1 274.64,28.39 274.57,28.46 274.57,29.12 274.08,29.61 U16.15
USB3O2_MUX_VCONN1_EN: length 2.8
  TOP w0.14: U16.45 274.48,37.19 274.29,37.38 v1(274.29,37.86)
  BOTTOM w0.14: TP80.1 274.29,37.28 v1(274.29,37.86)
USB3O2_MUX_VCONN2_EN: length 2.1
  TOP w0.14: v1(274.85,37.51) 274.88,37.47 U16.44
  BOTTOM w0.14: TP81.1 274.85,36.73 v1(274.85,37.51)
USB30_RX1+: length 171.9
  TOP w0.102: U14.C11 208.66,44.64 208.66,45.36 208.4,45.63 208.4,46.98 208.66,47.25 208.78,47.25 v1(209.01,47.48)
  TOP w0.14: v1(64.48,24.45) 64.3,24.64 63.61,24.64 63.46,24.49 63.22,24.49 C397.1
  IN4 w0.114: v1(209.01,47.48) 208.84,47.3 208.5,47.3 207.28,46.09 206.75,46.09 205.78,47.06 202.84,47.06 201.14,48.76 197.26,48.76 196.14,47.64 194.85,47.64 194.27,48.22 190.39,48.22 189.93,48.68 183.5,48.68 182.94,49.24 182.09,49.24 180.28,47.43 180.28,45.27 176.37,41.36 176.37,40.65 172.91,37.19 102.3,37.19 101.9,36.79 98.98,36.79 98.45,36.26 97.71,36.26 97.18,36.79 94.24,36.79 94.17,36.71 90.74,36.71 89.54,37.91 87.91,37.91 86.95,36.96 86.08,36.96 84.85,35.73 83.74,35.73 82.04,34.03 80.42,34.03 79.6,33.21 79.6,32.12 78.37,30.89 76.39,30.89 75.4,29.9 75.4,29.49 75.07,29.16 73.71,29.16 73.5,28.95 70.92,28.95 69.55,27.58 66.36,27.58 65.92,28.01 65.3,28.01 65.02,28.29 63.48,28.29 62.81,27.62 62.81,26.01 63.14,25.68 63.14,25.04 63.54,24.64 64.29,24.64 v1(64.48,24.45)
USB30_RX1+_C: length 2.8
  TOP w0.14: U21.8 60.57,25.02 60.65,25.1 60.9,25.1 61.38,24.63 61.87,24.63 62.04,24.46 62.32,24.46 C397.2
USB30_RX1+_R: length 67
  TOP w0.14: v1(52.06,24.2) 52.27,24.41 53.15,24.41 R422.2
  IN2 w0.089: v1(8.57,17.04) 8.57,16.92 8.25,16.6 7.95,16.6 7.63,16.27 7.63,15.19 8.12,14.69 8.12,13.74 8.89,12.97 10.04,12.97 10.52,12.49 11.96,12.49 14.54,15.07 15.23,15.07 16.92,16.75 18.19,16.75 18.98,17.53 24.69,17.53 26.77,19.6 37.29,19.6 38.05,20.36 46.21,20.36 48.91,23.06 48.91,23.82 49.62,24.53 51.72,24.53 v1(52.06,24.2)
  BOTTOM w0.14: v1(8.57,17.04) 8.57,16.79 8.41,16.63 7.96,16.63 7.03,17.56 7.03,21.94 7.63,22.54 11.1,22.54 11.14,22.5 CN17.18
USB30_RX1+_RT: length 2.5
  TOP w0.14: R422.1 53.93,24.52 54.57,24.52 55.05,25 55.5,25 55.52,25.02 U21.39
USB30_RX1-: length 171.9
  TOP w0.102: v1(209.01,46.82) 209.01,46.94 208.91,47.04 208.75,47.04 208.6,46.9 208.6,45.71 208.87,45.45 208.87,44.47 208.68,44.29 208.68,44.14 U14.D11
  TOP w0.14: v1(64.48,25.19) 64.48,25.02 64.34,24.88 63.51,24.88 63.36,24.73 63.21,24.73 C382.1
  IN4 w0.114: v1(64.48,25.19) 64.48,25 64.35,24.87 63.63,24.87 63.37,25.14 63.37,25.77 63.04,26.1 63.04,27.52 63.57,28.06 64.93,28.06 65.21,27.78 65.83,27.78 66.26,27.35 69.64,27.35 71.02,28.73 73.6,28.73 73.81,28.93 75.16,28.93 75.63,29.4 75.63,29.8 76.49,30.66 78.47,30.66 79.83,32.03 79.83,33.12 80.51,33.8 82.14,33.8 83.84,35.5 84.95,35.5 86.17,36.73 87.05,36.73 88,37.68 89.44,37.68 90.64,36.48 94.26,36.48 94.34,36.56 97.08,36.56 97.61,36.03 98.54,36.03 99.08,36.56 101.99,36.56 102.39,36.96 173.01,36.96 176.6,40.56 176.6,41.27 180.51,45.18 180.51,47.34 182.19,49.01 182.85,49.01 183.41,48.45 189.83,48.45 190.3,47.99 194.18,47.99 194.76,47.41 196.23,47.41 197.35,48.53 201.04,48.53 202.74,46.83 205.69,46.83 206.65,45.86 207.38,45.86 208.59,47.08 208.9,47.08 209.01,46.96 v1(209.01,46.82)
USB30_RX1-_C: length 2.8
  TOP w0.14: C382.2 62.27,24.7 62.14,24.7 61.97,24.87 61.48,24.87 61,25.34 60.62,25.34 60.54,25.42 U21.9
USB30_RX1-_R: length 67.1
  TOP w0.14: v1(52.06,24.94) 52.17,24.83 53.03,24.83 R413.2
  IN2 w0.089: v1(52.06,24.94) 51.92,24.81 49.5,24.81 48.63,23.94 48.63,23.18 46.1,20.64 37.93,20.64 37.17,19.88 26.65,19.88 24.58,17.81 18.86,17.81 18.08,17.03 16.8,17.03 15.12,15.35 14.42,15.35 11.84,12.77 10.63,12.77 10.15,13.25 9.01,13.25 8.4,13.86 8.4,14.81 7.91,15.3 7.91,16.16 8.07,16.32 8.28,16.32 v1(8.57,16.03)
  BOTTOM w0.14: CN17.19 11.14,23 11.1,22.96 7.46,22.96 6.61,22.11 6.61,17.39 7.79,16.21 8.39,16.21 v1(8.57,16.03)
USB30_RX1-_RT: length 2.5
  TOP w0.14: R413.1 53.83,24.94 54.39,24.94 54.88,25.42 U21.38
USB30_RX2+: length 165.8
  TOP w0.102: U14.C9 207.6,44.69 207.18,45.11 207.18,45.48 207.56,45.85 207.56,47.34 207.44,47.45 207.33,47.45 v1(207.1,47.23)
  TOP w0.14: C350.1 63.32,29.21 64.26,29.21 64.52,29.47 64.6,29.47 v1(64.75,29.33)
  IN4 w0.114: v1(207.1,47.23) 206.98,47.35 206.52,47.35 205.94,47.92 203.04,47.92 200.63,50.33 198.01,50.33 196.21,48.53 194.77,48.53 194.51,48.79 190.65,48.79 190.17,49.27 186.51,49.27 185.86,49.92 183.76,49.92 182.78,50.89 182.06,50.89 179.39,48.23 179.39,45.2 175.69,41.49 175.69,40.78 172.83,37.93 105.59,37.93 105.42,37.76 101.82,37.76 101.53,37.47 94.18,37.47 93.4,38.25 92.76,38.25 92.32,37.81 90.51,37.81 89.83,38.48 87.64,38.48 86.91,37.76 85.48,37.76 84.63,36.91 84.1,36.91 81.83,34.64 80.1,34.64 77.51,32.05 76.69,32.05 76.23,32.51 75.7,32.51 75.16,31.98 75.16,31.46 73.23,29.53 70.52,29.53 69.14,28.15 67.33,28.15 66.24,29.24 66.24,29.72 66.01,29.94 65.63,29.94 65.27,29.59 65.01,29.59 v1(64.75,29.33)
USB30_RX2+_C: length 2.7
  TOP w0.14: U21.17 60.94,28.62 61.5,29.18 62.22,29.18 C350.2
USB30_RX2+_R: length 75.6
  TOP w0.14: v1(52.22,28.76) 52.4,28.95 53.18,28.95 R381.2
  IN1 w0.086: v1(52.22,28.76) 51.99,28.99 51.71,28.99 50.36,27.64 48.04,27.64 46.76,26.37 46.76,21.06 46.23,20.53 37.89,20.53 37.01,19.65 32.78,19.65 31.8,18.67 25.07,18.67 24.45,19.29 20.61,19.29 18.09,16.77 17.11,16.77 15.34,15 14.54,15 12.05,12.5 10.28,12.5 7.41,15.37 7.41,17.83 8.1,18.52 8.1,18.92 8.48,19.29 9.1,19.29 10.68,20.87 10.68,21.86 11.34,22.52 13.18,22.52 13.66,23 13.66,26.86 13.4,27.13 12.98,27.13 12.82,26.97 v1(12.82,26.79)
  BOTTOM w0.14: CN17.27 12.62,27 v1(12.82,26.79)
USB30_RX2+_RT: length 2.5
  TOP w0.14: U21.30 55.3,28.62 54.82,29.1 53.94,29.1 R381.1
USB30_RX2-: length 165.8
  TOP w0.102: v1(207.07,47.88) 207.29,47.66 207.52,47.66 207.76,47.42 207.76,45.77 207.39,45.4 207.39,45.19 207.46,45.12 207.55,45.12 U14.B9
  TOP w0.14: v1(64.76,30) 64.47,29.71 64.42,29.71 64.16,29.46 63.11,29.46 C339.1
  IN4 w0.114: v1(207.07,47.88) 207.07,47.77 206.88,47.58 206.61,47.58 206.04,48.15 203.14,48.15 200.72,50.56 197.92,50.56 196.11,48.76 194.87,48.76 194.6,49.02 190.74,49.02 190.26,49.5 186.61,49.5 185.96,50.14 183.85,50.14 182.87,51.12 181.97,51.12 179.16,48.32 179.16,45.3 175.46,41.59 175.46,40.88 172.74,38.16 105.5,38.16 105.33,37.99 101.73,37.99 101.44,37.7 94.28,37.7 93.49,38.48 92.67,38.48 92.22,38.04 90.6,38.04 89.93,38.71 87.54,38.71 86.82,37.99 85.38,37.99 84.53,37.14 84.01,37.14 81.74,34.87 80,34.87 77.41,32.27 76.79,32.27 76.32,32.74 75.6,32.74 74.93,32.07 74.93,31.55 73.14,29.75 70.42,29.75 69.05,28.38 67.42,28.38 66.47,29.34 66.47,29.81 66.11,30.17 65.53,30.17 65.18,29.82 64.94,29.82 v1(64.76,30)
USB30_RX2-_C: length 2.7
  TOP w0.14: C339.2 62.37,29.42 61.4,29.42 60.84,28.86 60.67,28.86 60.52,29.02 U21.18
USB30_RX2-_R: length 75.6
  TOP w0.14: v1(52.24,29.46) 52.33,29.37 52.99,29.37 R371.2
  IN1 w0.086: v1(12.81,27.71) 13.16,27.36 13.49,27.36 13.9,26.96 13.9,22.9 13.28,22.28 11.44,22.28 10.92,21.76 10.92,20.77 9.2,19.06 8.58,19.06 8.34,18.82 8.34,18.42 7.65,17.73 7.65,15.47 10.38,12.74 11.95,12.74 14.44,15.24 15.24,15.24 17.01,17.01 18,17.01 20.51,19.53 24.55,19.53 25.17,18.91 31.7,18.91 32.69,19.89 36.91,19.89 37.79,20.77 46.13,20.77 46.53,21.16 46.53,26.47 47.94,27.88 50.26,27.88 51.61,29.23 52.02,29.23 v1(52.24,29.46)
  BOTTOM w0.14: v1(12.81,27.71) 12.52,27.42 12.28,27.42 12.2,27.5 CN17.28
USB30_RX2-_RT: length 2.5
  TOP w0.14: U21.29 55.49,29.02 55,29.52 53.82,29.52 R371.1
USB30_RX3+: length 103.1
  TOP w0.102: v1(208.64,48.74) 208.9,48.48 208.9,48.33 207.98,47.41 207.98,45.49 207.84,45.36 207.84,44.83 208.03,44.64 208.03,44.64 U14.C10
  TOP w0.14: C490.1 271.65,10.61 271.39,10.61 271.06,10.28 270.11,10.28 269.71,10.67 268.58,10.67 268.3,10.39 268.3,10.26 v1(267.96,9.92)
  IN4 w0.114: v1(208.64,48.74) 208.93,48.45 208.93,48.26 209.22,47.97 209.52,47.97 210.05,47.44 210.05,47.06 209.42,46.43 209.42,45.97 208.59,45.13 207.49,45.13 207.08,44.72 207.08,43.69 207.36,43.41 207.36,42.63 207.11,42.38 206.78,42.38 206.38,41.99 206.38,41.64 205.68,40.94 205.68,39.77 207.59,37.86 208.2,37.86 208.63,37.43 208.63,36.9 209.01,36.52 211.94,36.52 213.3,35.15 213.3,34.77 214.81,33.27 219.14,33.27 220.08,32.33 224.22,32.33 224.68,31.87 230.19,31.87 231.08,32.76 232.03,32.76 232.61,32.17 234.51,32.17 234.92,31.77 234.92,31.54 235.65,30.8 238.4,30.8 239.95,29.25 244.17,29.25 247.07,26.36 247.83,26.36 250.24,23.94 252.77,23.94 254.4,22.32 254.4,21.49 255.06,20.83 255.06,19.52 256.48,18.1 256.48,16.99 257.09,16.38 257.09,12.98 260.2,9.87 265.63,9.87 266.26,10.51 267.92,10.51 268.13,10.3 268.13,10.08 v1(267.96,9.92)
USB30_RX3+_R: length 11.8
  TOP w0.14: R621.2 280.94,10.81 281.3,10.81 281.48,10.63 282.42,10.63 282.84,10.21 282.84,9.93 v1(283.05,9.72)
  BOTTOM w0.14: v1(283.05,9.72) 282.86,9.91 282.86,10.08 283.1,10.32 283.68,10.32 284.21,10.84 284.21,11.92 283.77,12.35 283.77,13.56 284.06,13.84 284.25,13.84 D80.1 284.66,13.91 285.25,13.91 285.88,14.54 286.2,14.54 286.45,14.28 CN7.6
USB30_RX3+_RTI: length 2.2
  TOP w0.14: U30.21 278.81,11.15 278.83,11.17 279.6,11.17 279.95,10.82 280.19,10.82 R621.1
USB30_RX3+_RTO: length 2.1
  TOP w0.14: U30.8 273.81,11.15 273.29,10.62 272.6,10.62 C490.2
USB30_RX3-: length 103.1
  TOP w0.102: U14.B10 208.28,44.9 208.22,44.85 208.12,44.85 208.05,44.92 208.05,45.27 208.18,45.41 208.18,47.32 209.11,48.25 209.11,48.62 209.22,48.74 v1(209.43,48.74)
  TOP w0.14: v1(268.79,9.92) 268.54,10.17 268.54,10.29 268.68,10.43 269.61,10.43 270.01,10.04 271.16,10.04 271.49,10.37 271.69,10.37 C494.1
  IN4 w0.114: v1(268.79,9.92) 268.49,9.92 268.35,10.06 268.35,10.39 268.01,10.74 266.17,10.74 265.53,10.1 260.29,10.1 257.32,13.07 257.32,16.48 256.71,17.09 256.71,18.2 255.29,19.62 255.29,20.92 254.63,21.58 254.63,22.41 252.87,24.17 250.34,24.17 247.92,26.58 247.16,26.58 244.27,29.48 240.05,29.48 238.5,31.03 235.75,31.03 235.15,31.63 235.15,31.86 234.61,32.4 232.71,32.4 232.12,32.99 230.99,32.99 230.1,32.1 224.77,32.1 224.31,32.55 220.18,32.55 219.24,33.49 214.9,33.49 213.53,34.87 213.53,35.25 212.03,36.74 209.1,36.74 208.86,36.99 208.86,37.53 208.29,38.09 207.69,38.09 205.91,39.87 205.91,40.84 206.61,41.54 206.61,41.89 206.88,42.16 207.21,42.16 207.59,42.54 207.59,43.5 207.31,43.78 207.31,44.63 207.58,44.9 208.68,44.9 209.65,45.87 209.65,46.34 210.28,46.96 210.28,47.53 209.61,48.2 209.31,48.2 209.16,48.35 209.16,48.47 v1(209.43,48.74)
USB30_RX3-_R: length 11.8
  TOP w0.14: R627.2 280.93,10.39 281.12,10.39 281.3,10.21 282.24,10.21 282.42,10.03 282.42,9.8 v1(282.31,9.69)
  BOTTOM w0.14: CN7.5 286.45,15.14 286.26,14.95 285.7,14.95 285.08,14.33 284.7,14.33 D81.1 284.12,14.26 283.88,14.26 283.36,13.73 283.36,12.17 283.79,11.74 283.79,11.01 283.51,10.74 282.92,10.74 282.44,10.26 282.44,9.82 v1(282.31,9.69)
USB30_RX3-_RTI: length 2.2
  TOP w0.14: R627.1 280.19,10.4 279.77,10.4 279.42,10.75 U30.20
USB30_RX3-_RTO: length 2.1
  TOP w0.14: U30.9 273.76,10.75 273.39,10.38 272.59,10.38 C494.2
USB30_RX4+: length 78.6
  TOP w0.14: U14.J15 210.99,41.95 v1(211.22,42.18) ; C483.2 264.04,12.23 263.85,12.03 263.85,11.83 v1(264.11,11.57)
  IN4 w0.114: v1(211.22,42.18) 211.35,42.05 212.71,42.05 215.92,38.84 218.52,38.84 218.65,38.98 219.77,38.98 220.13,38.62 220.13,38.19 221.58,36.74 223.01,36.74 223.37,37.1 224.64,37.1 224.89,37.35 228.38,37.35 228.79,36.95 230.81,36.95 231.37,37.51 232.55,37.51 233.69,36.36 235.71,36.36 236.35,37 237.81,37 238.42,36.39 239.08,36.39 240.11,35.36 243.64,35.36 244.19,34.81 245.43,34.81 246.42,33.82 246.42,32.4 247.24,31.59 251.35,31.59 252.11,32.35 253.99,32.35 255.57,30.78 255.57,27.26 256.7,26.13 258.54,26.13 260.01,24.65 260.01,18.48 260.32,18.18 260.32,16.32 260.9,15.73 260.9,14.01 262.38,12.54 263.42,12.54 263.96,12 263.96,11.72 v1(264.11,11.57)
USB30_RX4-: length 78.6
  TOP w0.14: C482.2 263.47,12.23 263.61,12.09 263.61,11.9 v1(263.28,11.57) ; U14.K16 211.1,41.57 v1(211.47,41.57)
  IN4 w0.114: v1(211.47,41.57) 211.73,41.82 212.62,41.82 215.83,38.61 218.61,38.61 218.75,38.75 219.68,38.75 219.91,38.52 219.91,38.09 221.48,36.52 223.11,36.52 223.46,36.87 224.73,36.87 224.99,37.13 228.29,37.13 228.69,36.72 230.9,36.72 231.46,37.28 232.45,37.28 233.6,36.14 235.81,36.14 236.44,36.77 237.72,36.77 238.33,36.16 238.98,36.16 240.01,35.13 243.55,35.13 244.09,34.59 245.34,34.59 246.2,33.73 246.2,32.31 247.14,31.36 251.45,31.36 252.21,32.12 253.9,32.12 255.34,30.68 255.34,27.17 256.61,25.9 258.45,25.9 259.78,24.56 259.78,18.39 260.09,18.08 260.09,16.22 260.67,15.64 260.67,13.92 262.28,12.31 263.32,12.31 263.73,11.9 263.73,11.74 263.51,11.51 263.34,11.51 v1(263.28,11.57)
USB30_TX1+: length 160.4
  TOP w0.14: U14.F7 206.81,43.49 206.61,43.49 206.46,43.64 v1(206.46,43.89) ; v1(64.51,22.65) 64.42,22.65 63.89,22.11 63.08,22.11 C423.1
  IN4 w0.114: v1(64.51,22.65) 64.3,22.43 64.3,22.25 64.41,22.14 64.84,22.14 64.99,22.29 65.27,22.29 66.84,23.87 69.83,23.87 70.61,24.65 71.96,24.65 73.91,26.6 73.91,26.98 74.4,27.47 76.86,27.47 77.34,27.96 77.98,27.96 81.03,31 82.46,31 82.93,31.47 84,31.47 84.63,32.1 84.63,33.24 86.37,34.98 86.37,34.98 86.74,35.36 88.63,35.36 89.3,34.69 92.5,34.69 92.92,35.11 94.13,35.11 94.43,34.81 95.55,34.81 96.37,33.99 98.8,33.99 99.96,35.15 102.7,35.15 103.13,35.58 173.63,35.58 181.81,43.76 183.5,43.76 184.57,44.82 185.5,44.82 186.97,46.3 189.7,46.3 190.7,45.3 194.73,45.3 195.4,45.97 196.46,45.97 198.37,44.06 203.47,44.06 204.41,43.12 205.12,43.12 205.48,42.76 205.78,42.76 206.26,43.24 206.38,43.24 206.51,43.37 206.51,43.84 v1(206.46,43.89)
USB30_TX1+_C: length 2.7
  TOP w0.14: C423.2 62.27,22.28 61.47,22.28 61.04,22.7 60.67,22.7 60.59,22.62 U21.2
USB30_TX1+_R: length 64.3
  TOP w0.14: v1(52.46,22.17) 52.6,22.32 53.08,22.32 R444.2
  IN2 w0.089: v1(52.46,22.17) 52.25,22.38 49.45,22.38 46.55,19.48 38.41,19.48 37.71,18.78 27.11,18.78 25.04,16.7 19.4,16.7 18.56,15.86 17.35,15.86 15.73,14.24 14.89,14.24 12.25,11.61 8.84,11.61 7.23,13.21 7.23,14.41 6.8,14.84 6.8,17.58 7.49,18.27 8.59,18.27 8.74,18.42 v1(8.74,18.66)
  BOTTOM w0.14: v1(8.74,18.66) 8.74,18.53 8.6,18.39 8.36,18.39 8.1,18.65 8.1,19.08 8.45,19.43 9.06,19.43 10.66,21.04 11.1,21.04 11.14,21 CN17.15
USB30_TX1+_RT: length 2.4
  TOP w0.14: U21.45 55.43,22.62 55.41,22.6 55.03,22.6 54.73,22.31 53.88,22.31 R444.1
USB30_TX1-: length 160.4
  TOP w0.14: C406.1 62.98,22.55 63.18,22.35 63.79,22.35 63.88,22.45 63.88,22.69 v1(63.82,22.75) ; v1(206.83,42.97) U14.F9
  IN4 w0.114: v1(63.82,22.75) 64.07,22.51 64.07,22.16 64.32,21.91 64.93,21.91 65.09,22.06 65.36,22.06 66.94,23.64 69.92,23.64 70.71,24.43 72.05,24.43 74.14,26.51 74.14,26.88 74.5,27.25 76.95,27.25 77.43,27.73 78.07,27.73 81.12,30.78 82.56,30.78 83.03,31.24 84.1,31.24 84.85,32 84.85,33.14 86.59,34.88 86.59,34.89 86.84,35.13 88.54,35.13 89.21,34.46 92.59,34.46 93.02,34.88 94.04,34.88 94.34,34.59 95.45,34.59 96.28,33.76 98.9,33.76 100.06,34.92 102.8,34.92 103.23,35.35 173.72,35.35 181.9,43.53 183.59,43.53 184.66,44.59 185.59,44.59 187.07,46.07 189.61,46.07 190.6,45.07 194.83,45.07 195.49,45.74 196.37,45.74 198.27,43.83 203.38,43.83 204.32,42.89 205.03,42.89 205.38,42.54 205.88,42.54 206.36,43.01 206.78,43.01 v1(206.83,42.97)
USB30_TX1-_C: length 2.7
  TOP w0.14: U21.3 60.56,23.02 60.64,22.94 61.14,22.94 61.57,22.52 62.28,22.52 C406.2
USB30_TX1-_R: length 64.3
  TOP w0.14: v1(52.46,22.84) 52.57,22.74 53.15,22.74 R433.2
  IN2 w0.089: v1(8.73,17.9) 8.64,17.99 7.6,17.99 7.08,17.47 7.08,14.96 7.51,14.53 7.51,13.33 8.95,11.89 12.14,11.89 14.77,14.52 15.61,14.52 17.24,16.14 18.44,16.14 19.29,16.98 24.92,16.98 26.99,19.06 37.6,19.06 38.3,19.76 46.43,19.76 49.33,22.66 52.27,22.66 v1(52.46,22.84)
  BOTTOM w0.14: CN17.16 11.14,21.5 11.1,21.46 10.49,21.46 8.88,19.85 8.27,19.85 7.68,19.26 7.68,18.48 8.19,17.97 8.66,17.97 v1(8.73,17.9)
USB30_TX1-_RT: length 2.4
  TOP w0.14: U21.44 54.85,23.02 54.56,22.73 53.83,22.73 R433.1
USB30_TX2+: length 160.1
  TOP w0.127: v1(205.36,44.19) 205.36,44.34 205.16,44.54 204.98,44.54 U14.D4
  TOP w0.14: C364.1 63.13,26.53 63.54,26.53 63.9,26.89 64.17,26.89 v1(64.46,26.61)
  IN4 w0.114: v1(64.46,26.61) 64.46,26.82 64.32,26.96 64.08,26.96 63.88,26.76 63.88,26.39 64.32,25.96 65.92,25.96 66.41,25.47 71.63,25.47 72.44,26.28 72.44,27.12 73.09,27.77 73.57,27.77 74.07,28.27 75.99,28.27 77.81,30.09 78.89,30.09 80.77,31.97 82.3,31.97 82.95,32.62 82.95,33.79 84.09,34.93 85.18,34.93 86.41,36.16 89.07,36.16 89.72,35.5 92.18,35.5 92.59,35.91 94.63,35.91 94.66,35.95 96.16,35.95 96.7,35.4 99.09,35.4 99.63,35.95 102.3,35.95 102.74,36.39 173.27,36.39 177.23,40.35 177.23,41.06 177.93,41.75 178.49,41.75 182.83,46.09 183.57,46.09 185.06,47.59 188.59,47.59 188.76,47.42 193.94,47.42 194.53,46.83 196.46,46.83 197.58,47.95 200.8,47.95 203.11,45.63 204.23,45.63 204.94,44.93 204.94,44.31 205.06,44.19 v1(205.36,44.19)
USB30_TX2+_C: length 2.6
  TOP w0.14: C364.2 62.31,26.6 62.12,26.6 61.81,26.29 60.64,26.29 60.57,26.22 U21.11
USB30_TX2+_R: length 72.1
  TOP w0.14: R402.2 53.08,26.66 52.18,26.66 v1(52.15,26.63)
  IN1 w0.086: v1(12.46,25.5) 12.46,25.54 12.62,25.7 12.75,25.7 12.86,25.59 12.86,25.08 12.43,24.65 12.23,24.65 9.89,22.32 9.89,21.2 8.77,20.08 8.15,20.08 7.32,19.25 7.32,18.85 6.58,18.1 6.58,15.1 7.65,14.02 7.65,13.53 9.68,11.51 12.16,11.51 14.86,14.22 15.82,14.22 17.38,15.78 18.51,15.78 20.23,17.51 24.28,17.51 24.66,17.89 32.81,17.89 33.75,18.83 37.35,18.83 38.22,19.7 46.57,19.7 47.55,20.68 47.55,24.28 49.29,26.02 50.43,26.02 51.33,26.92 52.02,26.92 52.15,26.79 v1(52.15,26.63)
  BOTTOM w0.14: v1(12.46,25.5) CN17.24
USB30_TX2+_RT: length 2.5
  TOP w0.14: R402.1 53.87,26.64 53.99,26.64 54.37,26.27 55.17,26.27 55.22,26.22 U21.36
USB30_TX2-: length 160.1
  TOP w0.127: U14.C3 204.56,44.79 v1(204.56,44.11)
  TOP w0.14: v1(64.46,27.35) 64.25,27.14 63.8,27.14 63.44,26.78 63.3,26.78 C357.1
  IN4 w0.114: v1(64.46,27.35) 64.3,27.19 63.99,27.19 63.65,26.85 63.65,26.3 64.22,25.73 65.82,25.73 66.31,25.24 71.72,25.24 72.67,26.18 72.67,27.02 73.19,27.54 73.66,27.54 74.17,28.05 76.08,28.05 77.9,29.86 78.99,29.86 80.87,31.74 82.39,31.74 83.18,32.53 83.18,33.7 84.18,34.7 85.28,34.7 86.51,35.93 88.97,35.93 89.63,35.27 92.27,35.27 92.68,35.68 94.72,35.68 94.76,35.72 96.06,35.72 96.61,35.17 99.18,35.17 99.73,35.72 102.4,35.72 102.84,36.16 173.37,36.16 177.46,40.26 177.46,40.96 178.02,41.52 178.58,41.52 182.92,45.86 183.66,45.86 185.16,47.36 188.49,47.36 188.67,47.19 193.85,47.19 194.44,46.6 196.56,46.6 197.67,47.72 200.7,47.72 203.01,45.41 204.14,45.41 204.72,44.83 204.72,44.26 v1(204.56,44.11)
USB30_TX2-_C: length 2.6
  TOP w0.14: U21.12 60.56,26.62 60.65,26.53 61.71,26.53 62.02,26.85 62.28,26.85 C357.2
USB30_TX2-_R: length 72.1
  TOP w0.14: R390.2 53.15,27.08 52.39,27.08 v1(52.14,27.33)
  IN1 w0.086: v1(52.14,27.33) 51.97,27.16 51.23,27.16 50.34,26.26 49.19,26.26 47.31,24.38 47.31,20.78 46.47,19.94 38.12,19.94 37.25,19.07 33.65,19.07 32.71,18.12 24.56,18.12 24.18,17.75 20.13,17.75 18.41,16.02 17.28,16.02 15.72,14.45 14.77,14.45 12.06,11.75 9.77,11.75 7.89,13.63 7.89,14.12 6.81,15.2 6.81,18 7.56,18.75 7.56,19.15 8.25,19.84 8.87,19.84 10.13,21.1 10.13,22.22 12.33,24.42 12.53,24.42 13.1,24.98 13.1,25.69 12.85,25.94 12.72,25.94 v1(12.49,26.17)
  BOTTOM w0.14: v1(12.49,26.17) 12.49,26.14 12.35,26 CN17.25
USB30_TX2-_RT: length 2.5
  TOP w0.14: U21.35 55.24,26.62 55.17,26.69 54.54,26.69 54.17,27.06 53.85,27.06 R390.1
USB30_TX3+: length 90.6
  TOP w0.14: U14.G12 208.92,42.72 209.05,42.86 209.34,42.86 v1(209.47,42.73) ; v1(270.75,14.39) 270.75,14.24 270.86,14.14 270.96,14.14 271.09,14.01 271.34,14.01 271.62,14.29 C475.1
  IN4 w0.114: v1(209.47,42.73) 209.33,42.87 208.99,42.87 208.64,42.51 208.64,41.6 207.89,40.86 207.35,40.86 207.23,40.74 207.23,39.79 208.1,38.93 209.21,38.93 209.82,38.32 211.85,38.32 212.29,38.75 213.66,38.75 215.11,37.3 215.11,36.24 215.72,35.63 219.17,35.63 219.68,35.12 219.68,34.28 219.94,34.02 222.1,34.02 222.23,34.15 226.71,34.15 227.37,33.49 230.3,33.49 230.6,33.8 232.45,33.8 233,33.25 233.74,33.25 234.11,33.62 236.36,33.62 236.92,33.06 237.71,33.06 239.59,31.18 243.73,31.18 246.58,28.34 248.89,28.34 250.72,26.51 250.94,26.51 251.88,25.57 252.61,25.57 255.47,22.72 255.47,22.34 255.85,21.96 256.48,21.96 257.04,21.4 257.04,19.14 257.63,18.55 257.63,17.61 258.26,16.98 258.26,14.04 259.1,13.2 259.1,12.44 260.6,10.94 265.12,10.94 266.6,12.41 268.83,12.41 269.22,12.8 269.22,13.79 269.69,14.27 270.63,14.27 v1(270.75,14.39)
USB30_TX3+_C: length 1.7
  TOP w0.14: R607.1 281.84,12.65 281.67,12.65 281.26,13.06 280.97,13.06 C479.2
USB30_TX3+_R: length 10.2
  TOP w0.14: R607.2 283.17,12.68 283.65,12.68 284.22,12.11 284.22,10.66 284.94,9.94 284.94,8.92 284.51,8.49 283.7,8.49 v1(283.58,8.37)
  BOTTOM w0.14: v1(283.58,8.37) 283.72,8.51 284.38,8.51 D76.1 284.88,8.51 285.42,8.51 285.73,8.21 285.94,8.21 CN7.9
USB30_TX3+_RTI: length 2.4
  TOP w0.14: U30.2 273.57,13.55 273.08,14.04 272.36,14.04 C475.2
USB30_TX3+_RTO: length 2.2
  TOP w0.14: C479.1 280.17,13.08 279.94,13.08 279.48,13.55 U30.27
USB30_TX3-: length 90.6
  TOP w0.14: v1(209.09,43.29) 209.09,43.3 U14.F11 ; v1(270.75,13.68) 270.82,13.75 271.47,13.75 C478.1
  IN4 w0.114: v1(270.75,13.68) 270.39,14.04 269.79,14.04 269.44,13.7 269.44,12.71 268.92,12.18 266.69,12.18 265.22,10.71 260.5,10.71 258.87,12.34 258.87,13.1 258.03,13.94 258.03,16.88 257.4,17.52 257.4,18.46 256.81,19.04 256.81,21.31 256.39,21.73 255.75,21.73 255.24,22.25 255.24,22.62 252.52,25.34 251.78,25.34 250.84,26.28 250.62,26.28 248.79,28.11 246.48,28.11 243.64,30.95 239.5,30.95 237.62,32.83 236.83,32.83 236.27,33.39 234.2,33.39 233.83,33.03 232.9,33.03 232.36,33.57 230.69,33.57 230.39,33.27 227.27,33.27 226.62,33.92 222.32,33.92 222.19,33.79 219.85,33.79 219.45,34.19 219.45,35.02 219.08,35.4 215.62,35.4 214.88,36.14 214.88,37.21 213.56,38.52 212.38,38.52 211.95,38.09 209.72,38.09 209.11,38.7 208,38.7 207,39.7 207,40.83 207.26,41.09 207.8,41.09 208.41,41.7 208.41,42.61 v1(209.09,43.29)
USB30_TX3-_C: length 1.7
  TOP w0.14: C486.2 280.94,12.64 281.08,12.64 281.49,12.23 281.82,12.23 R613.1
USB30_TX3-_R: length 10.2
  TOP w0.14: v1(283.58,9.06) 283.74,8.9 284.34,8.9 284.52,9.09 284.52,9.76 283.8,10.49 283.8,11.94 283.48,12.26 283.24,12.26 R613.2
  BOTTOM w0.14: v1(283.58,9.06) 283.72,8.93 284.38,8.93 D78.1 284.87,8.93 285.6,8.93 285.9,8.63 286.68,8.63 286.86,8.81 286.86,9.29 CN7.8
USB30_TX3-_RTI: length 2.4
  TOP w0.14: U30.3 273.62,13.15 272.98,13.8 272.28,13.8 C478.2
USB30_TX3-_RTO: length 2.2
  TOP w0.14: U30.26 279.28,13.15 279.77,12.67 280.16,12.67 C486.1
USB30_TX4+: length 80.3
  TOP w0.102: v1(210.98,46.05) 210.84,46.19 210.56,46.19 210.46,46.09 210.46,45.63 210.24,45.42 210.24,45.02 209.91,44.69 U14.C14
  TOP w0.14: C481.2 261.82,12.23 261.68,12.09 261.68,11.69 261.82,11.55 v1(261.98,11.55)
  IN4 w0.114: v1(210.98,46.05) 210.83,46.2 210.67,46.2 210.46,45.99 210.46,44.9 210.68,44.68 210.68,44.11 210.15,43.58 210.15,41.65 210.99,40.81 210.99,40.53 211.35,40.17 213.4,40.17 215.54,38.04 218.79,38.04 219.01,37.82 219.37,37.82 221.68,35.5 224.78,35.5 225.42,36.14 232.68,36.14 233.26,35.55 236.06,35.55 236.37,35.86 237.47,35.86 237.74,35.59 238.73,35.59 240.02,34.31 243,34.31 244.24,33.06 244.24,31.82 246.81,29.25 250.03,29.25 251.81,27.47 251.81,26.81 252.24,26.38 253.59,26.38 254.09,25.87 255.05,25.87 255.59,25.33 255.59,23.74 256.28,23.05 256.64,23.05 257.88,21.81 257.88,19.68 258.44,19.12 258.44,18.45 258.63,18.25 259.07,18.25 259.51,17.82 259.51,14.27 261.55,12.23 261.55,11.67 261.7,11.51 261.94,11.51 v1(261.98,11.55)
USB30_TX4-: length 80.3
  TOP w0.102: U14.B14 209.81,45.13 209.91,45.03 209.97,45.03 210.04,45.1 210.04,45.51 210.25,45.72 210.25,46.18 210.48,46.4 210.69,46.4 v1(210.99,46.7)
  TOP w0.14: C480.2 261.44,11.92 261.44,11.69 261.3,11.55 v1(261.15,11.55)
  IN4 w0.114: v1(210.99,46.7) 210.72,46.43 210.58,46.43 210.23,46.08 210.23,44.8 210.45,44.58 210.45,44.2 209.92,43.67 209.92,41.55 210.76,40.71 210.76,40.43 211.25,39.95 213.31,39.95 215.44,37.81 218.69,37.81 218.92,37.59 219.27,37.59 221.59,35.27 224.88,35.27 225.51,35.91 232.58,35.91 233.17,35.32 236.16,35.32 236.47,35.63 237.37,35.63 237.65,35.36 238.64,35.36 239.92,34.08 242.9,34.08 244.01,32.97 244.01,31.72 246.71,29.02 249.94,29.02 251.58,27.38 251.58,26.72 252.15,26.15 253.49,26.15 254,25.65 254.96,25.65 255.36,25.24 255.36,23.65 256.18,22.83 256.54,22.83 257.65,21.72 257.65,19.58 258.21,19.02 258.21,18.36 258.54,18.03 258.98,18.03 259.28,17.73 259.28,14.17 261.32,12.13 261.32,11.72 v1(261.15,11.55)
USB_AUX_SW_V1: length 2.6
  TOP w0.14: v1(247.4,22.76) 247.4,22.51 248.03,21.88 U23.3
  BOTTOM w0.14: v1(247.4,22.76) 247.71,22.76 TP115.1
USB_BC_ON: length 332.8
  TOP w0.14: v1(81.68,22.19) 81.68,24.41 82.11,24.84 82.11,25.19 81.44,25.86 80.85,25.86 80.33,26.38 80.33,30.51 81.55,31.73 81.8,31.73 82.26,32.19 82.41,32.19 83.43,33.22 U18.97 ; U26.4 278.25,17.59 277.53,16.87 v1(276.96,16.87) ; v1(20.42,44.44) 20.06,44.08 U11.4 ; U8.4 20.38,50.4 20.52,50.54 20.52,50.74 v1(20.29,50.97)
  IN1 w0.086: v1(81.68,22.19) 81.26,22.61 80.7,22.61 80.3,22.22 77.31,22.22 76.51,23.02 74.63,23.02 v1(74.58,22.96)
  IN2 w0.089: v1(20.29,50.97) 20.29,47.72 19.55,46.98 19.55,45.99 20.23,45.31 20.23,44.6 20.39,44.44 v1(20.42,44.44) 21.22,44.44 22.38,45.61 25.34,45.61 27.75,43.19 27.75,40.65 27.1,40 27.1,38.85 28.28,37.67 29.73,37.67 31.73,39.67 31.73,39.86 32.05,40.18 36.01,40.18 37.31,38.87 43.71,38.87 44.49,38.09 44.49,36.75 46.35,34.89 47.15,34.89 48.64,33.4 52.75,33.4 54.67,31.47 54.67,30.37 56.78,28.27 56.78,27.93 57.29,27.42 58.79,27.42 59.28,26.93 59.28,25.91 60.24,24.95 61.29,24.95 61.45,24.79 62.57,24.79 63.56,25.79 64.51,25.79 64.69,25.61 65.33,25.61 66.51,24.44 66.51,24.03 68.53,22 72.73,22 73.07,22.33 73.07,22.84 73.36,23.14 74.41,23.14 v1(74.58,22.96) ; v1(276.96,16.87) 277.18,16.66 277.18,14.42 276.49,13.73 272.74,13.73 272.16,13.15 272.16,12.69 271.38,11.9 270.52,11.9 270.12,12.3 266.64,12.3 264.99,10.66 260.15,10.66 259.84,10.96 258.46,10.96 257.97,10.47 257.09,10.47 256.88,10.68 256.23,10.68 255.63,10.07 253.59,10.07 252.7,10.96 246.09,10.96 245.25,10.12 241.89,10.12 240.1,11.91 231.34,11.91 230.82,11.39 226.52,11.39 225.2,10.07 219.5,10.07 218.08,11.49 212.29,11.49 211.82,11.02 210.44,11.02 209.75,10.32 207.94,10.32 207.21,11.05 202.58,11.05 201.65,10.12 198.11,10.12 195.33,12.9 195.33,13.41 192.77,15.97 191.96,15.97 187.58,20.35 180.01,20.35 176.73,23.63 176.73,26.32 175.56,27.5 169.04,27.5 168.64,27.1 168.23,27.1 166.88,25.75 165.51,25.75 165.01,26.25 152.71,26.25 152.05,25.59 149.05,25.59 148.73,25.27 141.45,25.27 140.79,24.6 133.78,24.6 130.75,21.57 125.5,21.57 123.4,19.46 116.39,19.46 114.78,21.07 114.78,23.34 113.76,24.36 112.1,24.36 111.47,24.99 100.17,24.99 99.95,25.21 98.06,25.21 97.39,24.54 95.98,24.54 95.28,23.84 93.89,23.84 92.01,21.96 89.7,21.96 89.33,21.58 88.23,21.58 87.86,21.96 84.35,21.96 84.29,22.01 81.86,22.01 v1(81.68,22.19)
USB_CC1: length 69
  TOP w0.254: CN4.A5 290.44,27.2 v1(290.34,27.3)
  TOP w0.508: C270.2 286.29,36.66 285.92,37.02 285.26,37.02 285.01,37.28 v1(284.37,37.28) ; v1(252.01,16.15) 252.01,16.57 R527.1 ; R505.1 v1(245.03,18.71)
  IN1 w0.508: v1(252.01,16.15) 252.01,16.61 251.32,17.3 248.54,17.3 247.13,18.71 v1(245.03,18.71)
  IN3 w0.508: v1(252.01,16.15) 252.01,16.53 254.86,19.37 254.86,22.27 255.59,23 257.93,23 260.01,25.09 267.51,25.09 269.03,26.61 270.33,26.61 271.9,28.19 273.76,28.19 275.14,29.56 275.94,29.56 278.02,31.65 278.02,35.12 279.01,36.11 279.01,36.59 279.7,37.28 v1(284.37,37.28)
  IN4 w0.508: v1(287.9,36.21) 289,35.12 289,34.66 290.24,33.42 290.24,31.91 289.48,31.15 289.48,28.16 v1(290.34,27.3)
USB_CC2: length 70.8
  TOP w0.381: v1(246.17,21.37) 245.9,21.37 245.75,21.52 R445.1
  TOP w0.508: v1(282.52,37.91) 283.07,37.91 283.98,38.83 285.57,38.83 285.95,38.45
  IN2 w0.508: CN4.B5 293.41,28.75 291.94,30.22 290.65,30.22 290.04,30.83 290.04,31.79 290.26,32.02 290.26,33.49 289.02,34.74 289.02,35.38 288.66,35.73 288.66,36.54 v1(288.18,37.02)
  IN3 w0.508: v1(246.17,21.37) 246.35,21.55 246.35,25.87 246.88,26.41 248.18,26.41 248.23,26.46 251.89,26.46 252.44,25.9 255.36,25.9 255.75,26.29 256.47,26.29 257.04,25.72 267.24,25.72 268.77,27.25 270.06,27.25 271.64,28.82 273.5,28.82 276.37,31.69 276.37,36.16 278.12,37.91 v1(282.52,37.91)
  BOTTOM w0.508: v1(246.17,21.37) 246.39,21.37 246.75,21.73 248.48,21.73 248.99,21.23 248.99,20.44 249.31,20.12 R1060.1
USB_CHARGE_ON: length 341.9
  TOP w0.14: v1(278.53,17.21) 278.8,16.94 U26.5 ; U8.5 v1(19.08,52.19) 19.5,52.6 v1(19.58,52.6) 20.08,52.6 R161.2 ; U11.5 17.84,45.14 17.98,45.28 18.17,45.28 18.43,45.03 18.83,45.03 v1(19.24,45.44) 19.32,45.51 19.57,45.51 R194.2 ; U18.96 84.03,33.42 82.52,31.91 82.38,31.91 81.91,31.45 81.67,31.45 80.61,30.39 80.61,27.09 v1(81.1,26.61)
  IN1 w0.086: v1(81.1,26.61) 81.1,26.56 82.31,25.34 82.85,25.34 83.15,25.65 83.99,25.65 84.37,25.26 84.37,25.14 85.49,24.01 85.49,20.24 v1(85.32,20.07)
  IN2 w0.089: v1(19.08,52.19) 19.56,51.71 19.56,48.89 19.24,48.57 v1(19.24,45.44) 19.24,44.52 20,43.77 20.81,43.77 22.46,45.41 25.26,45.41 27.56,43.11 27.56,40.73 26.9,40.08 26.9,39.65 26.48,39.23 26.48,37.91 26.92,37.48 29.8,37.48 31.92,39.59 31.92,39.78 32.13,39.99 35.93,39.99 37.23,38.68 43.63,38.68 44.23,38.09 44.23,36.74 46.27,34.7 47.07,34.7 48.56,33.21 52.67,33.21 54.48,31.4 54.48,30.29 56.59,28.19 56.59,27.02 57.06,26.54 57.74,26.54 58.11,26.17 58.11,25.79 58.35,25.55 59.09,25.55 59.88,24.76 61.21,24.76 61.37,24.6 62.29,24.6 63.15,23.75 64.85,23.75 67.25,21.35 70.1,21.35 70.56,21.81 72.81,21.81 73.26,22.25 73.26,22.74 73.47,22.95 73.86,22.95 74.28,22.53 74.73,22.53 75.63,23.43 76.12,23.43 77.22,24.54 78.38,24.54 78.97,25.13 79.91,25.13 81.1,26.31 v1(81.1,26.61) ; v1(278.53,17.21) 279.09,16.65 279.09,16.22 278.94,16.07 278.48,16.07 277.41,15 277.41,14.32 276.63,13.54 272.84,13.54 272.35,13.05 272.35,12.61 271.46,11.71 270.44,11.71 270.04,12.11 266.72,12.11 265.08,10.47 260.07,10.47 259.76,10.77 258.54,10.77 258.04,10.28 257.01,10.28 256.8,10.49 256.31,10.49 255.71,9.88 253.51,9.88 252.62,10.77 246.17,10.77 245.33,9.93 241.81,9.93 240.07,11.66 231.37,11.66 230.9,11.2 226.6,11.2 225.28,9.88 219.42,9.88 218.39,10.91 216.98,10.91 216.54,10.48 212.39,10.48 212.04,10.83 210.52,10.83 209.57,9.88 207,9.88 206.01,10.86 202.66,10.86 201.73,9.93 198.03,9.93 195.14,12.82 195.14,13.33 192.69,15.78 191.88,15.78 187.5,20.16 179.93,20.16 176.93,23.16 176.16,23.16 175.79,23.53 175.79,24.33 176.51,25.06 176.51,26.27 175.48,27.31 169.12,27.31 168.72,26.91 168.31,26.91 166.96,25.56 165.43,25.56 164.93,26.06 154.78,26.06 154.11,25.4 149.13,25.4 148.14,24.41 133.86,24.41 130.83,21.38 125.58,21.38 123.48,19.27 116.31,19.27 114.59,21 114.59,23.26 113.69,24.17 112.02,24.17 111.51,24.67 100.22,24.67 99.87,25.02 98.14,25.02 97.47,24.35 96.06,24.35 95.36,23.65 93.97,23.65 92.09,21.77 89.78,21.77 89.4,21.39 87.81,21.39 87.46,21.04 85.78,21.04 85.49,20.74 85.49,20.24 v1(85.32,20.07)
  BOTTOM w0.14: v1(278.53,17.21) 278.26,17.21 R1080.1
USB_CLT1: length 328.5
  TOP w0.14: v1(18.6,45.54) 18.49,45.66 17.59,45.66 17.34,45.4 U11.6 ; v1(18.43,52.26) 18.43,51.98 18.58,51.83 U8.6 ; U26.6 279.61,16.93 279.61,16.22 279.61,15.62 v1(279.6,15.61) ; v1(83.74,21.45) 82.24,22.95 82.24,23.79 82.79,24.34 82.79,25.21 83.91,26.33 83.91,26.43 84.1,26.62 U18.79
  IN1 w0.086: v1(73.69,22.55) 74.04,22.19 74.67,22.19 75.08,21.78 76.59,21.78 76.83,22.01 79.5,22.01 80.49,21.02 83.31,21.02 v1(83.74,21.45)
  IN2 w0.089: v1(279.6,15.61) 278.5,15.61 277.69,14.8 277.69,14.17 276.87,13.35 272.92,13.35 272.54,12.97 272.54,12.53 271.54,11.52 270.36,11.52 269.96,11.92 266.8,11.92 265.16,10.28 259.99,10.28 259.68,10.58 258.62,10.58 258.12,10.09 256.93,10.09 256.72,10.3 256.39,10.3 256.16,10.06 256.16,9.98 255.87,9.69 253.43,9.69 252.55,10.58 246.25,10.58 245.41,9.74 241.73,9.74 240.05,11.42 231.39,11.42 230.98,11.01 226.68,11.01 225.36,9.69 219.34,9.69 218.31,10.72 217.05,10.72 216.62,10.29 212.31,10.29 211.96,10.64 210.6,10.64 209.65,9.69 206.92,9.69 205.93,10.67 202.74,10.67 201.81,9.74 197.69,9.74 194.95,12.48 194.95,13.26 192.61,15.59 191.8,15.59 187.43,19.97 179.85,19.97 176.86,22.97 176.08,22.97 175.59,23.45 175.59,24.41 176.32,25.14 176.32,26.19 175.4,27.12 169.2,27.12 168.8,26.72 168.39,26.72 167.04,25.37 165.35,25.37 164.85,25.87 159.44,25.87 158.74,25.18 158.15,25.18 157.61,25.72 154.7,25.72 154.19,25.21 149.21,25.21 148.22,24.22 133.94,24.22 130.9,21.19 125.66,21.19 123.55,19.08 116.23,19.08 114.4,20.92 114.4,23.18 113.61,23.97 111.94,23.97 111.43,24.48 99.36,24.48 98.93,24.04 98.2,24.04 98.08,24.16 96.14,24.16 94.89,22.91 94.89,22.39 94.74,22.24 92.84,22.24 92.17,21.57 89.86,21.57 88.76,20.47 87.29,20.47 86.46,19.64 84.77,19.64 83.74,20.67 v1(83.74,21.45) ; v1(73.69,22.55) 73.69,22.36 72.95,21.62 70.64,21.62 70.18,21.16 66.53,21.16 66.23,21.46 64.58,21.46 64.28,21.76 64.28,21.94 64,22.22 63.42,22.22 61.94,23.69 61.46,23.69 61.26,23.89 60.48,23.89 59.01,25.36 58.27,25.36 57.92,25.71 57.92,26.1 57.67,26.35 56.99,26.35 56.4,26.94 56.4,28.11 54.29,30.21 54.29,31.32 52.59,33.02 47.96,33.02 47.32,33.66 46.65,33.66 45.13,35.17 45.13,35.57 44.04,36.66 44.04,38.01 43.56,38.49 37.11,38.49 35.82,39.78 32.19,39.78 32.11,39.7 32.11,39.51 29.88,37.29 26.13,37.29 25.36,38.06 22.81,38.06 20.34,40.52 20.34,43.16 18.6,44.89 v1(18.6,45.54) 19.03,45.97 19.03,48.63 19.37,48.97 19.37,50.5 18.43,51.44 v1(18.43,52.26)
USB_DSCH_CTL: length 343
  TOP w0.14: v1(90.27,26.33) 90.27,26.34 90.39,26.46 90.39,26.86 89.93,27.32 89.49,27.32 R395.2 ; R466.2 254.52,20.54 v1(254.19,20.87) 253.79,20.87 253.28,21.38 U23.15
  TOP w0.203: v1(109.92,137.05) 109.92,138.13 110.36,138.57 PR130.2
  IN1 w0.086: v1(93.29,17.16) 91.97,18.48 91.97,18.86 89.71,21.12 89.71,23.94 90.39,24.63 90.39,26.24 90.31,26.33 v1(90.27,26.33) ; v1(109.92,137.05) 109.91,137.04 109.91,135.85 114.38,131.38 114.38,106.99 112.75,105.36 112.34,105.36 110.81,103.83 110.81,103.16 110.2,102.55 110.2,85.61 106.5,81.91 106.5,78.28 104.93,76.71 104.93,73.25 106.34,71.84 106.34,64.48 105.45,63.6 v1(104.42,63.6)
  IN3 w0.089: v1(93.29,17.16) 93.47,17.34 95.34,17.34 95.58,17.1 99.05,17.1 99.25,16.9 100.53,16.9 101.57,17.94 101.57,20.21 104.87,23.52 110.77,23.52 111.27,23.02 114.45,23.02 115.4,22.07 115.4,21.46 117.88,18.98 131.74,18.98 134.25,21.49 144.33,21.49 144.68,21.85 148.56,21.85 151.16,19.25 158.57,19.25 159.8,18.01 165.68,18.01 166.35,18.69 172.72,18.69 173.75,17.66 174.09,17.66 176.67,15.08 178.38,15.08 180.41,17.1 185.18,17.1 188.51,13.77 188.51,12.27 189.43,11.35 190.8,11.35 191.49,12.05 194.9,12.05 195.48,11.48 197.17,11.48 199.38,9.27 203.87,9.27 204.51,9.9 205.89,9.9 206.53,9.27 223.81,9.27 226.03,11.48 232.71,11.48 236.2,14.98 237.89,14.98 238.65,14.22 242.11,14.22 243.48,15.59 244.8,15.59 245.26,16.04 245.26,16.4 245.48,16.63 246.17,16.63 249.03,19.49 252.23,19.49 253.61,20.87 v1(254.19,20.87)
  IN4 w0.086: v1(104.42,63.6) 104.42,62.57 103.94,62.09 103.94,58.79 104.23,58.51 104.23,57.51 104.65,57.1 104.65,56.4 103.94,55.69 102.94,55.69 102.4,55.15 102.4,50.91 100.76,49.27 100.76,43.96 99.99,43.2 99.99,39.88 98.58,38.46 96.81,38.46 96.19,39.09 91.82,39.09 91.41,39.5 89.83,39.5 88.52,40.81 87.52,40.81 v1(87.45,40.73)
  BOTTOM w0.14: v1(87.45,40.73) 87.45,40.23 87.77,39.91 88.81,39.91 89.53,39.18 89.53,38.97 90.98,37.52 91.3,37.52 92.73,36.09 92.73,33.54 92.12,32.93 90.95,32.93 90.72,32.7 90.72,32 91.36,31.36 91.36,30.31 90.61,29.56 90.61,26.93 90.39,26.71 90.39,26.46 90.27,26.34 v1(90.27,26.33)
USB_FET_EN_Q: length 9.2
  TOP w0.203: PQ12.2 104.62,145.02 104.95,144.69 104.95,143.92 104.74,143.72 PQ12.4 104.02,143.72 v1(103.09,144.64)
  BOTTOM w0.203: v1(107.39,142.99) 107.02,143.36 PR471.2 106.33,143.58 PC329.1 105.91,144.2 105.9,144.19 PR470.1 104.62,144.19 104.46,144.03 103.7,144.03 v1(103.09,144.64)
USB_FET_EN_R: length 2.6
  BOTTOM w0.203: PR471.1 105.17,143.36 104.92,143.1 v1(104.92,142.87) 105.15,142.65 105.82,142.65 PQ43.3
USB_I2C_SCL: length 399.6
  TOP w0.14: v1(97.09,154.52) 97.64,154.52 PR92.2 ; R435.2 255.86,23.49 255.86,23.88 v1(256.25,24.27) ; R573.2 252.29,14.63 252.61,14.63 v1(252.7,14.55) 253.11,14.13 Q47.1
  IN1 w0.086: v1(97.09,154.52) 97.28,154.33 97.58,154.33 102.15,149.75 102.15,146.02 102.84,145.33 104.13,145.33 106.61,142.85 106.61,138.67 114.04,131.24 114.04,107.97 112.09,106.02 112.09,105.6 110.47,103.97 110.47,103.3 109.84,102.67 109.84,95.71 108.94,94.82 108.94,94.49 108.25,93.8 108.25,93.37 105.78,90.9 105.78,90.01 106.58,89.21 106.58,88.12 v1(106.82,87.88) 106.54,87.6 106.54,87.47 106.27,87.19 99.15,87.19 98.9,87.44 88.52,87.44 81.81,80.73 59.61,80.73 58.39,81.96 58.39,83.08 48.36,93.11 47.58,93.11 46.54,94.14 46.54,98.67 46.76,98.89 46.76,99.33 46.93,99.5 46.93,100.73 46.52,101.13 44.78,101.13 44.36,101.55 44.36,102.82 43.8,103.38 43.8,106.51 43.15,107.16 42.72,107.16 42.23,106.67 38.06,106.67 37.06,105.67 32.57,105.67 32.38,105.47 31.96,105.47 31.8,105.31 31.8,104.65 31.54,104.39 31.4,104.39 v1(31.08,104.07) ; v1(256.25,24.27) 256.23,24.27 256.16,24.21 256.04,24.21 255.53,24.72 255.53,25.68 255.39,25.82 255.39,26.94 255.1,27.23 254.24,27.23 253.76,27.7 251.38,27.7 250.68,28.4 246.36,28.4 243.62,31.14 242.2,31.14 241.38,31.96 241.38,33.38 241.96,33.96 241.96,35.74 242.7,36.48 242.7,37.06 241.67,38.09 241.67,40.68 241.34,41.01 241.34,42.76 240.76,43.35 240.76,44.9 239.67,45.99 239.67,48.4 237.04,51.03 237.04,51.17 234.65,53.56 229.45,53.56 225.05,57.97 225.05,58.77 223.68,60.14 219.02,60.14 218.61,60.54 215.99,60.54 215.88,60.66 214.71,60.66 214.51,60.86 212.11,60.86 211.68,61.29 206.38,61.29 204.48,63.2 197.69,63.2 196.84,62.35 195.75,62.35 195.27,62.83 192.98,62.83 189.59,66.22 187.41,66.22 182.9,61.71 181.75,61.71 181.46,61.42 v1(181.24,61.42)
  IN2 w0.089: v1(256.25,24.27) 256.25,24.17 256.06,23.98 254.16,23.98 253.09,22.92 253.09,14.94 v1(252.7,14.55)
  IN4 w0.086: v1(106.82,87.88) 106.6,87.65 106.6,87.34 115.51,78.43 164.78,78.43 178.31,64.9 178.31,64.59 178.68,64.22 178.68,63.9 180.14,62.44 180.14,61.78 180.5,61.42 v1(181.24,61.42)
  BOTTOM w0.14: v1(31.08,104.07) 30.79,104.37 30.04,104.37 29.32,103.65 28.64,103.65 28.58,103.71 Q63.6 28.02,101.87 RG134.2 ; v1(256.25,24.27) 255.82,24.27 255.65,24.44 255.65,24.87 255.17,25.35 254.09,25.35 R959.2 ; R1133.2 252.7,14.45 v1(252.7,14.55) 252.7,15.43 253.58,16.31 R1109.1
USB_I2C_SCL_3V3OR1V8: length 58.8
  TOP w0.14: R485.2 256.81,19.47 256.03,18.69 256.03,17.28 R529.2 255.54,16.55 255.06,16.07 v1(255.06,16.02) 254.93,16.15 253.49,16.15 253.11,15.77 Q47.6 ; R304.2 v1(255.79,33.96) ; R269.2 v1(281.21,38.55)
  IN2 w0.089: v1(255.06,16.02) 255.42,16.37 255.42,18.85 254.6,19.67 254.6,21.79 255.97,23.16 256.61,23.16 256.84,23.38 256.84,24.45 256.62,24.67 256.62,25.84 255.62,26.84 255.62,32.07 256.32,32.77 256.32,33.43 v1(255.79,33.96) 256.74,34.9 256.74,36.21 260.15,39.63 269.48,39.63 270.15,38.95 280.28,38.95 280.69,38.55 v1(281.21,38.55)
  BOTTOM w0.14: R1109.2 254.58,16.5 v1(255.06,16.02)
USB_I2C_SDA: length 404
  TOP w0.14: v1(97.1,153.81) 97.63,153.81 PR95.2 ; R448.2 255.3,22.05 255.77,22.52 255.77,22.98 v1(256.41,23.61) ; R564.2 252.4,15.05 252.85,15.05 v1(253.35,14.56) 253.51,14.39 254.15,14.39 254.55,14.8 254.55,15.43 Q47.4
  IN1 w0.086: v1(181.69,60.9) 181.69,61.34 181.84,61.5 182.99,61.5 187.49,66.01 189.51,66.01 192.89,62.62 195.18,62.62 195.66,62.13 196.93,62.13 197.78,62.98 204.39,62.98 206.3,61.08 211.59,61.08 212.02,60.65 214.42,60.65 214.63,60.44 215.79,60.44 215.91,60.33 218.52,60.33 218.93,59.92 223.59,59.92 224.83,58.69 224.83,57.88 229.36,53.35 234.56,53.35 236.82,51.09 236.82,50.95 239.45,48.31 239.45,45.9 240.55,44.81 240.55,43.26 241.13,42.68 241.13,40.92 241.46,40.59 241.46,38 242.49,36.97 242.49,36.57 241.75,35.83 241.75,34.05 241.17,33.47 241.17,31.87 242.11,30.93 243.53,30.93 246.27,28.19 250.59,28.19 251.29,27.49 253.68,27.49 254.15,27.02 255.01,27.02 255.18,26.85 255.18,25.73 255.31,25.59 255.31,24.63 256.33,23.61 v1(256.41,23.61) ; v1(31.08,104.73) 31.2,104.61 31.45,104.61 31.58,104.73 31.58,105.4 31.87,105.69 32.29,105.69 32.48,105.88 36.98,105.88 37.97,106.88 42.14,106.88 42.63,107.37 43.24,107.37 44.01,106.59 44.01,103.47 44.57,102.91 44.57,101.64 44.87,101.35 46.61,101.35 47.14,100.82 47.14,99.41 46.98,99.25 46.98,98.81 46.75,98.58 46.75,94.23 47.67,93.32 48.45,93.32 58.6,83.17 58.6,82.05 59.7,80.95 81.72,80.95 88.43,87.66 98.99,87.66 99.24,87.4 106.18,87.4 106.33,87.56 106.33,87.71 v1(106.14,87.9) 106.36,88.13 106.36,89.13 105.57,89.92 105.57,90.99 108.04,93.46 108.04,93.89 108.73,94.58 108.73,94.91 109.62,95.8 109.62,102.76 110.26,103.39 110.26,104.06 111.88,105.69 111.88,106.11 113.82,108.06 113.82,131.16 106.4,138.58 106.4,142.76 104.04,145.12 102.75,145.12 101.94,145.93 101.94,149.67 97.49,154.11 97.4,154.11 v1(97.1,153.81)
  IN2 w0.089: v1(256.41,23.61) 256.25,23.77 254.25,23.77 253.31,22.83 253.31,14.6 v1(253.35,14.56)
  IN4 w0.086: v1(106.14,87.9) 106.38,87.66 106.38,87.26 115.42,78.21 164.69,78.21 178.1,64.81 178.1,64.5 178.47,64.13 178.47,63.81 179.93,62.35 179.93,61.69 180.71,60.9 v1(181.69,60.9)
  BOTTOM w0.14: R975.2 254.51,25.09 255.06,25.09 255.39,24.76 255.39,24.33 256.1,23.61 v1(256.41,23.61) ; RG129.2 25,105.1 26.03,105.1 Q63.3 27.24,105.01 27.68,105.45 29.13,105.45 29.96,104.63 30.98,104.63 v1(31.08,104.73) ; R1114.1 253.31,15.54 252.96,15.19 252.96,14.94 v1(253.35,14.56) 253.35,14.53 254.14,13.74 R1134.2
