# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_S5: length 740.6
  TOP w0.14: PU21.4 89.02,58.27 89.33,58.58 v1(89.49,58.58) 89.65,58.42 PR192.1 ; v1(31.58,58.58) 31.52,58.58 31.22,58.27 PU15.4 ; PU19.4 69.96,58.27 70.19,58.5 v1(70.19,58.58) 70.35,58.42 PR190.1 ; PU18.4 60.31,58.27 60.54,58.5 v1(60.54,58.58) 60.69,58.42 PR189.1 ; PR187.1 41.39,58.42 v1(41.23,58.58) 41.23,58.5 41,58.27 PU16.4 ; PU20.4 79.61,58.27 79.84,58.5 v1(79.84,58.58) 80,58.42 PR191.1 ; PU17.4 50.66,58.27 50.89,58.5 v1(50.89,58.58) 51.04,58.42 PR188.1
  TOP w0.203: PR56.2 PR61.2 181.63,162.7 v1(181.37,162.45) ; v1(29.63,46.77) 29.63,46.9 29.43,47.11 PR301.1 ; v1(107.68,91.84) 107.68,91.8 107.85,91.64 PR139.1 ; PR86.2 v1(116.82,156.35) ; v1(151.96,26.69) 151.96,26.89 152.19,27.11 PR375.1 ; PR268.1 42.66,51.33 v1(42.66,51.88) 43.19,52.41 44.09,52.41 44.34,52.16 44.34,51.75 PR264.1 44.85,52.27 45.4,52.82 46.12,52.82 PR256.2
  TOP w0.254: PR2.1 9.97,173.4 10.28,173.4 v1(10.46,173.22) ; PU14.4 21.55,58.27 21.86,58.59 v1(21.86,59.35)
  TOP w0.381: v1(21.86,59.35) 21.9,59.31 PR177.1
  TOP w0.508: v1(155.95,166.69) 155.7,166.95 PR38.2 ; PU10.1 91.58,95.18 91.3,95.45 PC114.1 91.56,96.11 v1(91.98,96.11) ; v1(31.58,58.58) 32.07,58.58 PR186.1 ; PR394.1 151.98,26.67 v1(151.96,26.69) ; PR11.1 17.49,171.9 v1(16.73,172.66) ; v1(174.95,158.44) 174.95,156.61 173.99,155.65 173.99,153.84 174.69,153.13 174.69,150.29 175.16,149.83 v1(175.16,147.62) ; v1(166.92,167.2) 166.74,167.02 PR37.2 ; v1(144.72,167.71) 144.56,167.55 PR36.2 ; v1(46.99,42.31) 46.88,42.2 46.88,42.1 PR331.1 ; v1(133.42,167.2) 133.92,167.2 134.2,166.92 137.05,166.92 137.31,166.67 137.31,166.46 137.03,166.18 PR39.2
  TOP w1.524: 180.97,79.39 180.51,78.93 180.51,73.88 185.95,68.44
  IN1 w0.508: 102.28,79.19 100.22,81.25 100.22,85.26 101.39,86.43 106.98,86.43 107.39,86.83 108.36,86.83 109.15,87.62 109.15,90.59 108.7,91.03 108.45,91.03 107.68,91.8 v1(107.68,91.84) ; v1(10.46,173.22) 11.02,172.66 v1(16.73,172.66)
  IN1 w0.762: v1(144.72,167.71) 144.43,168 138.41,168 137.61,167.2 v1(133.42,167.2) ; 87.78,27.26 88.93,27.26 89.15,27.47 91.46,27.47 92.93,26 92.93,23.59
  IN2 w0.508: v1(89.49,58.58) 88.66,59.41 82.57,59.41 81.74,58.58 v1(79.84,58.58) 79.1,58.58 78.3,59.37 73.09,59.37 72.3,58.58 v1(70.19,58.58) 69.54,58.58 68.72,59.4 63.55,59.4 62.73,58.58 v1(60.54,58.58) ; v1(116.82,156.35) 117.47,156.35 123.51,162.4 124.98,162.4 127.97,165.4 131.62,165.4 v1(133.42,167.2) ; v1(174.95,158.44) 173.88,158.44 171.52,160.8 171.52,165.42 170.45,166.49 167.63,166.49 v1(166.92,167.2) 165.78,168.34 157.73,168.34 156.08,166.69 v1(155.95,166.69)
  IN3 w0.508: v1(91.98,96.11) 91.98,95.87 93.02,94.83 99.64,94.83 100.11,95.3 105.02,95.3 107.65,92.67 107.65,91.88 v1(107.68,91.84) ; v1(135.74,27.28) 135.74,26.22 136.26,25.7 138.75,25.7 139.64,26.58 141.6,26.58 142.16,26.03 147.75,26.03 148.82,27.1 151.55,27.1 v1(151.96,26.69) ; v1(10.46,173.22) 10.46,171.93 8.05,169.51 8.05,167.7 6.5,166.15 6.5,109.79 8.12,108.18 8.12,103.96 10.59,101.49 11.36,101.49 14.7,98.15 14.7,91.82 13.57,90.69 13.57,89.97 14.22,89.32 14.22,87.4 10.58,83.76 8.43,83.76 7.59,82.92 7.59,81.22 6.55,80.18 6.55,79.85 6.11,79.42 6.11,56.35 6.7,55.77 v1(7.84,55.77)
  IN4 w0.305: v1(29.63,46.77) 29.63,46.49 30.18,45.95 31.77,45.95 35.22,42.5 35.22,41.92 35.98,41.16 42.54,41.16 43.61,42.23 46.91,42.23 v1(46.99,42.31)
  IN4 w0.508: v1(155.95,166.69) 155,167.64 151.9,167.64 151.43,167.17 146.86,167.17 146.32,167.71 v1(144.72,167.71) ; v1(175.16,147.62) 175.16,145.16 173.91,143.91 173.91,112.21 176.75,109.37 177.35,109.37 177.86,108.86 177.86,107.73 178.37,107.22 179.88,107.22 181.88,105.22 181.88,90.52 184.55,87.85 184.55,84.12 185.06,83.61 v1(185.75,83.61) ; v1(42.66,51.88) 42.66,52.38 40.68,54.36 40.68,54.37 40.28,54.78 40.28,57.95 40.9,58.58 v1(41.23,58.58) ; v1(22.47,55.97) 21.98,55.48 20.28,55.48 20.17,55.59 15.58,55.59 14.99,55.01 12.12,55.01 12.12,55.01 11.62,55.01 11.61,55.01 10.82,54.21 9.04,54.21 7.84,55.41 v1(7.84,55.77) ; v1(41.23,58.58) 40.46,59.35 34.94,59.35 34.17,58.58 v1(31.58,58.58) 30.93,59.22 27.32,59.22 27.04,59.5 22.02,59.5 v1(21.86,59.35) ; v1(41.23,58.58) 43.69,58.58 44.47,59.35 50.11,59.35 v1(50.89,58.58) 53.6,58.58 54.37,59.35 59.76,59.35 v1(60.54,58.58) 63.38,58.58 64.15,59.35 69.42,59.35 v1(70.19,58.58) 72.9,58.58 73.68,59.35 79.07,59.35 v1(79.84,58.58) 82.3,58.58 83.13,59.4 88.67,59.4 v1(89.49,58.58)
  BOTTOM w0.14: PC372.1 79.6,58.82 v1(79.84,58.58) ; PC376.1 40.99,58.82 v1(41.23,58.58) ; PC374.1 60.3,58.82 v1(60.54,58.58) ; v1(50.89,58.58) 50.65,58.82 PC375.1 ; v1(70.19,58.58) 69.95,58.82 PC373.1
  BOTTOM w0.203: v1(42.66,51.88) 42.11,51.33 42.11,48.94 42.49,48.56 PR519.1 PR522.1 PR524.1 PR526.1 PR528.1 PR533.1 PR537.1 PR539.1 43.05,42.86 43.98,41.93 46.25,41.93 46.5,42.18 46.86,42.18 v1(46.99,42.31)
  BOTTOM w0.254: PR427.1 10.08,173.49 10.36,173.22 v1(10.46,173.22)
  BOTTOM w0.508: 97.1,38.5 97.44,38.16 98.91,38.16 99.57,37.5 99.57,37.04 101.75,34.86 111.53,34.86 114.28,32.11 114.28,31.27 114.9,30.65 133.04,30.65 135.74,27.95 v1(135.74,27.28) ; PC377.1 31.34,58.82 v1(31.58,58.58) ; PC371.1 88.79,58.82 89.03,58.58 v1(89.49,58.58) 89.49,59.34 90.57,60.42 91.2,60.42 92.09,61.31 92.09,61.61 92.6,62.12 94.03,62.12 94.18,61.97 94.61,61.97 94.9,61.68 95.86,61.68 96.36,61.18 96.36,59.14 96.96,58.55 100.84,58.55 101.1,58.81 v1(103.06,58.81) ; v1(21.86,59.35) 21.86,60.24 22.49,60.87 PC378.1 23.17,60.87 23.73,60.31 23.73,60.28 23.77,60.24 23.77,59.16 23.8,59.12 23.8,58.59 23.77,58.55 23.77,57.78 22.86,56.86 22.86,56.33 22.49,55.97 v1(22.47,55.97) ; v1(181.37,162.45) 181.07,162.45 180.43,161.81 180.43,160.81 177.55,157.93 175.46,157.93 v1(174.95,158.44) 174.85,158.54 PR458.2
  BOTTOM w1.524: 112.54,74.33 163.79,74.33 167.27,77.81 173.78,77.81 181.88,85.92 184.04,85.92
  vias: v1(92.29,20.32) v1(93.82,22.7) v1(94.48,22.7) v1(96.9,39.27) v1(104.21,79.87) v1(109.8,73.59) v1(185.77,82.73) v1(187.12,69.41) v1(187.3,68.35) v1(187.85,68) v1(188.38,68.37) v1(212.55,61.61) v1(212.9,62.19) v1(213.23,61.61) v3(86.45,27.25) v3(86.45,26.48) v3(87.2,27.26) v3(97.45,39.72) v3(103.11,59.52) v3(103.54,79.67) v3(109.63,74.27)
+5V_S5_TYPEC: length 3.7
  TOP w0.203: C257.1 253.98,36.78 253.56,36.37 U13.25
  TOP w0.508: v1(255.64,35.75) 254.62,36.78 C257.1
  vias: v1(238.25,28.13) v1(238.91,28.11) v1(240.71,29.68) v1(241.75,28.01) v1(242.46,31.61) v1(242.49,29.91) v1(242.51,28.01) v1(243.12,31.61) v1(243.15,29.91) v1(244.75,13.94) v1(245.43,13.88) v1(250.46,30.19) v1(250.84,30.8) v1(251.12,30.19) v1(251.5,30.73)
+5VA:
  vias: v1(25.55,31.79)
+5VPCU: length 193.7
  TOP w0.203: R182.1 R183.1 17.5,46.62 18.08,46.04 19.88,46.04 19.99,45.93 20.4,45.93 20.75,46.28 20.75,46.65 20.54,46.85 20.49,46.85 v1(19.67,47.68) ; v1(14.14,48.56) 13.84,48.86 13.84,49.13 13.07,49.9 13.07,50.28 R165.1 14.22,50.69 14.42,50.49 R166.1
  TOP w0.254: v1(162.86,19.98) 162.93,20.05 PU29.7
  TOP w0.508: PC275.1 162.86,19.7 v1(162.86,19.98) ; v1(98.7,25.62) 98.11,25.04 PR395.2
  IN1 w0.508: v1(29.28,160.09) 28.97,160.09 28.62,160.44 25.57,160.44 24.43,161.59 22.29,161.59 18.21,165.68 12.24,165.68 11.22,166.69 v1(9.54,166.69) ; v1(15.6,47.93) 15.8,47.93 16.33,48.45 16.33,50.79 15.31,51.81 15.31,53.59 13.83,55.06 11.57,55.06 10.57,56.06 10.57,58.14 10.02,58.69 9.2,58.69 8.68,59.22 8.68,60.54 9.8,61.66 9.8,63.8 7.16,66.43 7.16,72.54 8.48,73.85 8.48,75.43 9.29,76.24 9.29,78.9 10.47,80.08 10.47,85.03 13.34,87.9 v1(14.96,87.9)
  IN2 w0.508: v1(14.14,48.56) 14.76,47.93 v1(15.6,47.93)
  IN3 w0.508: v1(162.86,19.98) 162.86,21.11 163.39,21.65 164.57,21.65 165.08,22.15 v1(165.08,25.08) ; v1(14.96,87.9) 15.11,88.05 15.11,91.18 15.9,91.97 16.46,91.97 16.97,92.48 16.97,93.65 15.5,95.12 15.5,98.75 15.16,99.1 15.16,102.35 13.68,103.83 11.25,103.83 9.11,105.97 9.11,108.63 7.49,110.25 7.49,165.35 8.83,166.69 v1(9.54,166.69)
  BOTTOM w0.203: PR563.1 139.7,25.9 139.77,25.98 v1(140.71,25.98) 140.85,25.84 PR564.1
  BOTTOM w0.508: v1(14.96,87.9) 14.41,88.45 14.41,90.04 14.88,90.5 14.88,91.08 15.18,91.38 15.18,91.42 15.71,91.95 16.49,91.95 16.66,92.12 17.63,92.12 PR479.2 ; v1(78.56,22.67) 78.89,23 79,23 PR566.2
  vias: v1(18.75,41.83) v1(18.78,41.19) v1(19.7,48.33) v1(238.65,24.4) v1(238.83,25.04) v1(239.44,24.43) v1(241.78,24.43) v1(242.33,24.96) v1(242.46,24.17) v1(277.13,21.12) v1(277.16,20.46) v1(277.36,19.78) v3(74.64,24.02) v3(74.77,24.78) v3(75.41,23.92) v3(75.53,24.73) v3(76.09,24.22) v3(80.9,24.49) v3(129.25,23.84) v3(129.45,25.97) v3(129.43,24.64) v3(129.43,23.12) v3(129.82,26.63) v3(129.81,25.31) v3(130,23.84) v3(130.18,23.11) v3(130.23,25.96) v3(130.22,24.63) v3(130.57,26.63) v3(130.58,25.28) v3(130.75,23.85) v3(130.98,25.97) v3(130.97,24.64) v3(131.32,26.64) v3(131.33,25.29) v3(131.74,25.97) v3(131.73,24.64) v3(132.09,26.64) v3(132.09,25.29) v3(136.58,27.19) v3(136.62,26.39) v3(137.34,27.19) v3(137.37,26.4)
+12V_FAN: length 145.9
  TOP w0.254: v1(240.96,56.18) 240.83,56.04 PR199.2
  IN2 w1.016: 181.28,79.65 181.28,72.3 186.69,66.89 189.71,66.89 192.93,63.67 198.93,63.67 199.82,64.56 203.37,64.56
  IN3 w1.016: 115.16,71.03 115.16,69.81 114.14,68.79 108.03,68.79 104.57,65.33 103.76,65.33 102.1,63.67 102.1,62.68 100.12,60.7 100.12,59.05
  IN4 w0.508: v1(240.96,56.18) 237.89,56.18 235.1,53.38 229.46,53.38 v1(223.61,59.22)
  BOTTOM w1.016: 180.92,79.42 180.92,78.88 177.49,75.45 168.02,75.45 164.46,71.9 115.77,71.9
  vias: v1(6.8,59.58) v1(6.8,58.92) v1(21.66,56.11) v1(22.14,56.58) v1(61.21,54.55) v1(87.18,47.13) v1(87.71,47.51) v1(113.68,71.47) v1(114.06,72) v1(182.29,80.56) v1(182.77,81.02) v1(203.98,62.42) v1(204.56,62.02) v1(208.59,56.29) v1(217.27,59.12) v1(217.92,59.12)
+12V_FAN1:
  vias: v1(206.58,56.24)
+A3VPCU: length 3.3
  TOP w0.14: L14.2 87.69,24.93 87.03,24.27 C392.1 86.23,24.27 85.88,24.62 U18.74
+V3.3DX_ADO: length 4.3
  TOP w0.203: U14.BB14 210.09,25.39 v1(210.21,25.39)
  BOTTOM w0.102: v1(209.19,23.54) 209.22,23.56 R977.2
  BOTTOM w0.203: v1(210.21,25.39) 209.86,25.74 C867.1 209.45,25.74 209.45,25.12 209.22,24.88 R977.2
+VCC3P3_LC: length 11.7
  TOP w0.203: v2(261.4,54.05) 261.74,53.71 U7.R6
  IN4 w0.254: v2(261.4,54.05) 261.24,54.05 259.91,52.72 258.63,52.72 258.26,53.1 258.26,56.51 v1(257.83,56.94)
  BOTTOM w0.254: R753.1 R754.1 R755.1 R756.1 258.06,56.71 v1(257.83,56.94) ; C718.2 261.14,53.79 v2(261.4,54.05)
+VCC3P3_S0: length 2.4
  TOP w0.203: U7.R13 261.74,50.4 v2(261.43,50.09)
  TOP w0.254: R134.2 257.01,58.33 v1(256.3,58.33)
  BOTTOM w0.254: v1(264.93,57.71) 265.22,57.42 R744.2
  vias: v1(251.11,56.5) v1(251.86,56.3) v1(271.35,59.2) v1(272,59.2) v1(272.65,59.2) v2(261.39,50.75)
+VCC3P3_SX: length 7.7
  TOP w0.203: U7.F8 265.64,53.05 v2(265.95,53.36)
  TOP w0.254: v1(258.18,58.24) 258.13,58.29 R135.2
  BOTTOM w0.203: C720.2 266.14,53.17 v2(265.95,53.36)
  BOTTOM w0.254: v1(264.17,57.07) 264.17,56.48 264.42,56.22 R760.2 ; v1(260.75,59.36) 260.92,59.2 261.32,59.2 261.6,58.92 R132.1 262.07,58.55 262.11,58.6 R133.1 ; R803.1 280.99,48.05 v1(280.8,48.24) ; v1(270.71,59.2) 269.85,59.2 269.58,58.93 269.58,58.7 R732.2
  vias: v1(254.42,56.39) v1(254.73,57.73) v1(265.55,59.2) v1(274.31,53.66) v1(274.31,53)
+VCC_CORE: length 1.7
  TOP w0.508: v1(135.91,137) 136.56,137.65 R32.2
  vias: v1(127.28,114.73) v1(127.29,114.04) v1(128.69,122.03) v1(128.73,122.74) v1(128.89,130.54) v1(128.88,129.89) v1(128.88,129.24) v1(128.88,128.58) v1(129.18,113.93) v1(129.87,113.95) v1(130.46,130.54) v1(130.46,129.89) v1(132.04,131.19) v1(132.04,130.54) v1(132.03,129.89) v1(132.43,114.72) v1(132.43,114) v1(133.13,149.59) v1(133.49,124.77) v1(133.42,122.01) v1(133.57,123.67) v1(133.54,122.82) v1(133.61,130.54) v1(133.61,129.89) v1(133.61,128.61) v1(133.61,127.94) v1(133.61,127.29) v1(133.82,121.11) v1(133.81,120.24) v1(133.81,119.42) v1(133.81,118.61) v1(133.87,117.79) v1(133.87,117.07) v1(133.9,116.03) v1(134.11,122.01) v1(134.24,122.82) v1(134.21,114.65) v1(134.21,113.99) v1(134.51,121.11) v1(134.5,120.24) v1(134.5,119.42) v1(134.5,118.61) v1(134.56,117.79) v1(134.77,122.02) v1(134.92,124.37) v1(134.93,123.71) v1(134.9,122.83) v1(135.18,130.54) v1(135.18,129.24) v1(135.97,114.56) v1(135.96,113.91) v1(136.76,131.19) v1(136.76,130.54) v1(136.76,129.89) v1(136.76,129.24) v1(137.55,131.19) v1(137.55,130.54) v1(137.54,129.89) v1(137.54,129.24) v1(137.54,127.28) v1(137.54,126.63) v1(138.33,127.28) v1(139.58,114.6) v1(139.55,113.95) v1(139.91,130.54) v1(139.91,129.89) v1(139.91,129.24) v1(140.68,127.94) v1(140.68,127.28) v1(141.17,122.16) v1(141.2,122.86) v1(141.26,121.36) v1(141.26,120.52) v1(141.27,119.67) v1(141.27,118.85) v1(141.27,118.03) v1(141.33,123.65) v1(141.36,116.93) v1(141.38,116.19) v1(141.39,115.39) v1(141.48,131.19) v1(141.48,130.54) v1(141.48,129.89) v1(141.48,129.24) v1(141.48,127.94) v1(141.49,127.28) v1(141.42,114.62) v1(141.42,113.96) v1(141.89,122.86) v1(141.87,122.16) v1(141.96,121.36) v1(141.96,120.52) v1(141.97,119.67) v1(141.97,118.85) v1(141.97,118.03) v1(142.03,123.65) v1(142.27,131.19) v1(142.27,130.54) v1(142.27,129.89) v1(142.27,129.24) v1(142.26,127.94) v1(142.25,127.29) v1(142.27,126.64) v1(142.55,122.88) v1(142.53,122.17) v1(142.69,123.66) v1(143.05,129.9) v1(143.04,129.24) v1(143.2,114.7) v1(143.23,114.01) v1(143.84,131.19) v1(143.84,130.54) v1(143.84,129.89) v1(143.84,129.24) v1(143.84,128.59) v1(145.94,123.61) v1(145.94,119.68) v1(145.94,118.79) v1(146.7,123.61) v1(146.7,119.68) v1(146.7,118.79) v1(147.47,123.61) v1(147.47,119.68) v1(147.47,118.79) v1(147.78,130.54) v1(147.78,129.89) v1(147.78,127.29) v1(148.23,123.61) v1(148.23,119.68) v1(148.23,118.79) v1(148.57,127.94) v1(148.57,127.29) v1(148.74,122.85) v1(148.74,122.09) v1(148.74,121.33) v1(148.74,120.56) v1(148.74,118.15) v1(148.74,117.39) v1(148.74,116.63) v1(148.74,115.87) v1(149.5,122.85) v1(149.5,122.09) v1(149.5,121.33) v1(149.5,120.56) v1(149.5,118.15) v1(149.5,117.39) v1(149.5,116.63) v1(149.5,115.87) v1(150.14,130.54) v1(150.14,129.89) v1(150.93,127.94) v1(150.93,127.29) v1(155.61,131.88) v3(127.5,150.16) v3(127.5,149.39) v3(127.5,148.63) v3(127.5,147.87) v3(127.98,147.01) v3(127.98,146.24) v3(127.98,145.48) v3(128.26,150.16) v3(128.26,149.39) v3(128.26,148.63) v3(128.26,147.87) v3(128.75,147.01) v3(128.75,146.24) v3(128.75,145.48) v3(129.43,143.76) v3(129.51,147.01) v3(129.51,146.24) v3(129.51,145.48) v3(129.85,133.13) v3(129.85,132.34) v3(130.69,133.15) v3(130.69,132.37) v3(131.53,133.15) v3(131.53,132.37) v3(132.42,133.05) v3(132.42,132.27) v3(133.21,133.05) v3(133.21,132.27) v3(133.99,133.05) v3(133.99,132.27) v3(134.18,142.89) v3(134.18,142.13) v3(134.18,141.37) v3(134.18,140.61) v3(134.78,133.03) v3(134.78,132.24) v3(134.94,142.89) v3(134.94,142.13) v3(134.94,141.37) v3(134.94,140.61) v3(135.54,133.03) v3(135.54,132.24) v3(135.71,142.89) v3(135.71,142.13) v3(135.71,141.37) v3(135.71,140.61) v3(136.33,133.03) v3(136.33,132.24) v3(137.09,133.03) v3(137.09,132.24) v3(137.88,133.03) v3(137.88,132.24) v3(138.3,150.18) v3(138.3,149.42) v3(138.3,148.66) v3(138.3,147.9) v3(139.06,150.18) v3(139.06,149.42) v3(139.06,148.66) v3(139.06,147.9) v3(139.13,146.93) v3(139.13,146.17) v3(139.13,145.41) v3(139.34,142.84) v3(139.34,142.08) v3(139.34,141.32) v3(139.34,140.55) v3(139.9,146.93) v3(139.9,146.17) v3(139.9,145.41) v3(139.92,139.37) v3(140.1,142.84) v3(140.1,142.08) v3(140.1,141.32) v3(140.1,140.55) v3(140.66,146.93) v3(140.66,146.17) v3(140.66,145.41) v3(140.68,139.37) v3(140.86,142.84) v3(140.86,142.08) v3(140.86,141.32) v3(140.86,140.55) v3(141.44,139.37) v3(141.49,132.16) v3(141.59,133.03) v3(142.2,139.37) v3(142.28,132.16) v3(142.38,133.03) v3(143.04,132.16) v3(143.14,133.03) v3(143.82,132.14) v3(143.93,133) v3(144.59,132.14) v3(144.69,133) v3(145.64,143.3) v3(149.68,149.37) v3(149.68,148.61) v3(149.68,147.84) v3(149.68,147.08) v3(150.29,146.32) v3(150.29,145.56) v3(150.29,144.8) v3(150.44,149.37) v3(150.44,148.61) v3(150.44,147.84) v3(150.44,147.08) v3(151.05,146.32) v3(151.05,145.56) v3(151.05,144.8) v3(151.81,146.32) v3(151.81,145.56) v3(151.81,144.8) v3(155.01,143.48) v3(155.01,142.71) v3(155.01,141.95) v3(155.01,141.19) v3(155.01,140.43) v3(155.77,143.48) v3(155.77,142.71) v3(155.77,141.95) v3(155.77,141.19) v3(155.77,140.43) v3(156.53,143.48) v3(156.53,142.71) v3(156.53,141.95) v3(156.53,141.19) v3(156.53,140.43) v3(160.6,149.39) v3(160.6,148.63) v3(160.6,147.87) v3(160.6,147.11) v3(161.21,146.32) v3(161.21,145.56) v3(161.21,144.8) v3(161.36,149.39) v3(161.36,148.63) v3(161.36,147.87) v3(161.36,147.11) v3(161.97,146.32) v3(161.97,145.56) v3(161.97,144.8) v3(162.73,146.32) v3(162.73,145.56) v3(162.73,144.8)
+VCC_GT: length 3.9
  BOTTOM w0.508: v1(156.44,130.54) 157.21,130.54 v1(158.51,131.83) R686.2
  vias: v1(146.02,114.09) v1(146.21,131.85) v1(146.21,131.19) v1(146.21,130.54) v1(146.21,129.89) v1(146.21,129.24) v1(146.21,127.94) v1(146.21,127.29) v1(146.68,114.09) v1(147.33,114.09) v1(147.78,129.24) v1(147.78,128.59) v1(147.78,127.94) v1(148.3,113.95) v1(148.57,131.85) v1(148.57,131.19) v1(148.57,130.54) v1(148.57,129.89) v1(150.14,129.24) v1(150.14,128.59) v1(150.14,127.94) v1(150.14,127.29) v1(150.93,131.84) v1(150.93,131.19) v1(150.93,130.54) v1(150.93,129.89) v1(152.5,130.54) v1(152.5,129.89) v1(152.5,129.24) v1(152.5,128.59) v1(152.5,127.94) v1(152.5,127.29) v1(152.8,114.72) v1(153.29,131.84) v1(153.29,131.19) v1(153.29,130.54) v1(153.28,129.89) v1(153.29,127.29) v1(153.3,127.94) v1(153.56,114.72) v1(154.87,130.54) v1(154.87,129.89) v1(154.87,129.24) v1(155.08,123.68) v1(155.07,123.03) v1(155.08,121.66) v1(155.08,120.46) v1(155.11,124.35) v1(155.1,118.96) v1(155.11,118.28) v1(155.11,117.62) v1(155.65,130.54) v1(155.65,129.89) v1(155.65,129.24) v1(157.29,115.67) v1(157.29,114.09) v1(157.94,115.67) v1(157.94,114.09) v1(158.59,115.67) v1(158.59,114.09) v1(159.24,115.67) v1(159.24,114.09) v1(159.89,115.67) v1(159.89,114.09) v1(160.55,115.67)
+VCC_SA:
  vias: v1(124.33,147.76) v1(125.73,129.25) v1(125.73,127.93) v1(125.73,127.27) v1(125.72,126.61) v1(126.45,131.91) v1(126.52,131.19) v1(126.52,130.54) v1(126.52,129.89) v1(126.52,129.24) v1(126.52,127.92) v1(126.54,126.61) v3(122.4,143.48) v3(122.4,142.71) v3(122.9,146.6) v3(122.9,145.84) v3(122.9,145.08) v3(122.9,144.31) v3(123.08,137.58) v3(123.16,143.48) v3(123.16,142.71) v3(123.46,138.34) v3(123.92,143.48) v3(123.92,142.71) v3(123.97,137.58) v3(124.48,138.34) v3(124.73,142.66) v3(124.86,137.58)
+VCCA_BCLK: length 0.5
  TOP w0.254: v1(212.67,37.96) U14.V19
  vias: v1(213.76,40.17)
+VCCA_XTAL:
  vias: v1(203.17,39.31) v1(203.82,39.34) v1(211.25,37.2) v1(211.9,37.22) v1(212.39,40.64)
+VCCAMPHYPLL:
  vias: v1(231.77,45.53)
+VCCAPLL_1:
  vias: v1(200.42,49.56)
+VCCAPLL_2:
  vias: v1(202.02,53.12)
+VCCDPHY:
  vias: v1(177.26,45.46) v1(177.25,44.81) v1(187.62,43.58) v1(188.27,43.58) v1(214.24,31.79) v1(214.59,31.23) v1(214.98,31.79)
+VCCDSW_1.05V:
  vias: v1(227.51,19.27)
+VCCDUSB: length 1.1
  TOP w0.203: U14.W23 v1(214.24,36.44) ; U14.W22 v1(213.46,36.44)
+VCCIO: length 168.5
  TOP w0.203: PR22.1 181.54,170.47 180.99,169.93 v1(180.97,169.93)
  TOP w0.254: v1(138.25,111.72) 138.57,112.05 U3.AG12
  TOP w0.508: v1(175.58,153.32) 175.29,153.61 PR91.1 ; v1(110.5,107.54) 109.63,108.41 106.78,108.41 104.61,106.25 R103.1 ; R102.1 113.16,104.95 111.26,104.95 v1(110.82,105.39) ; v1(121.35,133.65) 121.23,133.65 120.82,134.05 114.9,134.05 114.27,133.42 112.34,133.42 111.3,132.38 111.3,130.56 110.85,130.12 109.94,130.12 109.67,130.38 v1(108.16,130.38)
  IN2 w0.508: v1(121.35,133.65) 121.35,133.71 122.23,134.6 123.96,134.6 v1(126.68,137.33) 127.06,137.71 133.38,137.71 134.04,138.38 138.55,138.38 139.23,137.69 140.6,137.69 141.08,137.21 157.26,137.21 158.77,135.7 160.31,135.7 160.72,135.28 167.87,135.28 169.73,137.14 169.73,142.28 173.02,145.57 173.02,147.38 176.19,150.55 176.19,152.71 v1(175.58,153.32) 177.11,153.32 180.33,156.54 180.33,169.28 v1(180.97,169.93) ; v1(125.76,123.06) 129.71,127.01 129.71,131.41 128.62,132.5 v1(128.62,132.99)
  IN3 w0.508: v1(108.16,130.38) 109.37,129.18 109.37,125.29 109.07,124.99 109.07,109.74 110.17,108.64 110.17,107.87 v1(110.5,107.54) 109.94,106.99 109.94,105.95 110.51,105.39 v1(110.82,105.39) ; v1(126.68,137.33) 126.68,136.22 128.62,134.28 v1(128.62,132.99)
  BOTTOM w0.508: R687.1 122.76,133.65 v1(121.35,133.65) ; R689.2 108.38,130.6 v1(108.16,130.38)
  vias: v1(125.48,115.31) v1(125.49,120.01) v1(125.49,119.35) v1(125.49,118.69) v1(125.49,118.02) v1(125.49,117.36) v3(182.64,84.62) v3(182.64,83.86) v3(182.64,83.1) v3(183.41,84.62) v3(183.41,83.86) v3(183.41,83.1) v3(186.76,53.81) v3(186.74,53.06) v3(187.54,53.69) v3(187.52,52.9) v3(188.28,52.82) v3(188.3,53.61)
+VCCPGPPA: length 0.9
  TOP w0.254: U14.AN32 218.94,30.11 219.25,29.8 v1(219.25,29.66)
  vias: v1(219.76,29.32)
+VCCPLL: length 19
  TOP w0.254: U3.J28 U3.H28 123.81,124.57 v1(123.81,124.56)
  IN2 w0.508: v1(115.6,127.07) 115.99,127.47 119.55,127.47 120.13,126.89 120.13,126.23 120.88,125.48 123.03,125.48 123.81,124.7 v1(123.81,124.56)
  BOTTOM w0.508: v1(115.6,127.07) 113.6,129.07 v1(111.33,129.07) R690.2 C559.2
+VCCPLL_OC: length 58.4
  TOP w0.254: U3.BJ13 155.35,112.7 U3.BH13 155.03,112.7 v1(154.71,112.37) ; v1(123.16,111.96) 123.16,111.93 123.49,111.61 U3.G11
  TOP w0.508: v1(109.86,104.27) 110.07,104.27 110.7,103.64 111.16,103.64 111.48,103.32 C93.2 111.49,102.13 111.49,101.3 R110.2
  IN3 w0.508: v1(109.86,104.27) 112.02,104.27 113.22,105.47 121.35,105.47 121.44,105.55 122.01,106.12 123.16,107.27 v1(123.16,111.96) 123.93,111.96 124.45,112.49 125.24,112.49 125.82,113.07 139.87,113.07 140.53,112.41 142.51,112.41 143.76,113.66 145.05,113.66 145.49,113.21 148.03,113.21 148.2,113.05 154.03,113.05 v1(154.71,112.37)
  vias: v1(123.78,112.05)
+VCCPRIM_MPHY:
  vias: v1(219.09,37.14) v1(222.17,36.62)
+VCCST: length 165
  TOP w0.254: v1(124.1,127.16) 124.1,126.79 124.14,126.75 U3.H30
  TOP w0.305: R72.1 166.76,123.48 R73.1 R76.1 167,122.05 v1(167,121.81)
  TOP w0.381: R71.1 v1(164.97,123.84)
  TOP w0.508: v1(166.69,131.21) 166.69,131.7 R42.1 ; R39.1 v1(166.92,133.26) ; v1(166.9,134.28) R36.2 ; R98.2 165.48,109.32 165.3,109.5 165.3,112.02 165.03,112.29 165.03,113.37 v1(165.09,113.43)
  IN1 w0.508: v1(167,118.68) 166.29,119.39 166.29,121.23 166.87,121.81 v1(167,121.81) 168.01,122.83 168.01,127.25 167.31,127.95 167.31,130.59 v1(166.69,131.21) ; v1(107.45,130.17) 107.45,130.16 107.96,129.65 111.41,129.65 v1(112.74,130.99)
  IN2 w0.508: v1(181.4,173.5) 181.5,173.5 182.01,172.99 182.01,152.81 177.98,148.77 175.28,148.77 173.86,147.36 173.86,144.38 172.74,143.26 172.74,142.02 v1(170.83,140.12) ; v1(167,118.68) 167,116.32 165.09,114.41 v1(165.09,113.43) ; v1(112.74,130.99) 113.5,131.74 118.3,131.74 119.06,130.99 122.27,130.99 122.54,130.72 ; 122.54,130.72 125.11,133.29 125.7,133.29 128.39,135.98 155.51,135.98 156.5,134.99 157.96,134.99 158.27,134.67 159.91,134.67 160.31,134.28 v1(166.9,134.28) 166.9,133.29 v1(166.92,133.26) 166.92,131.44 v1(166.69,131.21) ; 122.54,130.72 122.54,130.06 123.68,128.92 124.33,128.92 124.88,128.36 124.88,127.58 124.46,127.16 v1(124.1,127.16)
  BOTTOM w0.305: v1(124.1,127.16) 124.44,127.16 124.94,127.65 C555.2 ; v1(167,121.81) 167,123.13 166.29,123.84 v1(164.97,123.84)
  BOTTOM w0.508: R685.2 110.23,133.64 C537.2 111.02,135.13 111.4,134.75 v1(111.4,134.2) 111.4,133.46 112.74,132.11 v1(112.74,130.99) ; v1(166.9,134.28) 168.37,135.75 169.64,135.75 170.41,136.53 170.41,139.7 v1(170.83,140.12)
+VCCSTG: length 79.5
  TOP w0.254: U3.H29 124.14,125.88 U3.G30 123.49,127.14 v1(123.42,127.2)
  TOP w0.508: R67.1 167.64,125.8 v1(167.09,126.36)
  IN2 w0.508: v1(157.65,134.26) 157.53,134.38 156.25,134.38 155.26,135.37 128.64,135.37 127.18,133.91 127.18,129.65 128.01,128.82 128.01,126.58 127.29,125.87 124.37,125.87 123.42,126.82 v1(123.42,127.2) 123.31,127.09 120.78,127.09 119.95,127.93 119.95,129.52 119.16,130.3 118.53,130.3 118.12,130.71 v1(117.06,130.71)
  IN4 w0.508: v1(167.09,126.36) 167.31,126.58 167.31,128.71 163.21,132.81 160.85,132.81 160.5,133.16 159.14,133.16 158.04,134.26 v1(157.65,134.26)
  BOTTOM w0.508: R688.1 R689.1 v1(111.34,130.6) 111.83,130.11 113.18,130.11 113.78,130.71 v1(117.06,130.71)
+VDD12: length 0.5
  BOTTOM w0.508: 57.75,30.12 57.8,30.17 v1(57.8,30.64)
  vias: v1(54.57,25.8) v1(54.94,25.24) v1(55.04,21.81) v1(55.18,27.87) v1(55.18,24.51) v1(55.16,23.86) v1(58.64,20.87) v1(60.51,30.03) v1(61.07,26.97) v1(61.05,23.49) v1(61.11,25.85) v1(61.64,21.76)
+VDD33: length 40.5
  TOP w0.381: 60.13,34.57 60.37,34.34 60.37,34.09 60.53,33.92 61.89,33.92 62.27,33.54 62.27,33 61.47,32.21 61.47,30.89 R363.1 ; 59.92,34.78 R310.1
  IN1 w0.381: v1(62.73,23.6) 62.73,23.02 62.16,22.46 61.14,22.46 60.64,21.95 60.64,20.4 v1(60.88,20.16)
  IN2 w0.381: v1(54.2,21.08) 54.2,20.61 56.11,18.7 56.86,18.7 57.67,17.89 57.67,17.14 58.05,16.76 58.69,16.76 v1(58.84,16.91)
  IN4 w0.381: v1(56.06,34.5) 55.53,33.98 55.53,33.37 53.77,31.61 v1(53.77,30.57) 53.77,29.8 53.93,29.65 53.93,21.35 54.04,21.23 v1(54.2,21.08)
  BOTTOM w0.381: R979.1 63.11,23.98 v1(62.73,23.6) 63.17,23.15 R995.1 ; v1(58.84,16.91) 58.46,16.53 58.41,16.53 57.8,15.92 v1(57.8,14.85) ; v1(54.2,21.08) 54.18,21.1 54.15,21.1 54.02,21.23 53.61,21.23 53.1,21.74 R1009.1 ; R923.1 v1(53.1,29.9) v1(53.77,30.57)
+VDD_DCI: length 1
  TOP w0.178: U30.5 273.31,12.35 273.25,12.28 273.17,12.28 273.17,12.28 v1(273.16,12.28)
  vias: v1(271.77,11.85)
+VDDIO:
  vias: v1(61.13,27.63) v1(62.55,28.78)
+VDDQ: length 2.2
  TOP w0.14: v1(161.69,28.24) 161.18,27.73 161.18,27.09 160.63,26.54 PC246.1
+VIN: length 365.4
  TOP w0.14: 108.68,163.14 108.68,161.51 108.35,161.18 106.09,161.18 105.9,161.36 PR69.1 ; PR295.1 30.19,48.32 v3(30.19,48.84)
  TOP w0.508: v1(154.3,28.85) 154.3,28.35 PR372.1 ; v1(173.34,156.59) 171.82,158.11 v1(171.82,159.12) ; v1(211.38,55.44) 211.37,55.43 202.69,55.43 201.92,56.2 199.89,56.2 198.83,57.26 192.58,57.26 192.47,57.37 192.47,57.37 192.11,57.73 190.74,57.73 190.21,58.27 189.03,58.27 187.93,57.17 186.78,57.17 185.97,56.36 185.97,56.08 v1(184.74,54.85) 183.14,56.45 PR195.1 182.34,56.88 182.7,57.25 182.7,58.33 183.21,58.84 PR178.1
  IN1 w0.508: v1(153.72,11.24) 152.9,12.07 148.25,12.07 146.29,14.03 146.29,18.06 144.82,19.53 143.79,19.53 142.72,20.6 v1(142.72,24.86) ; v1(178.37,29.06) 178.37,28.83 177.34,27.81 176.52,27.81 176.19,27.48 176.19,26.76 176.85,26.1 176.85,23.69 177.89,22.65 177.89,20.66 176.48,19.24 171.45,19.24 171.21,19 167.77,19 167.1,18.33 159.61,18.33 v3(157.98,16.7)
  IN3 w0.508: v3(106.04,163.72) 108.71,161.05 123.62,161.05 127.68,165.12 133.85,165.12 136.14,167.4 138.7,167.4 141.67,170.37 143.05,170.37 146.75,174.08 162.38,174.08 165.7,170.76 168.29,170.76 171.27,167.78 172.18,167.78 172.76,167.2 172.76,165.52 171.39,164.15 171.39,159.55 v1(171.82,159.12)
  IN4 w0.305: v3(30.19,48.84) 26.14,48.84 25.58,48.28 25.58,47.71 25.28,47.41 22.65,47.41 21.61,48.45 21.61,49.29 21.08,49.83 21.08,52.34 20.62,52.79 20.62,54.42 19.96,55.08 15.89,55.08 15.07,54.27 13.21,54.27 12.77,53.83 12.77,53.75 12.27,53.25 11.78,53.25 11.5,53.53 10.66,53.53 10.03,52.91 9.06,52.91 8.76,53.21 8.76,53.78 6.25,56.28 6.25,60.06 8.15,61.96 8.15,65.37 7.16,66.36 7.16,72.86 7.56,73.27 7.56,78.02 8.6,79.06 8.6,80.28 7.56,81.32 7.56,83.28 8.97,84.69 8.97,85.11 14.51,90.64 14.51,93.26 14.2,93.56 v1(14.09,93.56)
  BOTTOM w0.203: v1(14.09,93.56) 14.62,94.1 14.62,97.04 PR475.1
  BOTTOM w0.254: v1(171.82,159.12) 172.7,160 PR457.2
  BOTTOM w0.508: v1(154.3,28.85) 154.3,28.09 151.69,25.49 147.87,25.49 147.24,24.86 v1(142.72,24.86) ; PR467.1 PR466.1 174.72,156.59 v1(173.34,156.59) 170.36,153.61 170.36,150.76 172.5,148.62 172.5,140.05 172.24,139.79 R680.2 ; v1(211.38,55.44) 211.38,54.34 v1(211.78,53.94) 211.78,53.93 212.29,53.43 218.47,53.43 219.65,52.24 219.65,51.42 220.81,50.26 222.86,50.26 223.74,51.15 226.02,51.15 226.1,51.24 231.02,51.24 231.84,50.41 232.68,50.41 233.75,49.34 234.46,49.34 235.48,50.36 PR509.1 ; v1(184.74,54.85) 184.3,54.85 183.79,54.34 183.79,53.36 183.37,52.94 183.37,52.41 181.36,50.4 181.36,46.46 181.84,45.98 181.84,45.47 181.25,44.89 181.25,40.88 181.59,40.54 PR580.1 181.59,39.78 181.12,39.31 181.12,35.86 178.07,32.81 178.07,29.36 v1(178.37,29.06) ; PR487.1 94.16,61.23 93.97,61.23 93.77,61.43 v1(93.72,61.43)
  vias: v1(101.39,160.82) v1(113.03,162.28) v1(114.38,148.86) v1(114.8,151.02) v1(114.8,150.26) v1(114.8,149.5) v1(119.5,17.03) v1(122.44,16.44) v1(131.13,162.63) v1(131.9,162.63) v1(132.66,162.63) v1(141.6,162.83) v1(142.36,162.83) v1(143.12,162.83) v1(151.53,162.63) v1(152.29,162.63) v1(153.05,162.63) v1(162.23,17.62) v1(162.38,162.75) v1(163.14,162.75) v1(163.9,162.75) v3(30.19,52.65) v3(30.19,51.88) v3(30.19,51.12) v3(30.19,50.36) v3(30.19,49.6) v3(32.53,52.57) v3(32.53,51.81) v3(32.53,51.05) v3(32.53,50.28) v3(32.53,49.52) v3(32.53,48.76) v3(33.24,52.19) v3(33.24,51.43) v3(33.24,50.66) v3(33.24,49.9) v3(33.24,49.14) v3(59.99,41.6) v3(60.03,43.14) v3(60.03,42.38) v3(60.75,43.91) v3(60.79,43.14) v3(60.79,42.38) v3(60.79,41.61) v3(61.56,43.14) v3(61.56,42.38) v3(61.56,41.61) v3(62.3,42.54) v3(62.32,41.77) v3(68.49,42.81) v3(68.83,43.5) v3(69.25,42.81) v3(69.67,43.45) v3(74.49,44.17) v3(74.8,43.49) v3(75.46,43.86) v3(75.46,43.09) v3(76.22,43.86) v3(76.22,43.09) v3(76.98,43.86) v3(76.98,43.09) v3(76.98,42.33) v3(77.74,43.86) v3(77.74,43.09) v3(77.74,42.33) v3(78.5,43.09) v3(78.5,42.33) v3(101.47,165.24) v3(101.47,164.48) v3(101.47,163.72) v3(102.23,165.24) v3(102.23,164.48) v3(102.23,163.72) v3(102.99,165.24) v3(102.99,164.48) v3(102.99,163.72) v3(103.75,165.24) v3(103.75,164.48) v3(103.75,163.72) v3(104.51,165.24) v3(104.51,164.48) v3(104.51,163.72) v3(105.28,165.24) v3(105.28,164.48) v3(105.28,163.72) v3(106.04,165.24) v3(106.04,164.48) v3(109.75,147.74) v3(109.75,146.98) v3(109.75,146.22) v3(110.24,22.23) v3(110.22,21.45) v3(110.21,20.68) v3(110.51,147.74) v3(110.51,146.98) v3(110.51,146.22) v3(110.98,21.45) v3(110.97,20.68) v3(111,22.23) v3(111.45,165.62) v3(111.45,164.86) v3(111.45,164.1) v3(111.76,22.23) v3(111.74,21.45) v3(111.73,20.68) v3(112.21,165.62) v3(112.21,164.86) v3(112.21,164.1) v3(112.49,20.68) v3(112.52,22.23) v3(112.5,21.45) v3(112.97,165.62) v3(112.97,164.86) v3(112.97,164.1) v3(113.73,165.62) v3(113.73,164.86) v3(113.73,164.1) v3(114.5,165.62) v3(114.5,164.86) v3(114.5,164.1) v3(125.74,25.83) v3(125.71,25.03) v3(125.73,24.22) v3(126.47,25.03) v3(126.46,23.43) v3(126.52,25.84) v3(126.5,24.22) v3(127.28,25.84) v3(127.23,25.03) v3(127.26,24.22) v3(127.22,23.43) v3(127.98,163.87) v3(127.96,163.11) v3(127.96,162.35) v3(128.52,164.43) v3(138.44,163.02) v3(138.44,162.26) v3(138.53,164.54) v3(138.53,163.78) v3(147.39,169.56) v3(147.39,168.8) v3(147.62,170.3) v3(148.15,169.56) v3(148.15,168.8) v3(148.28,165.12) v3(148.28,164.35) v3(148.28,163.59) v3(148.28,162.83) v3(148.91,169.56) v3(148.91,168.8) v3(149.68,169.56) v3(149.68,168.8) v3(150.44,169.56) v3(150.44,168.8) v3(151.2,169.56) v3(151.22,168.76) v3(152.04,169.59) v3(152.04,168.82) v3(152.16,170.83) v3(155.68,18.23) v3(155.68,17.47) v3(155.68,16.71) v3(156.45,18.23) v3(156.45,17.47) v3(156.45,16.71) v3(157.22,16.7) v3(159.15,164.79) v3(159.15,164.02) v3(159.15,163.26) v3(159.15,162.5)
+VIN_GPU_TOTAL: length 3.8
  TOP w0.14: PR294.1 29.4,48.35 29.23,48.35 ; 27.65,48.35 27.65,47.9 PR299.2
  TOP w0.508: PR32.1 10.19,164.93 9.47,164.2 9.47,163.72 v3(9.26,163.52)
  vias: v1(6.9,63.14) v1(6.9,62.45) v1(6.93,61.74) v1(9.12,160.93) v1(9.93,160.51) v1(10.7,160.5) v1(10.92,161.64) v1(11.46,160.5) v1(13.38,160.37) v1(13.76,161.08) v1(14.17,160.37) v1(14.52,161.08) v1(14.93,160.37) v1(21.28,166.74) v1(21.33,165.78) v1(21.6,170.86) v1(21.61,169.97) v1(21.61,168.95) v1(21.76,165.27) v1(21.81,167.15) v1(21.81,166.36) v3(8.58,162.7) v3(9.34,162.7) v3(19.2,169.46) v3(19.45,167.05) v3(19.45,166.28) v3(19.45,165.52) v3(25.24,52.65) v3(25.24,51.88) v3(25.23,50.4) v3(25.24,48.93) v3(25.46,51.13) v3(25.43,49.68)
+VIN_PANEL_R:
  vias: v1(173.27,133.86)
+VIN_VGACORE: length 9.8
  TOP w0.14: v3(24.35,48.11) 24.6,48.11 24.89,48.4 25.73,48.4 25.77,48.36 26.94,48.36 27.27,48.02 PR298.2
  TOP w0.508: PR266.2 41,51.67 PC185.1 41,52.97 v1(40.89,53.08)
  IN2 w0.508: v1(40.89,53.08) 41.95,54.14 41.95,54.42 42.97,55.44 v3(42.97,56.35)
  vias: v1(26.05,58.64) v1(26.03,57.85) v1(26.03,57.06) v1(35.68,57.85) v1(35.71,58.64) v1(35.71,57.07) v1(45.36,58.64) v1(45.33,57.85) v1(45.37,57.09) v1(55.03,58.67) v1(55,57.88) v1(55.01,57.09) v1(64.66,58.64) v1(64.64,57.85) v1(64.67,57.1) v1(74.29,57.85) v1(74.26,57.09) v1(74.31,58.64) v1(81.17,58.03) v1(83.97,58.64) v1(83.94,57.85) v1(83.95,57.08) v3(12.31,56.63) v3(12.69,58.23) v3(13.07,57.57) v3(13.4,58.82) v3(13.84,57.45) v3(13.94,58.23) v3(14.98,60.04) v3(15.44,59.43) v3(22.17,51.73) v3(22.17,50.97) v3(22.17,50.21) v3(22.19,49.44) v3(22.17,48.68) v3(22.78,48.2) v3(22.83,52.11) v3(22.83,51.35) v3(22.83,50.59) v3(22.85,49.83) v3(22.85,49.04) v3(23.6,48.1) v3(24.1,56.58) v3(24.45,57.24) v3(24.86,56.51) v3(25.22,57.17) v3(25.75,56.3) v3(33.32,57.12) v3(33.32,56.35) v3(34.08,57.06) v3(34.87,57.01) v3(35.4,56.3) v3(42.97,57.12) v3(43.73,57.06) v3(44.52,57.01) v3(45.05,56.3) v3(52.62,57.12) v3(52.62,56.35) v3(53.38,57.06) v3(54.17,57.01) v3(54.7,56.3) v3(59.09,51.72) v3(59.12,52.58) v3(59.94,52.54) v3(59.96,51.76) v3(62.27,57.12) v3(62.27,56.35) v3(63.04,57.06) v3(63.82,57.01) v3(64.36,56.3) v3(71.93,57.12) v3(71.93,56.35) v3(72.69,57.06) v3(73.48,57.01) v3(74.01,56.3) v3(81.45,57.22) v3(81.6,56.48) v3(82.34,57.06) v3(83.13,57.01) v3(83.25,56.23)
AVDD09: length 1.9
  TOP w0.203: v1(261.77,29.89) 261.84,29.96 U15.36
  BOTTOM w0.381: v1(261.77,29.89) 261.89,30.01 C829.1
  vias: v1(265.14,30.7) v1(265.86,30.67)
GND: length 3705.4
  TOP w0.089: U7.L20 263.35,47.54
  TOP w0.102: UG1.H22 51.65,123.27 v2(51.8,123.12) ; VRAM7.M12 19.13,117.28 ; UG1.AE10 43.24,112.04 42.54,112.04 v2(42.41,111.9) ; v2(21.76,110.92) 21.76,110.91 ; UG1.H34 60.01,123.99 60.01,124.69 v2(60.03,124.7) ; v2(43,94.38) 43.25,94.63 UG1.BJ10 UG1.BG10 ; 50.95,103.62 UG1.AU21 ; 95.02,118.43 VRAM6.F12 ; UG1.AU22 51.65,103.62
  TOP w0.118: v2(45.65,149.33) 45.58,149.27 45.41,149.27 45.41,149.27 45.11,149.27 v2(44.89,149.27) ; v2(16.51,126.93) 16.52,126.92 16.52,126.43 16.55,126.4 16.55,126.24 v2(16.53,126.21) ; v2(75.51,149.27) 75.53,149.29 76.2,149.29 76.22,149.31 v2(76.25,149.31)
  TOP w0.125: UG1.B48 69.81,128.11 69.81,127.94 69.49,127.62 69.49,127.31 69.71,127.1 v2(70.17,127.1)
  TOP w0.128: UG1.B37 62.15,128.01 62.24,127.92 62.24,127.89 62.42,127.71 62.42,127.31
  TOP w0.14: PU14.2 21.54,57.37 21.74,57.57 v1(21.99,57.57) ; v2(70.88,111.71) 70.91,111.73 71.37,111.73 71.51,111.87 71.59,111.87 71.77,112.05 UG1.AE51 ; v1(292.12,36.24) 292.04,36.16 292.04,36.01 291.99,35.96 D42.1 ; v1(51,54.92) 50.48,54.4 PR230.1 ; PR244.2 25.6,54.27 25.91,53.96 v1(26.41,53.96) ; v1(290.85,36.24) 290.85,36.16 290.98,36.03 D41.1 ; U14.A33 219.27,46.11 v1(219.11,46.28) ; v1(12.62,60.24) 12.62,60.21 12.71,60.12 PC160.2 ; v2(64.7,152.28) v2(63.95,152.28) 63.51,152.72 63.51,153.55 63.86,153.9 63.86,153.95 ; v2(93.15,107.32) 93.15,108.03 v2(93.13,108.05) ; C289.2 25.57,34.3 v1(25.39,34.48)
  TOP w0.15: UG1.BJ7 41.01,95.39 41.01,95.72 v2(40.99,95.75) ; UG1.BF2 37.76,97.35 38.01,97.1 v2(38.64,97.1) 38.67,97.1 38.92,97.35 UG1.BF4 ; v2(46.4,99.05) 46.62,99.05 46.68,99.12 46.97,99.12 47.13,98.96 v2(47.33,98.96)
  TOP w0.152: U14.AM49 227.21,30.75 v1(227.48,31.02) ; v1(203.09,32.73) 203.18,32.82 U14.AG1 ; U14.BG28 217.11,23.15 217.11,22.17 217.53,21.75 217.53,21.54 v1(217.68,21.39) ; v1(268.55,46.27) 268.55,46.34 268.4,46.5 U7.A22 U7.B22 U7.C22 ; U14.BG17 211.53,22.98 211.37,22.83 211.26,22.83 211.26,22.83 v1(211.16,22.83) ; U14.BG25 215.4,22.52 v1(215.46,22.46) ; U3.T5 U3.T4 U3.T3 ; U7.AB20 258.44,47.42 U7.AC20 257.68,47.42 v2(257.47,47.21) ; v1(227.66,32.64) 227.48,32.82 U14.AG49 ; U3.T1 U3.T2 U3.T3 ; U7.B12 U7.A12 268.65,51.1 v2(268.73,51.02) ; v2(268.66,50.18) U7.A14 U7.B14 267.36,50.18 267.09,50.45 U7.D13 267,50.38 267,49.86 U7.D15 ; U14.BG22 213.61,23.07 v1(213.61,22.7) ; U7.B16 267.47,49.26 v2(267.26,49.47) ; U7.C23 267.18,45.94 267.43,45.69 ; v2(257.51,55.62) 257.59,55.7 U7.AC2 ; U14.AM1 203.27,30.63 203.12,30.47 v1(203.12,30.45) ; U14.A37 221.47,46.11 v1(221.66,46.3) ; v1(160.82,105.99) 160.63,106.18 U3.BT3 ; v2(267.25,52.72) 267.47,52.94 U7.B8 U7.A8 268.54,52.94 v2(268.67,52.8) ; U14.AD2 204.05,34.45 203.63,34.45 U14.AD1 203.45,34.64 202.81,34.64 202.38,35.07 201.95,35.07 201.77,35.25 v1(201.77,35.93) ; U7.B20 267.54,47.51 v2(267.23,47.51) ; v2(268.7,52.24) 268.6,52.24 268.38,52.02 U7.A10 U7.B10 ; v2(267.25,48.15) 267.44,48.34 U7.B18 ; v1(220.08,22.05) 219.85,22.05 219.47,22.43 219.47,22.61 219.32,22.76 219.32,23.14 U14.BG33 ; v1(130.64,105.77) U3.T3 ; U14.AA49 227.55,36.18 227.82,36.44 v1(227.82,36.7)
  TOP w0.178: v2(259.86,45.56) 259.82,45.6 U7.W23 U7.W22 ; v2(262.06,46.91) 262.02,46.91 U7.R20 ; U7.AB10 U7.AC10 256.67,52.02 256.45,51.8 256.45,51.78 v1(256.43,51.77) ; v2(268.73,49.26) U7.A16 U7.B16 ; v1(257.37,53.89) 257.41,53.86 U7.AC6 U7.AB6 ; U7.R19 261.5,48.08 261.5,48.27 U7.R18 ; U7.R19 262.03,47.55 262.03,47.49 U7.R20 ; U7.R19 261.42,47.53 261.42,47.51 U7.R20 ; U7.D11 U7.D9 266.94,52.4 v2(267.25,52.72) ; U7.H13 264.94,50.45 v2(264.64,50.75) 264.34,51.05 U7.J12 ; U7.B20 U7.A20 268.6,47.42 v2(268.69,47.33) ; U7.N22 U7.N23 262.58,46.04 262.58,45.61 v2(262.55,45.58) ; v2(257.52,46.57) 257.65,46.57 257.73,46.5 U7.AC22 U7.AB22 ; v2(257.19,50.64) 257.65,51.1 U7.AC12 U7.AB12 ; v2(263.5,45.58) U7.L23 U7.L22 ; U7.G22 U7.G23 v2(265.34,45.53) ; v2(262.51,57.23) 262.51,56.71 262.12,56.32 U7.P1 U7.P2 ; v2(266.35,45.54) 266.26,45.64 U7.E23 U7.E22 265.97,46.79 265.97,46.9 ; v2(263.05,57.17) 263.04,57.16 263.04,56.16 U7.M1 U7.M2 263.04,55.62 v2(262.71,55.29) ; U5.5 v1(284.46,52.28) ; v2(267.24,50.79) 267.33,50.79 U7.B12 267.3,51.43 v2(267.22,51.43) 267.22,51.6 U7.B10 ; U7.T16 U7.T18 ; v2(264.66,49.47) 264.66,49.47 U7.J15 264.65,50.11 264.65,50.13 U7.J13 ; U7.R20 261.7,47.2 261.43,46.92 v2(261.43,46.87) ; v2(264.64,56.68) 264.88,56.44 U7.H1 U7.H2 ; U30.13 275.67,9.61 v1(275.99,9.29) ; v2(261.68,56.67) 261.2,56.18 U7.T1 U7.T2 ; U7.E9 266.29,52.36 v2(265.96,52.04) ; v2(268.76,48.34) U7.A18 U7.B18 ; v2(264.38,45.51) 264.42,45.54 U7.J23 U7.J22 ; v2(258.58,45.57) 258.9,45.89 U7.AA23 U7.AA22 ; U7.U22 U7.U23 v2(260.74,45.53) ; v1(257.04,52.9) 257.09,52.9 257.13,52.94 U7.AC8 U7.AB8 258.6,52.94 U7.Y9 259.31,52.57 259.61,52.57 U7.W9 ; U7.K2 U7.K1 263.95,56.16 263.62,56.48 v2(263.62,57.32) ; U7.V16 U7.W18 ; v2(257.52,56.17) 257.53,56.16 U7.AC1 U7.AB1 U7.AB2 U7.AC2 ; U7.R22 U7.R23 261.66,45.57 v2(261.67,45.55) ; v2(257.5,49.7) 257.5,49.72 257.95,50.18 U7.AC14 U7.AB14 258.87,50.18 U7.Y13 ; U7.B6 U7.A6 268.91,53.86 269.13,53.64 v2(269.18,53.64) ; U7.C23 U7.C22 ; v2(257.52,49.11) 257.67,49.26 U7.AC16 U7.AB16
  TOP w0.2: UG1.AJ33 59.35,109.25 v2(59,109.6) 58.78,109.38 58.65,109.25 UG1.AJ32 ; v2(61.02,143.86) VRAM3.T5 v2(60.96,143.29) ; UG1.W4 38.84,116.46 38.25,116.46 38.22,116.42 v2(38.14,116.35) ; UG1.AF38 v2(62.52,111.02) 62.49,111.06 62.44,111.06 UG1.AF37 v2(61.81,111.01) 61.47,111.35 61.45,111.35 ; UG1.AL37 62.15,107.82 62.51,107.53 62.85,107.82 UG1.AL38 ; UG1.AD21 v2(50.6,112.4) UG1.AD20 v2(49.9,113.1) UG1.AD19 ; v2(63.9,109.6) UG1.AJ39 ; UG1.BG7 41.15,96.62 v2(41.51,96.26) ; UG1.AJ17 v2(48.5,109.6) UG1.AJ18 ; UG1.BC16 47.33,99.33 v2(47.33,98.96) ; v2(63.9,110.97) 63.9,110.97 63.9,111 UG1.AF39 ; UG1.AW30 v2(56.9,101.9) UG1.AW29 ; UG1.V27 v2(55.5,117.3) UG1.V28 ; v2(49.65,94.38) 49.55,94.28 UG1.BL19 ; UG1.AF20 50.25,111.33 v2(49.91,110.99) 49.91,110.99 UG1.AF19 ; 62.42,127.31 62.31,127.2 v2(62.27,127.2) ; 61.45,111.35 UG1.AF36 ; 61.45,111.35 61.26,111.54 60.94,111.54 60.75,111.35 UG1.AF35 ; v2(68.1,101.9) 68.45,102.25 UG1.AW46 ; UG1.AG15 v2(47.1,111) UG1.AG16 ; v2(38.13,114.15) UG1.AB2 ; v2(58.32,117.32) UG1.V31 ; v2(42.81,114.4) 43.06,114.15 UG1.AB10 ; UG1.AJ28 v2(55.5,109.6) UG1.AJ27 ; UG1.AW39 63.36,102.06 63.04,102.06 UG1.AW38 62.85,102.2 v2(62.53,101.89) 62.17,102.25 UG1.AW37 v2(61.8,101.9) 61.45,102.25 UG1.AW36 ; v2(66.18,147.05) 65.82,146.69 VRAM3.M12 ; UG1.BL10 43.25,94.18 43.05,94.38 v2(43,94.38) ; v2(40.8,96.96) 40.84,97 40.86,97 40.84,97.02 40.78,97.02 UG1.BF6 ; UG1.P20 v2(50.6,120.12) UG1.P21 ; UG1.AU35 60.75,103.65 60.72,103.65 60.42,103.33 60.38,103.29 v2(60.37,103.29) 60.35,103.29 60.05,103.62 60.05,103.65 UG1.AU34 ; v2(70.89,126.41) 70.89,126.41 UG1.D49 v2(70.17,127.1) ; UG1.AW34 60.05,102.25 v2(60.4,101.9) 60.75,102.25 UG1.AW35 ; UG1.AH10 43.24,109.95 42.97,110.22 42.94,110.22 v2(42.85,110.3) ; UG1.BF41 v2(64.59,96.99) ; v2(71.41,109.89) 71.89,109.89 UG1.AH51 ; UG1.AB39 v2(63.9,113.8) ; UG1.V30 v2(56.9,117.3) UG1.V29 ; 53.75,102.25 UG1.AW25 ; UG1.AJ19 49.62,109.17 50.17,109.17 UG1.AJ20 v2(50.58,109.58) 50.62,109.58 UG1.AJ21 ; v2(78.96,144.47) 78.89,144.4 78.89,143.86 79.13,143.62 79.6,143.62 VRAM4.C5 ; UG1.BC37 UG1.BD38 ; v2(65.99,120.74) 66.06,120.74 UG1.N43 ; v2(49.25,100.45) 49.55,100.15 UG1.BC19 ; UG1.AU33 59.35,103.65 59.02,103.98 v2(58.98,103.98) 58.65,103.65 UG1.AU32 ; UG1.AJ23 52.35,109.25 52.04,109.56 v2(51.98,109.56) 51.96,109.56 51.65,109.25 UG1.AJ22 ; v2(71.39,107.66) 71.58,107.85 UG1.AL51 ; UG1.AG34 60.02,110.65 59.71,110.96 v2(59.69,110.96) 59.38,110.65 UG1.AG33 ; UG1.AG17 48.25,110.55 48.75,110.55 UG1.AG18
  TOP w0.203: C40.1 v1(132.58,133.77) ; 262.39,52.4 v2(262.06,52.72) U7.N8 ; 262.39,52.4 U7.N9 262.71,52.07 ; 262.39,52.4 262.06,52.07 262.39,51.75 U7.N11 ; R276.2 81.77,37.86 81.57,38.06 v1(81.53,38.06) 81.08,37.61 R272.2 ; v1(286.3,43.6) D26.1 286.3,43.04 ; PR384.1 163.5,26.43 PC449.2 163.49,27.76 PC241.2 ; v1(221.67,22.75) 221.67,22.99 U14.BG37 ; v1(262.71,37.28) 262.64,37.21 U15.13 ; v1(136.85,133.8) 136.59,134.05 C43.1 ; UG1.AB35 60.72,114.15 v2(60.37,114.5) 60.05,114.18 UG1.AB34 60,114.15 v2(59.7,113.85) 59.4,114.15 UG1.AB33 ; U7.T16 U7.R18 ; UG1.V37 v2(61.8,117.3) 61.45,116.95 UG1.V36 ; v2(262.74,46.9) 262.74,46.9 U7.M20 ; v2(262.74,46.9) 262.58,46.74 U7.N22 ; v2(262.74,46.9) 262.44,47.2 U7.N20 ; U7.N13 U7.M12 ; U7.N13 U7.N12 ; U7.N13 262.27,50.33 262.27,49.91 U7.N15 ; U7.M12 262.93,51.2 262.93,51.65 U7.M11 262.71,52.07 ; U7.M12 U7.N12 ; U7.M12 263.32,50.82 v2(263.37,50.82) 263.39,50.79 263.39,50.74 U7.L13 ; v1(175.31,173.86) 175.31,173.46 175.52,173.25 PC8.1 ; CG34.2 12.96,105.51 v1(13,105.55) 13.02,105.55 13.14,105.44 13.6,105.44 CG32.2 ; U3.AR14 144.97,113.35 v1(144.65,113.02) 144.97,112.7 U3.AR13 ; U7.T20 261.39,46.89 261.4,46.89 v2(261.43,46.87) 261.43,46.72 U7.R22 ; U7.T20 260.79,46.9 260.74,46.9 ; U7.T20 261.1,47.2 261.42,47.51 ; U16.46 274.08,37.1 273.63,37.56 v1(273.63,37.81) ; v1(286.98,40.83) 287.2,41.05 D29.1 ; D34.1 286.91,38.15 v1(286.91,38.5) ; D34.1 287.32,37.74 287.61,37.74 v1(288.16,38.29) ; D34.1 287.29,38.14 287.57,38.41 v1(287.57,38.65) D30.1 ; v1(71.51,23.88) 71.1,23.88 70.24,23.02 U18.27 ; v2(90.13,153.65) 89.99,153.79 C33.2 ; v1(120.56,115.9) 120.56,115.97 120.84,116.24 U3.C17 120.89,116.52 121.44,117.08 U3.D18 ; v1(20.14,96.1) 20.33,95.91 20.33,95.75 20.34,95.73 PU11.11 ; C206.1 230.1,45.35 v1(229.6,44.85) ; v1(26.46,98.84) 26.66,99.05 CG45.2 ; v1(60.56,54.61) 60.35,54.4 PR233.1 ; UG1.AL32 58.65,107.85 v2(58.3,108.2) UG1.AL31 ; UG1.P39 63.51,119.75 63.21,119.45 v2(63.21,119.4) 62.86,119.75 UG1.P38 ; U7.Y20 259.19,47.2 v2(259.48,46.91) 259.77,47.2 U7.W20 259.89,47.09 260.33,47.09 U7.V20 ; v1(97.82,59.2) 97.84,59.18 98.07,59.18 98.57,58.69 PR183.1 ; v1(286.93,43.68) 287.12,43.49 D25.1 ; U7.F5 265.31,54.67 U7.H5 264.95,54.35 v2(264.64,54.65) 264.64,54.59 264.39,54.35 U7.J5 264.34,54.4 v2(264.01,54.72) 263.69,54.4 ; U7.F5 U7.E5 ; U7.F5 265.74,54.24 265.74,53.8 ; U7.F5 U7.E4 266.58,55.29 v2(266.62,55.29) ; C942.2 281.5,9.54 v1(281.59,9.63) ; 262.71,52.07 U7.N11 ; C333.2 C332.2 86.31,31.31 v1(86.28,31.28) 86.14,31.42 U18.91 ; CG20.2 7.87,118.84 8.02,118.69 v1(8.15,118.69) ; C280.2 31.99,35.18 31.73,35.45 v1(31.73,35.55) ; v1(37.39,40.24) 37.46,40.31 PC223.2 PR321.1 ; PR224.1 31.43,54.4 v1(31.64,54.61) ; PR280.2 96.12,48.98 96.34,48.76 v1(96.34,48.28) ; U24.18 v1(265.54,23.56) ; v1(95.08,155.1) 95.01,155.04 C32.2 ; U7.E16 265.97,49.46 v2(265.97,49.47) ; U7.E16 265.98,48.84 v2(265.97,48.84) 265.66,49.15 U7.F16 265.96,49.47 v2(265.97,49.47) ; U7.E16 U7.D16 ; v2(267.25,52.72) 267.25,52.73 U7.D8 266.94,53.01 v2(266.64,52.72) 266.32,52.4 U7.E9 ; D22.1 289.06,47.54 289.06,47.55 v1(289.3,47.79) ; D22.1 289.43,47.16 v1(289.53,47.06) 289.69,46.89 D23.1 ; D22.1 288.68,47.78 v1(288.64,47.82) ; C45.1 142.67,134.26 142.62,134.2 v1(142.62,133.78) ; PU7.2 101.08,156.53 PC75.2 ; 286.3,43.04 285.97,43.04 v1(285.65,43.36) ; 286.3,43.04 v1(286.91,43.04) ; PC156.1 94.01,57.97 v1(93.55,57.5) ; v1(68.21,34.17) 68.57,33.81 68.57,33.62 68.78,33.42 U18.1 ; PR255.2 43.5,51.91 v1(43.28,51.69) ; PR93.1 111.86,154.52 112.04,154.7 v1(112.21,154.7) ; U7.H16 v2(264.66,49.47) U7.H15 264.65,50.13 ; 265.74,53.8 266.18,53.8 U7.E6 266.39,53.59 266.39,53.15 U7.E8 ; 265.74,53.8 U7.F6 U7.H8 ; U3.C19 120.89,118.1 121.44,118.65 U3.D20 ; U7.N20 262.34,47.2 v2(262.06,46.91) ; U7.N20 262.71,47.52 262.71,47.52 263.04,47.84 U7.M19 263.35,47.54 ; U7.N20 262.09,47.49 262.03,47.49 ; v1(14.42,27.27) 14.5,27.19 14.5,27.09 14.7,26.89 R400.2 ; U14.AT45 225.3,28.55 225.61,28.86 v1(225.61,29.05) 225.61,29.38 U14.AP46 ; v1(220.01,43.63) 220.01,43.69 U14.E35 ; 286.32,34.28 286.58,34.28 286.66,34.21 v1(286.91,34.21) ; 286.32,34.28 D46.1 286.23,34.28 ; 286.32,34.28 286.23,34.28 ; U3.A12 118.86,112.35 v1(118.75,112.45) ; U7.W18 260.11,48.18 260.7,48.18 v2(260.76,48.11) ; v1(8.12,129.38) 8.05,129.38 7.81,129.15 CG9.2 ; U24.4 266.24,17.24 v1(266.01,17.47) ; R194.1 20.41,45.53 20.91,45.53 21.23,45.85 21.23,46.05 ; C189.2 21.23,46.88 21.23,46.05 ; U3.AY14 148.76,113.51 148.81,113.55 149.06,113.73 v1(149.09,113.76) ; v1(77.56,21.43) 77.43,21.3 U18.49 ; U7.J13 264.34,50.47 264.61,50.75 v2(264.64,50.75) U7.H12 ; D27.1 285.9,41.33 v1(285.69,41.11) ; D27.1 286.67,41.33 v1(286.91,41.57) ; D27.1 v1(286.3,40.81) ; U7.T13 261.01,50.37 ; 261.01,50.37 260.71,50.07 U7.V15 ; 261.01,50.37 261.01,49.87 U7.T15 ; v1(153.86,25.82) 153.51,26.18 PR388.1 ; 263.69,54.4 U7.L5 ; 263.69,54.4 v2(263.36,54.72) 263.35,54.72 263.04,54.41 U7.M5 262.96,54.35 262.7,54.6 v2(262.7,54.62) 262.42,54.35 U7.N5 262.28,54.45 261.84,54.45 U7.R5 261.54,54.54 261.28,54.54 U7.T5 ; PR1.2 v1(7.05,173.55) ; 20.98,60.99 20.96,60.99 v1(20.76,61.19) ; U3.A24 v1(118.95,121.8) ; v1(11.22,105.6) 11.13,105.51 CG33.2 ; v1(259.94,37.15) 260.24,36.85 U15.19 ; U13.47 246.64,35.97 U13.75 ; v1(288.18,39.28) 288.07,39.17 D30.1 ; U15.17 261.04,37.14 v1(260.88,37.3) ; PC217.2 30,42.63 30.9,41.73 31.74,41.73 32.06,41.41 PQ31.1 ; U7.D5 266.9,54.35 v2(266.62,54.07) 266.94,53.75 U7.D6 ; C38.1 130.3,134.43 v1(130.85,133.87) ; PC205.2 34.57,48.3 34.38,48.49 34.07,48.49 33.83,48.73 PC202.2 33.83,49.5 v1(33.86,49.54) ; v1(21.23,46.05) 21.23,46.05 ; PR340.2 42.1,38.51 PC227.2 42.42,38.49 42.83,38.08 v1(42.83,37.68) ; v2(8.54,121.75) 8.34,121.55 CG17.2 ; C198.1 198.81,46.34 198.95,46.2 C205.1 ; U7.D16 v2(267.26,49.47) 267.26,49.47 U7.D15 266.86,49.72 266.36,49.72 U7.E15 265.97,49.48 v2(265.97,49.47) ; U7.D16 U7.D18 266.94,48.47 v2(267.25,48.15) 267.3,48.1 267.3,47.59 v2(267.23,47.51) 267.28,47.46 267.28,46.6 U7.C22 266.82,46.85 266.16,46.85 266.1,46.91 v2(265.96,46.91) ; U3.A10 118.66,110.78 v1(118.54,110.89) ; C51.1 174.94,132.39 v1(175.13,132.58) ; U7.J15 U7.L15 263.43,50.05 263.39,50.05 v2(263.37,50.08) 263.69,50.4 U7.L13 ; U3.A22 v1(118.95,120.23) ; v1(8.4,114.78) CG24.2 ; PR16.2 11.4,170.91 v1(11.55,170.76) ; v1(286.28,35.65) 286.35,35.65 286.69,35.99 D39.1 287.29,35.86 v1(286.91,35.47) ; v2(63.17,117.32) 63.17,117.27 UG1.V38 62.99,116.81 63.41,116.81 UG1.V39 v2(63.91,117.34) ; D47.1 286.19,32.57 285.51,31.89 v1(285.51,31.69) ; D47.1 286.71,32.14 286.71,31.26 v1(286.8,31.17) 286.92,31.29 D50.1 287.57,31.46 v1(287.22,31.82) ; D47.1 286.27,31.59 v1(286.05,31.36) ; v1(235.45,54.98) 235.27,55.16 PR208.1 ; C41.1 v1(134.05,133.77) ; v1(155.72,23.69) 155.71,23.7 PU27.14 ; U7.J22 264.42,46.63 v2(264.68,46.89) 264.64,46.89 U7.J20 ; v2(38.12,122.34) 38.25,122.21 38.77,122.21 39.05,122.49 UG1.K4 39.17,122.67 39.64,122.67 39.91,122.41 40.31,122.41 UG1.K6 ; v1(23.21,93.21) 23.54,92.88 CG67.2 ; PR236.1 69.91,54.4 v1(70.3,54.79) ; PR248.2 64.21,54.19 64.41,53.99 v1(65.06,53.99) ; C251.2 73.99,37.78 C252.2 73.07,37.78 v1(72.78,38.08) ; R161.1 20.7,51.86 20.5,51.65 20.08,51.65 v1(19.96,51.54) ; v1(178.08,159.38) 178.15,159.38 PR75.2 ; D30.1 v1(286.91,39.17) ; 265.34,46.9 U7.F20 265.67,47.2 v2(265.96,46.91) ; 265.34,46.9 265.29,46.9 U7.H20 264.98,47.2 v2(264.66,47.52) ; 265.34,46.9 U7.G22 ; v1(237.61,43.43) 237.74,43.43 238.55,44.24 C211.2 ; U13.80 247.42,36.77 U13.45 ; v1(21.96,54.54) 21.82,54.4 PR221.1 ; U14.AT1 203.4,28.59 v1(203,28.59) ; v1(265.19,31.84) 265.12,31.84 264.79,32.17 U15.2 ; C256.2 80.33,36.8 80.53,36.6 v1(80.63,36.6) U18.104 ; U7.J20 264.66,47.52 v2(264.66,47.52) ; U7.J20 264.31,47.2 v2(264.02,46.91) ; U3.D14 121.28,113.68 121.28,113.54 U3.C13 120.89,113.07 v1(120.56,112.75) ; v1(289.55,32.57) D48.1 288.94,32.3 v1(289.25,32) ; U7.L13 U7.J12 264.04,51.39 v2(264.04,51.4) ; U3.BR9 v1(159.24,110.94) ; v1(286.2,30.01) 286.56,29.66 v1(286.81,29.66) 286.96,29.51 D51.1 287.7,29.51 288.08,29.12 v1(288.08,28.79) ; v1(141.8,133.77) 141.8,134.18 141.85,134.23 C44.1 ; R292.2 25.42,35.47 25.06,35.12 C278.1 25.01,34.87 v1(25.39,34.48) ; v1(265.22,14.32) 265.14,14.39 U24.57 ; U14.J46 225.46,41.89 225.22,42.14 v1(225.22,42.21) 225.15,42.21 224.65,42.7 U14.G44 ; PR246.2 44.9,54.05 v1(44.6,53.74) ; v1(92.87,60.8) PR174.2 ; PR247.2 54.56,54.05 v1(54.28,53.78) ; v1(70.58,36.57) 70.97,36.57 C262.2 ; U14.AP4 205.7,29.89 205.7,30.39 205.91,30.6 205.91,31.13 v1(205.86,31.18) ; UG1.AB30 57.35,114.05 57.85,114.05 UG1.AB31 v2(58.3,114.5) 58.65,114.15 UG1.AB32 ; C334.2 66.56,31.32 66.05,31.83 v1(66.05,31.9) 66.19,32.04 C329.2 ; v1(27.88,45.89) 28.42,45.89 28.62,46.09 PR306.2 ; v1(34.67,50.15) 34.85,49.97 PR281.2 ; 286.23,34.28 v1(285.64,34.28) 285.64,34.41 285.44,34.61 v1(285.08,34.61) ; U3.BT12 160.68,112.12 v1(160.81,112.25) ; U39.45 89.63,152.7 89.48,152.55 C34.2 ; CG6.2 12.74,136.74 v2(12.62,136.62) ; UG1.AL36 61.39,107.79 60.81,107.79 UG1.AL35 60.69,107.79 60.11,107.79 UG1.AL34 ; PR308.2 35.17,45.49 35.43,45.23 v1(35.95,45.23) ; PC82.2 v1(110.58,152.16) ; v1(216.65,45.69) 216.77,45.81 U14.A28 ; PC257.2 152.5,24.2 152.01,24.2 v1(151.96,24.15) ; v1(225.51,37.77) 225.46,37.73 U14.V46 ; C42.1 135.12,134.07 v1(135.4,133.8) ; v1(288.28,34.81) 288.74,34.81 288.94,34.61 D45.1 288.63,34.45 v1(288.33,34.15) ; v1(287.57,41.57) D29.1 ; D29.1 288.07,41.05 v1(288.18,41.16) ; v1(286.28,45.41) 286.28,46.6 286.84,47.16 D21.1 286.98,47.16 286.98,46.63 v1(287.17,46.45) 287.17,46.24 v1(287.52,45.89) 287.57,45.84 D24.1 ; U13.51 245.43,34.37 245.05,33.99 v1(245.02,33.99) ; C166.1 200.6,51.02 v1(200.4,51.22) ; v1(288.3,43.74) 288.04,43.74 287.79,43.49 D25.1 ; v1(20.19,46.43) R181.2 R180.2 ; CG7.2 7.82,130.67 8.07,130.42 v1(8.12,130.42) ; PC146.1 95.65,60.24 v1(95.56,60.33) ; D23.1 290.58,46.89 v1(290.72,47.03) ; D23.1 290.13,47.37 v1(290.09,47.41) ; U7.J18 264.61,48.22 v2(264.61,48.18) 264.61,48.12 U7.J19 264.66,47.52 v2(264.66,47.52) ; PR102.2 97.38,152.38 97.2,152.56 v1(97.2,152.75) 97.56,153.11 PC80.2 ; v1(287.57,42.97) D25.1 ; v1(8.17,124.96) 7.83,124.62 CG13.2 ; v1(79.75,53.99) 79.34,54.4 PR239.1 ; v2(264.02,46.91) 263.97,46.91 263.97,46.99 263.77,47.2 U7.L20 263.5,47.01 U7.L22 263.82,46.82 263.93,46.82 v2(264.02,46.91) ; U14.G6 206.58,42.4 U14.H8 ; C463.2 10.78,15.51 v1(10.61,15.33) ; PR227.1 41.08,54.4 v1(41.29,54.61) ; C285.2 34.64,34.46 34.45,34.65 34.45,34.71 34.25,34.92 v1(34.23,34.92) ; U7.N11 U7.N12 ; U7.D13 266.94,50.49 v2(267.24,50.79) 266.94,51.09 U7.D12 ; v1(172.94,173.8) 173.42,173.8 PC5.1 173.62,173.7 174,174.08 PR10.1 ; v1(77.03,52.9) 77.03,53.18 77.32,53.47 PD5.2 ; U7.D12 U7.E11 266.01,52.02 265.97,52.02 v2(265.96,52.04) 265.64,52.36 U7.F9 ; U7.D12 266.94,51.15 v2(267.22,51.43) 266.94,51.72 U7.D11 ; v1(48.25,52.44) 47.61,51.8 47.61,51.29 PC198.2 ; v1(157.02,160.16) 157.27,160.42 PC62.2 ; D24.1 v1(286.94,45.37) ; D24.1 v1(288.18,45.37) ; v1(207.11,46.54) U14.A8 ; v2(15.78,116.13) 15.78,116.18 VRAM7.H11 16.13,116.47 v2(16.44,116.16) ; PR249.2 73.86,54.27 73.68,54.09 v1(73.68,53.74) ; v2(265.96,46.91) 265.97,46.9 ; CG77.2 33.8,86.15 v1(33.48,85.83) ; v1(193.08,19.68) 193.08,19.53 192.61,19.06 Q38.4 ; v1(120.56,119.05) 120.89,119.37 U3.C21 120.89,119.72 121.27,120.11 121.42,120.11 U3.D22 ; v1(262.63,23.69) 262.63,23.31 262.74,23.19 U24.25 ; CG26.2 v1(8.4,113.32) ; U15.37 262.24,29.97 262.4,29.81 v1(262.4,29.71) ; v1(160.82,106.84) 160.75,106.9 U3.BT4 ; C35.2 88.28,148.9 v1(88.28,148.78) ; UG1.P22 51.65,119.77 51.94,120.06 51.94,120.09 v2(51.96,120.11) 51.98,120.09 52.04,120.09 52.35,119.78 UG1.P23 ; PR245.2 35.25,54.22 35.46,54.02 36.09,54.02 v1(36.21,53.89) ; U3.A20 v1(118.95,118.65) ; PR354.1 47.14,31.11 v1(47.12,31.1) ; v1(248.5,43.65) 248.17,43.98 C214.2 ; C282.2 60.83,34.61 60.41,35.02 v1(60.41,35.12) ; U3.AG10 138.71,110.75 v1(138.25,111.07) 138.71,111.4 U3.AG11 ; v1(66.75,22.79) 66.61,22.79 66.27,22.45 C415.2 ; v1(144.08,133.78) 144.26,133.95 C46.1 ; U3.A18 v1(118.95,117.08) ; D28.1 290.1,40.7 289.25,40.7 289.15,40.81 v1(288.94,40.81) ; PR26.2 v1(9.16,168.9) ; CG38.2 16.21,103.62 v1(16.21,103.23) ; U3.D12 121.44,112.35 120.89,111.8 U3.C11 120.89,111.5 v1(120.56,111.17) ; U3.BT5 160.78,107.7 v1(160.86,107.78) ; v1(120.56,120.62) 120.89,120.95 U3.C23 120.89,121.3 121.39,121.8 U3.D24 ; PR392.1 116.63,26.1 116.64,26.11 v1(116.64,26.21) ; C39.1 v1(131.76,133.85) ; Q30.4 93.93,37.62 93.85,37.71 93.14,37.71 v1(93.01,37.84) ; R503.1 11.67,19.46 v1(10.92,20.21) ; C261.1 34.16,37.15 34.04,37.03 C264.1 ; U3.A16 v1(118.95,115.5) ; v1(77.44,38) 77.11,37.67 C258.2 ; U3.A14 v1(118.75,113.93) ; v1(17.9,38.01) 19.14,39.26 C226.2 19.08,40.34 R229.2
  TOP w0.225: v2(71.61,125.71) UG1.E51 72.31,126.35 v2(72.32,126.38) ; UG1.B51 v2(72.29,128.49) ; UG1.B52 v2(73.21,128.27) ; UG1.A51 v2(72.3,129.35) ; UG1.C51 v2(71.61,127.12) ; v2(70.94,129.27) 70.94,129.27 UG1.A50 ; UG1.C52 72.59,127.46 72.33,127.77 v2(72.34,127.81)
  TOP w0.229: U7.AB18 U7.AC18 257.86,48.34 257.45,47.92 v2(257.45,47.84) ; 263.35,47.54 263.35,47.51 U7.M20 262.71,47.52 ; U7.V20 260.74,46.9 U7.U22
  TOP w0.25: v2(41.15,94.39) UG1.BL7 ; UG1.BL1 36.66,93.56 v2(36.66,93.29) ; UG1.BG16 47.72,96.92 v2(47.72,97.02) ; v2(38.63,105.98) 38.4,105.75 UG1.AP2 ; UG1.D46 68.45,126.75 68.5,126.8 68.5,127.27 68.41,127.36 v2(68.41,127.6) ; VRAM3.N12 v2(66.2,145.53) ; v2(49.91,97) 49.9,97 UG1.BG19 ; v2(87.91,100.53) 88.27,100.89 VRAM8.D1 ; v2(52,96.97) 51.65,96.65 UG1.BG22 ; v2(37.22,92.82) 37.27,92.82 37.59,93.15 UG1.BM2 ; UG1.BE13 45.35,98.05 45.15,98.25 45.15,98.93 v2(45.04,99.03) 45.15,99.14 45.15,99.25 45.35,99.45 UG1.BC13 ; v2(90.89,101.31) VRAM8.G1 ; v2(64.48,94.81) 64.25,94.58 UG1.BL40 ; v2(47.11,97.71) 47.45,98.05 UG1.BE16 ; UG1.A3 38.35,128.85 v2(38.53,129.29) ; VRAM4.D1 82.67,144.41 v2(83.03,144.05) ; UG1.B25 53.75,128.15 54.02,127.82 54.01,127.77 v2(54.03,127.74) ; VRAM2.D1 52.39,144.03 v2(52.41,144.03) ; v2(87.89,116.55) 88.27,116.92 VRAM6.R14 ; UG1.BD38 63.2,98.4 v2(63.25,98.4) ; UG1.BL43 66.35,94.44 v2(66.62,94.71) ; VRAM1.R14 36.71,144.41 37.05,144.07 37.05,144.02 v2(37.08,143.99) ; v2(67.71,142.53) 67.33,142.91 VRAM3.U14 v2(66.95,143.28) ; VRAM2.G1 v2(51.64,147.03) ; v2(73.14,105.07) 72.67,105.07 UG1.AR52 ; v2(39.41,93.5) 39.75,93.84 UG1.BL5 ; UG1.BH2 37.65,95.95 37.65,95.91 37.91,95.65 37.99,95.65 v2(38,95.64) ; 81.13,145.91 v2(80.75,146.28) 81.13,146.66 ; v2(37.2,93.37) 37.2,93.42 37.59,93.85 UG1.BL2 ; UG1.BE21 51.39,97.61 v2(51.43,97.61) 51.43,97.83 UG1.BE22 ; v2(67.71,144.03) 67.33,144.41 VRAM3.R14 ; v2(82.25,150.03) VRAM4.M1 ; VRAM1.G3 v2(28.83,150.78) ; v2(35.58,145.53) VRAM1.N12 ; v2(58.01,97.32) 58.11,97.22 58.11,96.81 UG1.BG31 ; v2(87.14,117.31) VRAM6.U14 86.77,116.92 v2(86.39,116.55) ; v2(60.39,96.99) 60.05,96.65 UG1.BG34 ; VRAM3.G3 v2(59.45,150.78) ; VRAM6.V4 v2(86.39,124.06) ; v2(51.64,150.03) VRAM2.M1 ; v2(82.25,147.03) VRAM4.G1 ; v2(62.5,97) UG1.BG37 ; v2(37.09,142.53) 36.71,142.91 VRAM1.U14 v2(36.33,143.28) ; UG1.BE39 v2(63.89,97.71) ; VRAM3.D1 v2(57.2,153.03) ; VRAM6.N12 v2(89.39,118.06) ; UG1.BG28 v2(56.18,96.98) ; UG1.BK1 36.51,94.55 v2(36.47,94.51) ; v2(38.13,92.73) 38.13,92.93 38.35,93.14 UG1.BM3 ; v2(94.66,124.79) VRAM6.G3 ; UG1.BG13 45.35,96.68 v2(45.69,97.02) ; VRAM6.D1 v2(96.89,127.06) ; v2(87.89,125.56) 87.89,125.55 VRAM6.T3 87.89,124.81 v2(87.9,124.81) VRAM6.R3 ; v2(64.59,96.99) UG1.BG40 ; v2(26.58,153.03) VRAM1.D1 ; v2(93.89,101.31) VRAM8.M1
  TOP w0.254: Q13.1 178.28,110.41 178.68,110.81 v1(178.68,111.01) ; JDIM2.60 158.32,39.03 157.38,39.97 v1(157.3,39.97) ; U3.BA38 150.08,131.84 v1(150.14,131.84) ; JDIM2.40 163.32,38.71 v1(163.51,38.89) ; v1(122.27,56.92) 122.07,57.11 JDIM1.197 ; JDIM2.72 155.32,38.23 155.21,38.34 v1(155.21,38.72) ; v1(32.63,87.88) 32.68,87.93 33.42,87.93 34.1,88.6 34.1,89.38 v1(36.37,91.66) ; v1(118.96,129.62) 119.23,129.35 U3.A34 ; v1(125.59,125.07) U3.L29 U3.L30 ; v1(121.3,131.93) 121.3,131.89 U3.D38 121.68,131.49 U3.C37 120.9,130.88 120.37,130.88 U3.B37 ; U3.A30 119.2,126.73 v1(119.07,126.61) ; CN4.A1 290.53,25.2 v1(290.37,25.04) ; v1(108.58,38.71) 108.32,38.46 JDIM2.252 108.32,36.24 108.48,36.09 109.17,36.09 109.32,36.24 JDIM2.248 ; U14.AK4 205.52,31.72 205.86,31.38 v1(205.86,31.18) ; U14.AK46 225.46,31.27 v1(225.49,31.23) ; v1(148.62,42.34) 148.62,43.63 148.57,43.68 JDIM2.99 148.57,46.63 ; v1(157.29,38.67) 157.29,38.66 157.32,38.62 JDIM2.64 ; JDIM2.231 113.57,46.56 ; v1(161.43,38.73) 161.43,38.69 161.32,38.58 JDIM2.48 ; v1(227.6,39.92) 227.6,40.21 U14.M49 ; JDIM1.167 129.57,57.27 129.31,57 129.31,56.52 128.93,56.15 128.93,55.31 127.96,54.33 v1(127.55,54.33) ; JDIM1.94 149.82,49.1 149.39,48.67 149.15,48.67 v1(149.02,48.54) 148.82,48.74 JDIM1.98 148.82,52.07 148.54,52.35 v1(148.54,53.12) ; v1(207.7,25.05) 207.81,24.94 U14.BC10 ; v1(169.25,42.32) 169.57,42.65 JDIM2.15 169.57,46.63 169.62,46.68 ; 172.12,59.77 172.12,59.52 172.07,59.47 JDIM1.5 172.07,57.36 v1(172.42,57.01) ; JDIM1.196 122.32,51.53 v1(122.27,51.58) ; JDIM1.36 164.32,52.3 v1(164.51,52.48) ; R463.1 54.86,19.77 R506.1 ; v2(23.26,131.49) 23.26,131.45 VRAM5.A4 v2(24.01,131.45) ; UG1.AU23 52.35,103.62 v2(52.71,103.26) 53.05,103.6 UG1.AU24 ; U3.AH36 139.19,130.54 v1(139.12,130.54) ; v1(118.86,43.44) 118.86,43.87 119.07,44.08 JDIM2.209 119.07,46.62 ; 166.62,59.77 166.62,59.49 166.57,59.44 JDIM1.27 166.57,57.15 166.62,57.1 166.62,56.23 166.14,55.75 v1(165.81,55.75) 165.29,56.27 165.29,56.81 165.57,57.09 JDIM1.31 165.57,59.46 165.62,59.51 165.62,59.77 ; v1(268.75,43.86) 268.75,44.37 267.43,45.69 ; v1(159.27,55.32) 159.07,55.52 JDIM1.57 159.07,59.37 159.12,59.42 159.12,59.77 ; 147.82,49.08 JDIM1.102 147.82,51.69 147.32,52.19 v1(146.87,52.19) ; U3.AL34 141.71,128.75 141.65,128.75 v1(141.48,128.59) 141.67,128.4 141.71,128.4 141.85,128.26 U3.AL33 ; v1(115.08,38.72) 114.82,38.46 JDIM2.226 ; 159.32,49.12 159.32,49.08 v1(159.55,48.85) ; 159.32,49.12 JDIM1.56 v1(159.32,53.16) ; 159.32,49.12 159.37,49.07 ; v1(155.03,119.62) 155.15,119.62 155.53,120 U3.BJ22 U3.BK22 ; v1(151.93,44.05) 152.07,44.19 JDIM2.85 152.07,46.63 ; U3.AE33 137.48,127.93 v1(137.53,127.93) ; v1(119.02,124.99) 119.06,124.95 U3.A28 ; v1(127.55,55.66) 127.65,55.66 128.32,56.33 128.32,56.98 128.57,57.23 JDIM1.171 ; 111.57,46.56 JDIM2.239 111.57,44.28 110.73,43.44 110.73,42.78 111.55,41.96 v1(111.75,41.96) ; U3.BB30 U3.BB29 150.54,125.23 v1(150.65,125.11) ; v1(227.68,34.36) 227.36,34.36 U14.AD49 ; U3.AU34 146.45,128.76 146.38,128.76 v1(146.21,128.59) 146.41,128.38 146.48,128.38 U3.AU33 ; 110.32,49.18 JDIM1.244 110.32,51.47 110.49,51.64 v1(110.49,52.35) ; 124.07,46.56 JDIM2.189 124.07,43.47 123.71,43.11 123.71,41.94 v1(124.25,41.41) ; v1(166.6,38.72) 166.82,38.5 JDIM2.26 ; U3.BE30 U3.BE29 153.53,124.98 v1(153.65,124.98) ; v1(290.7,31.26) 290.55,31.11 290.55,30.9 290.75,30.7 CN4.A12 ; U3.U37 130.53,131.19 v1(130.46,131.19) 130.78,131.51 U3.U38 ; U3.BT32 v1(160.76,127.81) ; v1(225.06,39.21) 225.2,39.21 U14.P46 ; UG1.K28 55.85,122.58 56.03,122.75 v2(56.03,123.04) ; U3.BF34 153.36,129.24 v1(153.29,129.24) ; v1(146.85,55.83) 146.9,55.83 147.62,56.55 147.62,57.37 147.57,57.42 JDIM1.103 ; v1(171.34,51.66) 171.34,51.66 170.82,51.15 JDIM1.10 ; U3.D6 121.21,108.74 v1(121.21,108.82) ; JDIM1.226 114.82,49.18 ; JDIM2.44 162.32,38.58 v1(162.54,38.8) ; v1(168.79,118.69) 168.79,119.22 Q8.1 ; v1(125.94,42.55) 126.32,42.92 126.32,43.52 126.07,43.77 JDIM2.181 ; v1(152.09,52.86) 152.28,52.86 152.87,52.26 152.87,51.71 152.82,51.66 JDIM1.82 152.82,49.16 ; v2(266.35,45.54) 266.41,45.49 v1(266.41,43.86) ; 112.62,46.61 112.62,46.45 112.57,46.4 JDIM2.235 ; v1(165.77,51.63) 165.82,51.58 JDIM1.30 165.82,48.85 v1(165.83,48.85) 166.57,48.1 JDIM2.27 ; v1(159.55,42.52) 159.55,43.03 159.07,43.51 JDIM2.57 159.07,46.63 ; 163.21,46.79 163.57,46.43 JDIM2.39 ; UG1.AW16 v2(47.1,101.9) UG1.AW15 46.73,102.25 v2(46.4,101.92) 46.07,102.25 UG1.AW14 v2(45.72,101.92) ; v1(147.78,131.85) 147.72,131.85 U3.AV38 ; v2(51.33,99.1) 51.65,99.42 UG1.BC22 ; v1(160.57,43.92) JDIM2.51 160.57,46.52 v1(160.87,46.82) ; U3.AH35 139.19,129.89 v1(139.12,129.89) ; JDIM2.184 125.32,38.77 125.14,38.95 125.14,39.11 124.44,39.8 v1(124.3,39.8) 123.89,39.4 123.89,38.96 124.32,38.53 JDIM2.188 ; UG1.AW23 52.35,102.25 v2(52,101.9) 51.65,102.25 ; v1(148.58,40) 148.82,39.75 JDIM2.98 ; JDIM1.185 125.07,56.23 124.41,55.56 v1(124.22,55.56) ; v1(123.37,130.54) 123.3,130.54 U3.F36 ; v1(149.93,44.02) 150.07,44.16 JDIM2.93 150.07,46.63 ; U7.T16 U7.V16 260.11,49.47 v2(260.05,49.47) ; JDIM2.192 123.32,38.55 123.16,38.72 123.16,39.4 122.52,40.04 v1(122.28,40.04) ; v1(230.91,24.23) 230.43,24.23 v1(230.27,24.39) ; JDIM1.210 118.82,51.2 v1(119.26,51.63) ; U3.J33 124.38,128.09 124.31,128.09 v1(124.16,127.94) 124.48,127.61 U3.J32 ; v1(119.07,108.44) 119.09,108.46 119.56,108.46 U3.A6 ; v1(229.71,13.53) 229.61,13.63 CN5.12 ; v1(129.74,134.76) 129.66,134.68 C37.1 ; v1(162.34,51.78) 162.32,51.77 JDIM1.44 162.32,49.21 ; v1(122.31,52.89) 123.32,51.87 JDIM1.192 ; Q16.4 106.58,105.48 v1(107.42,106.32) ; U31.3 209.66,11.23 v1(209.17,11.71) ; JDIM1.9 171.07,59.41 171.12,59.46 171.12,59.77 ; v1(38.07,77.69) 38.07,77.78 37.69,78.16 QG16.4 ; v1(152.06,39.95) 152.3,39.95 152.82,39.43 JDIM2.82 ; v1(157.17,48.72) 156.97,48.92 156.54,48.92 156.32,49.14 JDIM1.68 ; v1(30.56,77.69) 29.99,78.26 UG3.3 ; v2(51.84,94.75) 51.65,94.55 UG1.BL22 ; v1(111.83,38.81) 111.83,38.77 111.82,38.77 JDIM2.238 ; U3.AE34 137.48,128.58 v1(137.54,128.58) ; v1(112.04,51.86) 111.82,51.64 JDIM1.238 111.82,49.18 ; U3.BK25 U3.BJ25 155.13,122.36 v1(155.11,122.34) ; U3.E38 122.48,131.62 v1(123.11,132.25) ; U14.AC46 225.1,34.72 v1(225.1,34.6) 225.1,34.28 U14.AE46 ; PQ26.1 26.24,47.51 v1(26.45,47.3) ; 71.56,105.58 71.72,105.75 UG1.AP51 ; v1(256.84,28.13) 256.84,26.58 257.44,25.98 C383.1 ; v1(150.14,131.19) 150.08,131.19 U3.BA37 ; U14.BA6 206.27,26.48 v1(205.86,26.88) ; U3.F31 122.84,127.35 123.26,127.77 v1(123.26,127.84) 123.54,127.84 U3.H32 ; 151.82,48.78 JDIM1.86 ; v1(148.12,124.96) 148.15,124.96 148.17,124.98 U3.AW29 U3.AW30 ; C224.1 268.72,42.53 268.83,42.42 v1(268.83,40.64) ; U3.D33 121.21,127.78 v1(121.21,127.71) 120.89,127.39 U3.C31 ; JDIM2.222 115.82,39.92 v1(116.22,40.31) ; Q11.1 177.56,112.7 177.14,113.11 v1(177.04,113.11) ; U3.BD38 152.44,131.84 v1(152.51,131.84) ; JDIM2.218 116.82,38.36 v1(117.16,38.7) ; 46.05,118.35 UG1.T15 UG1.T16 47.46,118.35 v2(47.8,118.02) ; 46.05,118.35 UG1.T14 ; 46.05,118.35 v2(45.7,118.7) ; UG1.AW24 53.08,102.25 ; JDIM2.43 162.57,43.96 v1(162.52,43.91) ; JDIM1.106 146.82,49.08 v1(147.08,48.83) ; U3.F15 123.16,115.04 v1(123.16,115.11) 123.16,115.18 U3.G16 ; v1(124.94,104.43) 124.94,104.66 U3.K1 125.05,105.01 125.05,105.42 U3.K2 125.5,105.86 v1(125.61,105.86) ; UG1.BL25 53.75,94.3 v2(53.74,94.31) ; 168.57,46.66 JDIM2.19 ; 163.62,59.77 163.62,59.54 163.57,59.49 JDIM1.39 ; v2(260.11,50.07) 260.39,49.8 U7.V15 ; v2(59.89,94.81) 59.95,94.74 v2(59.95,94.3) 60.05,94.2 UG1.BL34 ; v1(122.36,41.61) 121.68,42.29 121.68,43.32 122.07,43.71 JDIM2.197 122.07,46.67 ; JDIM1.222 115.82,51.37 116.39,51.93 116.39,53.51 116.42,53.55 116.42,53.72 116.88,54.18 v1(116.91,54.18) ; 151.87,48.73 152.42,48.19 v1(154.14,48.19) ; v1(127.55,51.69) 127.32,51.47 JDIM1.176 ; 219.04,34.74 v1(218.99,34.74) ; 219.04,34.74 219.44,34.34 U14.AE33 ; 219.04,34.74 219.38,35.08 U14.AC33 ; JDIM2.213 118.07,46.43 117.84,46.66 v1(117.84,47.27) 117.51,47.27 117.12,46.88 ; 167.57,46.63 JDIM2.23 167.57,44.09 v1(167.72,43.95) ; v1(119.3,39.98) 119.98,39.3 119.98,38.33 119.82,38.18 JDIM2.206 ; v1(122.27,38.77) 122.27,38.72 122.32,38.67 JDIM2.196 ; v1(127.56,40.04) 127.69,40.04 128.32,39.41 JDIM2.172 ; JDIM1.218 116.82,51.16 116.87,51.21 v1(116.87,51.58) ; JDIM1.52 160.32,51.61 v1(160.31,51.62) ; U3.BM38 v1(156.9,132.09) 156.76,131.95 U3.BL38 ; v1(257.59,24.64) 257.59,23.32 257.85,23.05 259.1,23.05 259.35,22.8 v1(259.35,22.57) ; v1(127.4,44.03) 127.4,44.03 127.57,44.21 JDIM2.175 127.57,46.39 127.9,46.71 128.29,46.71 128.57,46.43 JDIM2.171 ; v1(155.13,44.1) 155.13,44.15 155.07,44.21 JDIM2.73 155.07,46.63 ; v1(151.98,41.91) 152.67,42.6 152.67,42.68 154.07,44.08 JDIM2.77 154.07,46.45 154.12,46.5 154.12,46.81 153.99,46.94 153.41,46.94 153.07,46.61 JDIM2.81 ; v1(135.17,127.93) 135.17,127.94 135.11,127.94 U3.AB33 ; UG1.AG14 46.05,110.66 v2(45.71,111) ; 226.83,44.21 226.83,43.93 U14.F47 ; 113.87,49.13 113.82,49.18 JDIM1.230 113.82,51.57 v1(113.63,51.77) ; U3.AY33 148.64,128.59 v1(148.57,128.59) ; v1(119.27,123.77) 119.27,123.69 U3.A26 ; v1(221.63,28.26) 222.37,27.52 U14.AV39 222.48,27.33 222.66,27.15 U14.AW40 ; v1(146.92,59.8) 146.92,59.8 146.83,59.8 146.57,59.54 JDIM1.107 ; JDIM2.6 171.82,36.23 171.66,36.06 170.98,36.06 170.82,36.22 JDIM2.10 170.82,38.3 171.17,38.65 v1(171.17,38.79) ; v1(132.03,128.58) 132.1,128.58 U3.W33 ; U14.BC19 212.34,24.94 v1(212.17,24.77) ; v1(205.86,26.88) 205.86,26.99 205.52,27.33 U14.AW4 ; v1(205.86,26.88) 205.86,26.71 205.54,26.4 U14.BA5 ; v2(63.9,108.17) 63.9,108.14 UG1.AL39 v2(63.88,107.52) ; U14.AT21 213.45,28.6 v1(213.79,28.26) ; v1(227.55,41.49) 227.55,41.52 227.45,41.62 U14.J48 226.11,41.62 U14.J47 ; Y1.2 266.53,42.46 266.21,42.78 C223.1 ; v1(120.54,40.21) 120.82,39.92 JDIM2.202 ; v1(112.87,38.74) 112.82,38.69 JDIM2.234 ; U14.BE44 224.8,24.45 v1(224.8,24.61) 224.78,24.63 U14.BD43 ; v1(218.65,24.8) 218.32,24.8 U14.BC31 ; v1(110.68,38.87) 110.32,38.51 JDIM2.244 ; v1(157.24,54.56) 156.73,54.05 156.73,51.87 157.32,51.28 JDIM1.64 157.32,49.07 ; UG1.BH5 39.75,95.99 v2(39.4,96.35) ; Q8.4 167.24,120.78 v1(167.02,121) ; UG1.BL37 62.15,94.22 v2(62.07,94.3) 61.94,94.42 v2(61.94,94.83) ; PC444.2 23.17,93.17 v1(23.21,93.21) ; v1(127.97,133.8) 127.76,134.01 C36.1 ; U3.D16 121.5,115.5 121.22,115.22 121.22,115.1 120.89,114.76 U3.C15 120.89,114.58 U3.D14 ; 157.07,46.63 JDIM2.65 157.07,44.09 156.76,43.77 156.76,43.18 157.04,42.9 v1(157.24,42.9) 157.39,42.9 158.07,43.58 JDIM2.61 158.07,46.63 ; v1(120.56,117.47) 120.56,117.51 120.89,117.83 U3.C19 ; v1(127.31,127.93) 127.64,128.26 U3.N33 U3.N34 ; v1(169.33,55.32) 169.57,55.57 JDIM1.15 169.57,59.42 169.62,59.47 169.62,59.77 ; U14.AW46 225.34,27.33 v1(224.94,26.93) 224.94,26.71 U14.BA44 ; JDIM2.56 159.32,38.46 159.5,38.63 v1(159.5,38.74) ; C260.1 257.03,36.86 256.23,37.66 v1(256.23,38.09) ; 158.32,49.12 JDIM1.60 ; v2(66.73,112.42) 66.73,112.32 66.46,112.05 UG1.AE43 ; U3.G28 123.36,124.95 123.03,125.28 123.03,125.55 U3.F29 122.84,125.79 v1(122.5,126.13) ; 165.57,46.63 JDIM2.31 165.57,44.26 v1(165.77,44.07) ; v2(52.7,118.7) 52.35,118.35 UG1.T23 52.32,118.35 v2(51.96,118) 51.65,118.31 UG1.T22 ; v2(41.47,110.28) 41.8,109.95 UG1.AH8 ; JDIM1.180 126.32,51.54 125.8,52.07 125.8,52.68 v1(125.95,52.84) ; CN5.14 230.61,13.73 230.76,13.58 v1(230.76,13.57) ; U3.E34 122.19,129.56 U3.E35 ; U3.E34 121.85,128.56 v1(121.85,128.51) ; U3.E34 v1(122.54,128.53) ; VRAM8.C5 87.52,104 87.88,104.36 88.52,104.36 88.57,104.31 v2(88.67,104.31) ; v1(147.78,131.19) 147.71,131.19 U3.AV37 ; v1(12.57,173.57) 12.9,173.24 PR7.1 ; v1(130.46,129.24) 130.39,129.24 U3.T34 ; JDIM2.90 150.82,38.31 151.05,38.53 151.05,39.43 150.41,40.06 v1(150.08,40.06) ; v1(173.75,45.88) 173.75,46.26 173.27,46.74 171.38,46.74 171.07,46.44 JDIM2.9 ; D49.1 231.69,32.17 v1(231.71,32.19) ; 168.62,46.71 v1(168.98,47.07) ; JDIM2.14 169.82,38.51 169.69,38.65 169.69,39.68 v1(169.26,40.11) ; v2(48.5,118) 48.15,118.35 UG1.T17 ; JDIM2.176 127.32,38.5 v1(127.57,38.75) ; UG1.AJ39 63.51,109.25 v2(63.2,109.55) 63.15,109.55 UG1.AJ38 ; v1(150.93,128.59) 151,128.59 U3.BC33 ; v1(130.46,128.58) 130.39,128.58 U3.T33 ; U14.BC45 v1(224.53,25.25) 224.24,25.25 U14.BB43 ; v1(154.06,52.71) 153.82,52.47 JDIM1.78 153.82,49.08 ; v1(160.9,114) 160.52,114 U3.BT14 ; UG1.AL38 v2(62.5,108.2) UG1.AL37 ; v1(89.04,53.84) 88.94,53.94 PR242.1 ; 115.57,46.56 JDIM2.223 115.57,43.79 115.62,43.74 115.62,42.87 114.9,42.14 v1(114.9,41.46) ; U3.H35 123.81,129.56 v1(124.15,129.91) 124.46,130.21 U3.J36 ; JDIM2.230 113.82,38.69 v1(113.77,38.74) ; UG1.T19 v2(49.22,118.02) 48.89,118.35 UG1.T18 ; v2(45.7,112.4) UG1.AD14 ; UG1.AD14 45.7,113.1 v2(45.66,113.1) ; UG1.AD14 46.05,112.72 v2(46.4,112.37) 46.75,112.72 UG1.AD15 ; v1(150.03,38.74) 149.82,38.54 JDIM2.94 ; v1(146.92,38.72) 146.82,38.63 JDIM2.106 ; U3.BD37 152.44,131.19 v1(152.51,131.19) ; v1(165.75,38.81) 165.75,38.64 165.82,38.56 JDIM2.30 ; v1(109.9,41.76) 109.9,43.46 110.57,44.14 JDIM2.243 110.57,46.49 ; v1(146.95,43.93) 146.57,44.3 JDIM2.107 ; U3.Y38 133.28,131.51 v1(133.61,131.19) 133.54,131.19 U3.Y37 ; U7.AB6 258.63,53.86 v2(258.82,54.04) ; JDIM2.36 164.32,38.35 164.2,38.48 164.2,40.19 v1(164.3,40.3) ; Y1.4 267.74,40.64 267.08,39.98 265.97,39.98 265.68,40.27 v1(265.68,41.09) ; U3.AC38 135.51,131.51 v1(135.18,131.19) 135.25,131.19 U3.AC37 ; JDIM1.168 129.32,49.26 129.15,49.09 128.48,49.09 128.32,49.24 JDIM1.172 128.32,52.19 128.12,52.4 128.12,52.47 127.65,52.94 v1(127.55,52.94) ; CN5.10 228.61,13.73 v1(228.47,13.58) ; C391.1 231.67,23.99 232.08,23.58 234.18,23.58 234.41,23.81 v1(234.41,25.67) 234.41,27.42 234.13,27.7 232.35,27.7 231.67,27.02 C365.1 ; v1(167.77,51.58) 167.82,51.52 JDIM1.22 167.82,49.16 ; v1(212.64,51.45) 212.64,51.48 212.37,51.75 U6.3 211.1,51.75 210.85,52 R160.1 ; v1(139.12,129.24) 139.19,129.24 U3.AH34 U3.AH33 ; v1(124.12,52.89) 124.21,52.89 124.65,52.45 124.65,52.21 124.88,51.97 124.88,51.84 125.32,51.4 JDIM1.184 ; JDIM2.180 126.32,39.1 v1(125.55,39.87) ; v1(223.25,44.2) U14.E42 223.63,43.86 U14.F43 223.69,43.5 223.67,43.48 223.63,43.48 U14.F41 223.3,43.27 v1(222.94,43.63) 222.57,44 U14.E40 ; v1(116.89,52.88) 117.34,52.88 117.82,52.39 JDIM1.214 ; v1(83.2,53.64) 83.51,53.94 PR250.2 ; U3.BT26 U3.BR26 159.56,123.22 v1(159.24,123.54) 159.24,123.47 U3.BP26 ; JDIM2.18 168.82,38.83 v1(167.75,39.91) ; UG1.AU30 UG1.AU31 58,103.65 v2(58.35,104) 58.65,103.69 UG1.AU32 ; v1(148.57,129.24) 148.64,129.24 U3.AY34 ; v1(108.93,51.71) 108.9,51.71 108.32,51.13 JDIM1.252 ; v1(162.3,55.12) 161.77,55.65 161.77,56.64 162.57,57.44 JDIM1.43 162.57,59.48 162.62,59.53 162.62,59.77 ; v1(259.45,37.63) 259.45,38.04 259.89,38.47 259.89,39.23 259.57,39.55 C237.1 258.64,40.26 v1(257.9,40.26) ; v1(120.49,56.01) 121.07,56.6 JDIM1.201 ; U14.BC26 215.73,24.69 v1(215.3,24.69) 215.06,24.94 U14.BC24 ; JDIM1.93 150.07,57.22 150.05,57.19 v1(150.05,56.95) ; U7.Y13 259.19,50.45 v2(259.48,50.74) 259.77,50.45 U7.W13 ; v1(154.87,131.84) 154.8,131.84 U3.BG38 ; 164.57,46.63 JDIM2.35 164.57,43.09 v1(164.05,42.57) ; JDIM1.99 148.57,55.4 v1(148.5,55.32) ; v1(124.12,51.62) 124.32,51.41 JDIM1.188 ; v1(154.07,39.91) 153.82,39.66 JDIM2.78 ; v1(126,55.12) 126.07,55.2 JDIM1.181 ; Y3.2 258.33,28.79 259.53,28.79 259.86,28.46 259.86,27.75 v1(259.89,27.73) ; v1(150.05,52.83) 150.28,52.83 150.82,52.29 JDIM1.90 150.82,49.08 ; U3.BC34 151,129.24 v1(150.93,129.24) ; JDIM2.205 120.07,46.55 ; 259.15,27.08 260.5,25.73 260.5,25.01 260,24.51 C395.1 ; 166.82,49.13 JDIM1.26 ; v1(151.51,54.83) 151.53,54.85 152.54,54.85 153.68,56 153.68,57.01 154.07,57.4 JDIM1.77 ; 156.12,59.77 156.12,59.48 156.07,59.43 JDIM1.69 156.07,56.67 155.29,55.88 v1(155.16,55.88) 154.78,55.88 154.53,56.13 154.53,56.66 155.07,57.21 JDIM1.73 155.07,59.48 155.41,59.82 ; v1(161.33,47.36) 161.57,47.12 JDIM2.47 ; UG1.BE19 49.51,98.05 v2(49.17,97.7) 49.17,97.73 UG1.BE18 ; 51.65,102.25 v2(51.3,101.9) UG1.AW21 ; 51.65,102.25 UG1.AW22 ; UG1.AU14 46.05,103.65 v2(46.4,103.3) UG1.AU15 ; UG1.B2 37.65,128.2 v2(37.29,128.56) ; v2(37.29,128.56) 37.58,128.85 UG1.A2 ; v2(37.29,128.56) 36.95,128.22 UG1.B1 ; UG1.BL31 57.95,94.23 v2(57.85,94.33) 57.75,94.43 v2(57.75,94.83) ; 168.62,59.77 168.62,59.47 168.57,59.42 JDIM1.19 168.57,56.44 168.32,56.18 v1(167.75,56.18) 167.48,56.18 167.18,56.47 167.18,57.04 167.57,57.43 JDIM1.23 167.57,59.41 167.62,59.46 167.62,59.77 ; v1(150.02,42.71) 150.02,42.75 151.07,43.8 JDIM2.89 151.07,46.63 ; v1(153.31,128.59) 153.36,128.59 U3.BF33 ; U14.AH12 208.36,31.85 v1(208.36,31.83) 208.36,31.65 208.77,31.24 U14.AL12 209.14,31.08 209.14,30.33 U14.AN12 ; v1(154.78,48.87) 155.08,48.87 155.32,49.11 JDIM1.72 ; v1(120.56,108.02) 120.56,107.95 U3.C5 ; v1(167.7,38.83) 167.7,38.66 167.82,38.54 JDIM2.22 ; U3.W34 132.1,129.24 v1(132.03,129.24) ; JDIM2.86 151.82,38.41 v1(152.1,38.69) ; U14.AD25 215.34,34.5 215.02,34.82 v1(215.02,34.84) 215.02,34.91 215.38,35.27 U14.AB25 ; v1(220.89,24.79) 220.82,24.85 220.46,24.85 U14.BC35 ; U3.C25 120.57,122.9 120.57,122.98 v1(120.56,123) ; Y2.2 255.31,39.63 255.31,40.83 255.57,41.09 256.74,41.09 257.08,40.74 Y2.4 ; 59.35,103.65 59.39,103.65 v2(59.7,103.96) 60.01,103.65 UG1.AU34 ; JDIM2.2 172.82,38.59 v1(172.61,38.8) ; JDIM1.40 163.32,49.01 v1(163.58,48.76) ; JDIM2.247 109.57,46.55 108.95,47.18 v1(108.42,47.18) 108.35,47.1 108.35,46.69 108.57,46.46 JDIM2.251 ; UG1.AU37 UG1.AU38 63.19,103.31 v2(63.25,103.31) 63.55,103.61 UG1.AU39 63.9,103.3 v2(63.9,103.27) ; v1(113.3,42.8) 113.58,42.8 114.57,43.79 JDIM2.227 114.57,46.56 ; 160.62,59.77 160.62,59.54 160.57,59.49 JDIM1.51 160.57,57.28 160.09,56.8 160.09,56.09 160.42,55.77 v1(160.57,55.77) 160.79,55.77 161.21,56.2 161.21,56.95 161.57,57.31 JDIM1.47 161.57,59.48 161.62,59.53 161.62,59.77 ; U14.AT24 v1(214.45,28.31) ; JDIM2.167 129.57,43.48 129.13,43.04 v1(129.13,42.55) ; 161.32,49.22 JDIM1.48 ; JDIM2.5 172.07,43.6 171.89,43.42 v1(171.89,43.11) ; v1(160.56,38.72) 160.56,38.36 160.32,38.13 JDIM2.52 ; JDIM1.35 164.57,57.19 164.4,57.02 164.4,55.84 164.53,55.71 v1(164.53,55.35) ; UG1.AL14 46.05,107.91 45.77,108.19 v2(45.73,108.19) ; 158.12,59.77 158.12,59.47 158.07,59.42 JDIM1.61 158.07,56.59 157.39,55.91 v1(157.24,55.91) 157.04,55.91 156.76,56.19 156.76,56.8 157.07,57.12 JDIM1.65 157.07,59.45 157.12,59.5 157.12,59.77 ; U3.AJ38 140.37,131.51 v1(140.7,131.19) 140.62,131.19 U3.AJ37 ; U3.L34 126.06,128.91 v1(125.73,128.59) 125.74,128.58 125.81,128.58 U3.L33 ; 121.07,46.61 JDIM2.201 ; U3.AM38 142.73,131.51 v1(143.06,131.19) 142.99,131.19 U3.AM37 ; v1(128.67,34.89) 128.67,35.55 129.32,36.21 JDIM2.168 129.32,38.69 v1(129.38,38.74) ; JDIM1.81 153.07,56.75 152.3,55.97 v1(151.92,55.97) 151.73,55.97 151.47,56.22 151.47,56.72 152.07,57.32 JDIM1.85 ; v1(150.04,55.66) 150.22,55.66 150.9,56.34 150.9,57.14 151.07,57.31 JDIM1.89 ; v1(154.87,131.19) 154.8,131.19 U3.BG37 ; JDIM1.202 120.82,52.76 119.98,53.6 119.98,54.16 119.28,54.86 v1(116.91,54.86) ; JDIM1.14 169.82,52.61 169.51,52.93 v1(169.32,52.93) ; v1(171.44,48.85) 171.82,49.23 JDIM1.6 ; v1(193.04,17.33) 193.77,18.06 Q38.1 ; v2(55.67,94.81) 55.74,94.74 v2(55.74,94.3) 55.85,94.19 UG1.BL28 ; U14.BB41 223.22,25.52 223.01,25.52 v1(222.93,25.44) 222.57,25.08 U14.BC40 ; U14.T49 227.45,38.61 v1(227.67,38.61) ; JDIM1.206 119.82,51.18 120.05,51.4 120.05,52.44 119.57,52.91 v1(119.29,52.91) ; v1(117.22,39.95) 117.42,39.95 117.89,39.48 117.89,38.32 117.82,38.26 JDIM2.214 ; UG1.AU2 v2(36.85,103.65) ; U3.P38 128.56,131.51 v1(128.89,131.19) 128.69,130.99 128.65,130.99 128.53,130.86 U3.P37 ; v1(119.03,38.73) 119.03,38.45 118.82,38.25 JDIM2.210 ; 117.07,46.83 JDIM2.217 ; v1(38.5,90.97) 38.06,90.97 35.83,88.74 v1(35.83,88.17) 35.83,87.08 34.98,86.24 34.98,85.84 34.04,84.91 v1(33.55,84.91) CG80.2 32.78,84.91 32.53,84.65 32.53,84.19 32.25,83.91 29.18,83.91 28.95,84.14 v1(28.95,85.11) 28.95,85.46 29.08,85.59 29.08,87.77 v1(28.95,87.9) 29.14,88.09 31.3,88.09 31.56,87.84 YG1.2 ; JDIM1.189 124.07,57.05 v1(124.23,56.9) ; v1(125.54,132.47) 125.34,132.27 U3.K38 ; C320.2 238.53,33.21 v1(239.16,32.58) 238.83,32.25 C328.1 ; U32.3 248.52,9.55 v1(248.38,9.41) ; v1(237.32,17.5) 237.49,17.68 U27.3 ; v1(118.68,109.86) 118.81,109.99 U3.A9 U3.B9 120.56,109.67 v1(120.56,109.6) ; v2(59.7,108.2) UG1.AL34 ; v2(264.68,53.39) 264.68,53.39 U7.J8 ; U3.F17 123.16,116.61 v1(123.16,116.68) 123.49,117.01 U3.G18 123.61,117.2 124.06,117.2 U3.H18 U3.J18 ; v2(36.38,127.49) 36.43,127.45 UG1.C1 ; Q35.1 194.67,20.03 194.94,19.75 195.12,19.75 v1(195.17,19.7) ; v1(127.53,56.96) 127.53,57.14 127.57,57.18 JDIM1.175 ; v1(227.4,12.97) 227.61,13.19 CN5.8 ; JDIM2.68 156.32,38.39 156.44,38.51 156.44,39.15 155.75,39.84 v1(155.3,39.84) ; U14.AE4 205.34,33.84 v1(205.9,33.29) ; v1(155.65,42.75) 156.07,43.18 JDIM2.69 156.07,46.63 ; U3.G14 123.15,114.27 v1(123.15,114.33) ; UG1.N2 38.09,120.45 v2(38.14,120.4) ; 112.82,49.18 JDIM1.234 ; 168.82,49.2 JDIM1.18 ; JDIM2.185 125.07,46.6 ; U14.A45 U14.A46 ; 215.27,38.09 U14.U24 ; v1(122.25,55.63) 122.68,55.63 123.07,56.02 JDIM1.193 ; JDIM2.102 147.82,38.6 v1(147.95,38.73) ; U3.AB34 135.12,128.58 v1(135.18,128.58) ; 60.75,103.65 UG1.AU36 ; v1(146.88,42.37) 147.09,42.37 147.8,43.07 147.8,44.25 147.57,44.47 JDIM2.103 ; 123.07,46.58 JDIM2.193 ; 109.32,49.18 JDIM1.248
  TOP w0.28: VRAM1.M14 36.71,146.66 37.13,147.07 v2(37.13,147.08) ; 53.05,110.65 UG1.AG24 ; 53.05,110.65 v2(52.69,111.02) 52.35,111.35 UG1.AF23 ; 53.05,110.65 53.2,110.49 53.59,110.49 53.75,110.65 UG1.AG25 ; UG1.AL21 v2(51.3,108.2) 51.65,107.85 UG1.AL22 ; UG1.AL17 47.8,107.5 UG1.AL16 ; UG1.AL17 48.5,107.5 UG1.AL18 ; UG1.AL17 v2(47.8,108.2) UG1.AL16 ; UG1.AF21 50.97,111.35 v2(51.3,111.02) 51.62,111.35 UG1.AF22 ; UG1.AL16 47.33,107.73 46.87,107.73 UG1.AL15 ; UG1.AN18 v2(49.2,106.78) UG1.AN19 ; UG1.AF19 49.2,111 v2(49.15,111) 49.15,110.95 UG1.AG18 ; UG1.AG26 v2(54.8,111) UG1.AF27 ; v2(37.1,145.54) 37.07,145.54 VRAM1.N14 ; UG1.AL19 v2(49.9,108.18) UG1.AL20
  TOP w0.3: UG1.AD37 62.3,112.9 62.7,112.9 UG1.AD38 v2(63.2,112.4) UG1.AD39 v2(63.9,112.4) ; VRAM6.F14 v2(95.41,116.54) ; VRAM6.F14 95.02,116.88 v2(94.64,116.5) 94.27,116.87 VRAM6.G14 ; VRAM6.F14 v2(95.39,117.31) ; UG1.V35 60.75,116.95 v2(60.4,117.3) 60.05,116.95 UG1.V34 ; VRAM1.F3 v2(28.83,151.53) VRAM1.E4 v2(29.58,152.28) ; VRAM1.F3 v2(28.08,150.78) VRAM1.G3 v2(28.83,150.03) VRAM1.H4 v2(29.58,149.28) ; VRAM1.F3 v2(28.83,150.78) ; VRAM4.N1 82.66,151.16 v2(83.04,150.78) 82.66,150.41 VRAM4.M1 ; VRAM4.N1 v2(82.25,151.53) ; VRAM4.N1 82.97,151.49 v2(83.04,151.49) ; VRAM2.N12 v2(43.39,150.78) VRAM2.M12 ; VRAM2.N12 v2(44.14,151.53) VRAM2.P11 v2(44.14,152.28) VRAM2.R12 ; VRAM2.N12 v2(44.14,150.78) VRAM2.M12 ; VRAM2.D3 50.51,144.41 v2(50.89,144.78) ; v2(99.14,102.81) 98.77,103.18 ; 98.77,103.18 v2(99.14,103.56) ; 98.77,103.18 VRAM8.V4 v2(98.39,102.81) ; 97.27,109.18 v2(96.89,108.81) 96.52,109.18 ; 97.27,109.18 VRAM8.T12 ; 97.27,109.18 v2(97.64,109.56) ; v2(41.82,154.63) 42.26,154.18 VRAM2.U14 42.64,154.54 v2(42.64,154.57) 42.67,154.57 VRAM2.V13 ; 50.51,151.16 v2(50.14,150.78) 50.51,150.41 ; 50.51,151.16 VRAM2.N3 ; 50.51,151.16 v2(50.14,151.53) VRAM2.P4 v2(49.39,152.28) ; 50.51,151.16 v2(50.89,150.78) 50.51,150.41 ; v2(99.14,117.31) VRAM6.A13 v2(98.39,118.06) ; v2(72.45,154.62) 72.88,154.19 72.88,154.16 ; v2(34.83,153.03) VRAM1.D12 35.21,152.66 v2(35.58,152.29) ; VRAM8.N3 v2(94.64,102.81) VRAM8.M3 ; VRAM8.N3 v2(95.39,102.81) VRAM8.P4 v2(96.14,103.56) ; VRAM8.N3 v2(94.64,102.06) VRAM8.M3 ; VRAM3.L11 v2(64.7,147.04) ; VRAM3.L11 64.74,147.74 v2(64.74,147.78) ; VRAM3.L11 v2(65.42,147.06) VRAM3.M12 v2(65.45,146.28) VRAM3.N12 v2(65.45,145.53) VRAM3.P11 65.07,145.16 v2(65.45,144.78) VRAM3.R12 ; v2(94.66,124.79) 94.66,124.83 VRAM6.F3 ; VRAM3.G12 65.82,150.41 66.19,150.78 v2(66.19,150.78) 65.82,151.16 VRAM3.F12 ; VRAM3.G12 v2(65.45,150.04) VRAM3.H11 ; VRAM3.G12 65.46,150.77 v2(65.46,150.79) 65.46,150.79 VRAM3.F12 ; VRAM4.M14 72.91,150.41 v2(73.28,150.04) ; v2(97.64,118.06) 97.27,118.43 VRAM6.C12 v2(96.89,118.81) VRAM6.D12 96.52,118.43 v2(96.15,118.05) ; VRAM8.G1 v2(90.14,100.56) VRAM8.F1 v2(89.39,101.31) ; VRAM4.V4 v2(80.75,154.53) ; VRAM4.V4 v2(80,155.28) ; VRAM4.V4 v2(80.75,155.28) ; v2(38.11,118.29) 38.06,118.29 38,118.35 UG1.T2 ; v2(89.37,125.56) 89.74,125.18 VRAM6.N3 89.77,125.15 v2(90.13,124.79) VRAM6.M3 ; VRAM1.G12 35.2,150.41 35.57,150.78 v2(35.58,150.78) 35.2,151.16 VRAM1.F12 ; VRAM1.G12 v2(34.82,150.03) VRAM1.H11 ; VRAM1.G12 v2(34.83,150.78) VRAM1.F12 ; v2(27.33,146.28) VRAM1.M1 v2(26.56,146.26) 26.6,146.26 VRAM1.N1 v2(26.58,145.53) ; v2(81.5,144.78) 81.13,144.41 VRAM4.D3 ; VRAM5.V4 v2(10.51,131.45) ; VRAM5.V4 v2(10.51,130.7) ; VRAM5.V4 v2(11.26,131.45) ; UG1.P36 61.45,119.8 v2(61.75,120.1) 62.1,119.75 UG1.P37 ; VRAM2.F1 52.39,145.53 v2(52.4,145.53) ; VRAM2.F1 52.39,146.28 ; VRAM2.F1 v2(51.64,145.53) ; v2(87.13,110.33) 86.78,110.68 VRAM8.B14 86.44,110.35 v2(86.4,110.35) 86.4,110.32 VRAM8.A13 v2(85.64,109.56) ; VRAM1.E11 34.82,151.55 34.83,151.55 v2(34.84,151.54) 34.84,151.52 VRAM1.F12 ; v2(68.41,127.6) 68.45,127.65 68.45,128.15 UG1.B46 ; v2(86.39,102.06) VRAM8.A2 v2(85.64,101.31) ; v2(41.85,151.57) 41.85,151.54 42.23,151.16 VRAM2.N14 v2(42.64,151.53) ; 89.77,109.18 VRAM8.F12 v2(89.39,108.81) VRAM8.E11 v2(88.64,108.06) ; 89.77,109.18 v2(90.14,109.56) 90.52,109.18 ; 89.77,109.18 v2(90.14,108.81) 90.52,109.18 ; v2(18.73,126.18) 18.56,126 VRAM5.H11 ; v2(28.83,141.78) 29.2,142.16 ; 29.2,142.16 VRAM1.V4 ; 29.2,142.16 v2(29.58,141.78) ; VRAM4.F12 v2(74.75,146.28) VRAM4.G12 74.01,146.29 v2(74.01,146.28) VRAM4.F12 ; VRAM4.F12 v2(74.75,145.53) VRAM4.E11 v2(75.5,144.78) ; VRAM6.R3 v2(88.65,124.8) VRAM6.P4 ; VRAM2.M12 v2(44.14,150.03) VRAM2.L11 ; VRAM5.R12 v2(12.76,125.45) VRAM5.T12 v2(12.01,124.7) ; VRAM5.R12 v2(13.51,124.7) ; VRAM5.R12 v2(13.51,125.45) ; v2(27.33,144.78) VRAM1.R1 v2(26.58,144.03) ; 87.52,109.18 VRAM8.C12 ; 87.52,109.18 v2(87.14,109.56) ; 87.52,109.18 v2(87.89,108.81) 88.27,109.18 ; 93.52,103.18 v2(93.89,102.81) VRAM8.M3 ; 93.52,103.18 VRAM8.L4 ; 93.52,103.18 v2(93.14,103.56) ; 80.38,142.16 v2(80.75,141.78) ; 80.38,142.16 VRAM4.A4 ; 80.38,142.16 v2(80.75,142.53) ; v2(87.15,107.31) VRAM8.C10 ; v2(34.83,143.28) VRAM1.T12 v2(35.58,144.03) VRAM1.R12 v2(34.83,144.78) 34.45,145.16 ; v2(15.01,125.45) VRAM5.M12 ; VRAM5.M12 v2(15.76,125.45) ; VRAM5.M12 v2(15.01,124.7) ; v2(75.48,147.06) 75.13,147.41 VRAM4.H11 ; VRAM2.V2 v2(51.64,155.28) ; UG1.Y35 v2(61.1,115.9) 61.45,115.55 UG1.Y36 ; v2(36.33,141.78) VRAM1.V13 35.58,142.53 v2(35.57,142.53) ; v2(22.15,115.21) 22.13,115.22 VRAM7.T10 ; UG1.P34 60.05,119.75 v2(60.4,120.1) 60.75,119.75 UG1.P35 ; v2(27.33,143.28) VRAM1.U1 v2(26.58,142.53) ; 81.13,153.41 v2(80.75,153.03) 81.13,152.66 ; 81.13,153.41 v2(81.5,153.78) ; 81.13,153.41 VRAM4.T3 ; v2(13.51,130.7) VRAM5.P4 v2(14.26,131.45) ; v2(58.68,145.59) 59,145.91 VRAM3.N3 59.1,145.91 59.41,146.21 59.43,146.21 v2(59.44,146.22) 59.44,146.23 59.44,146.29 VRAM3.M3 ; v2(57.95,152.28) VRAM3.D1 v2(57.95,153.03) ; VRAM3.A2 v2(57.95,155.28) ; VRAM3.A2 v2(57.95,154.53) VRAM3.B1 v2(57.2,154.53) ; VRAM3.A2 v2(58.7,155.28) ; v2(93.14,119.56) VRAM6.H11 ; VRAM6.H11 v2(93.89,119.56) ; VRAM6.H11 v2(93.89,118.81) VRAM6.G12 ; v2(36.33,155.28) VRAM1.A13 v2(35.58,154.53) ; 88.27,109.18 VRAM8.D12 ; 88.27,109.18 v2(88.64,109.56) ; v2(99.14,102.06) VRAM8.V2 v2(99.14,101.31) ; 36.59,123.64 36.66,123.56 36.66,123.56 36.95,123.28 UG1.J1 ; 36.59,123.64 36.64,123.64 UG1.H1 ; 36.59,123.64 v2(36.58,123.64) ; v2(60.95,153.78) 60.95,153.78 VRAM3.C5 ; v2(74,143.28) VRAM4.C12 v2(74.75,144.03) VRAM4.D12 v2(74,144.78) ; VRAM1.N14 36.33,146.28 v2(36.33,146.29) 36.33,146.29 VRAM1.M14 ; UG1.B40 64.25,127.64 v2(64.28,127.64) ; 81.13,151.16 v2(81.5,150.78) 81.13,150.41 ; 81.13,151.16 v2(80.75,150.78) 81.13,150.41 ; 81.13,151.16 VRAM4.N3 ; 81.13,151.16 v2(80.75,151.53) VRAM4.P4 v2(80,152.28) ; VRAM4.C3 81.13,143.66 v2(81.5,143.28) ; VRAM1.A11 v2(34.84,155.34) ; VRAM1.A11 v2(34.09,155.34) ; VRAM1.A11 v2(34.82,154.55) ; VRAM6.R12 88.27,118.44 87.9,118.81 v2(87.89,118.81) VRAM6.T12 ; VRAM6.R12 v2(87.89,118.06) VRAM6.T12 ; VRAM6.R12 v2(88.64,118.81) VRAM6.P11 v2(89.39,118.81) VRAM6.N12 ; v2(60.2,152.28) VRAM3.E4 v2(59.45,151.53) VRAM3.F3 ; v2(34.08,150.03) VRAM1.H11 ; VRAM1.H11 v2(34.08,149.28) ; v2(12.76,123.95) VRAM5.R14 13.13,123.55 v2(12.76,123.18) ; 96.52,109.18 v2(96.14,108.81) 96.14,108.81 VRAM8.P11 v2(95.39,108.81) 95.1,109.1 95.02,109.18 ; 96.52,109.18 v2(96.14,109.56) ; 96.52,109.18 VRAM8.R12 ; VRAM2.R12 v2(44.14,153.03) VRAM2.T12 v2(43.39,153.78) ; VRAM2.R12 43.59,152.48 v2(43.39,152.28) ; VRAM8.V13 98.52,110.18 v2(98.39,110.31) VRAM8.U14 98.08,110.68 v2(98.51,111.11) ; VRAM8.V13 v2(99.3,109.57) ; VRAM8.V13 v2(99.3,110.32) ; UG1.B43 66.35,128.15 66.35,127.7 v2(66.37,127.68) ; v2(79.25,153.78) VRAM4.T5 ; v2(34.83,141.78) 34.45,142.16 ; 34.45,142.16 VRAM1.V11 ; 34.45,142.16 34.09,142.52 v2(34.09,142.52) ; 52.39,146.28 v2(52.4,146.28) ; 52.39,146.28 VRAM2.G1 ; VRAM3.F3 v2(59.45,150.78) ; VRAM3.F3 v2(58.7,150.78) VRAM3.G3 v2(59.45,150.03) VRAM3.H4 ; v2(28.08,153.78) VRAM1.C3 v2(28.83,153.03) VRAM1.D3 v2(28.08,152.28) ; v2(59.45,141.78) 59.82,142.16 ; 59.82,142.16 VRAM3.V4 ; 59.82,142.16 v2(60.2,141.78) ; v2(82.25,144.03) VRAM4.D1 ; v2(83.07,154.53) 82.69,154.16 VRAM4.U1 v2(82.25,154.53) ; 34.45,145.16 VRAM1.P11 ; 34.45,145.16 v2(34.83,145.53) VRAM1.N12 v2(34.83,146.28) VRAM1.M12 v2(34.8,147.06) VRAM1.L11 ; v2(96.14,102.06) VRAM8.R3 v2(96.89,102.81) VRAM8.T3 v2(97.64,102.06) ; v2(75.75,155.58) 75.13,154.96 75.13,154.91 ; v2(96.92,116.53) VRAM6.D14 v2(96.89,117.31) ; v2(22.51,124.68) 22.51,124.71 VRAM5.C12 v2(21.76,125.45) 21.39,125.08 VRAM5.D12 v2(21.01,124.7) ; VRAM6.F3 v2(94.64,125.56) VRAM6.G3 v2(93.89,124.8) VRAM6.H4 v2(93.14,124.06) ; VRAM6.F3 95.35,124.85 95.35,124.81 v2(95.37,124.78) 95.39,124.76 95.44,124.76 VRAM6.E4 v2(96.14,124.06) ; v2(63.78,143.68) 63.8,143.66 VRAM3.T10 ; v2(93.89,108.06) VRAM8.L11 ; VRAM8.L11 93.14,108.05 v2(93.13,108.05) ; VRAM8.L11 v2(93.89,108.81) 94.27,109.18 ; v2(57.94,146.26) 57.94,146.29 VRAM3.M1 v2(57.17,146.26) 57.22,146.26 VRAM3.N1 57.2,145.53 v2(57.17,145.53) ; v2(87.95,120.52) 87.95,120.46 87.52,120.03 VRAM6.T10 ; v2(27.33,152.28) VRAM1.D1 v2(27.33,153.03) ; 90.52,109.18 VRAM8.G12 ; v2(57.95,143.28) VRAM3.U1 57.52,142.91 v2(57.17,142.56) ; v2(43.39,144.78) VRAM2.D12 v2(44.14,144.03) VRAM2.C12 v2(43.39,143.29) ; v2(45.69,143.26) 45.64,143.3 45.64,143.3 45.29,143.66 VRAM2.C10 ; v2(85.64,102.81) 86.02,103.18 ; 86.02,103.18 VRAM8.A4 ; 86.02,103.18 v2(86.39,102.81) ; 72.88,154.16 v2(73.25,154.53) 73.33,154.53 73.63,154.83 VRAM4.V13 ; 72.88,154.16 VRAM4.U14 ; v2(90.09,116.55) 90.16,116.55 90.52,116.91 VRAM6.M14 v2(90.14,117.31) VRAM6.N14 89.47,116.63 v2(89.47,116.55) ; VRAM2.E11 44.51,145.16 ; 44.51,145.16 44.54,145.16 v2(44.88,144.81) ; 44.51,145.16 v2(44.14,145.53) VRAM2.F12 ; v2(85.64,124.81) VRAM6.V4 v2(85.64,124.06) ; v2(52.44,153.01) 52.08,152.66 VRAM2.R1 v2(51.64,153.03) ; v2(38.14,116.35) 38.04,116.25 UG1.W2 ; 59.35,118.35 59.35,118.36 v2(59.71,118.72) 60.05,118.38 60.05,118.35 UG1.T34 ; 59.35,118.35 UG1.T33 ; 59.35,118.35 59.21,118.21 58.79,118.21 58.65,118.35 UG1.T32 ; v2(41.83,144.06) 41.89,144.06 42.24,144.41 VRAM2.D14 42.59,144.08 v2(42.59,144.04) ; v2(50.14,141.78) 49.76,142.16 ; 49.76,142.16 v2(50.14,142.53) ; 49.76,142.16 VRAM2.A4 ; 94.27,109.18 v2(94.64,109.56) 95.02,109.18 ; 94.27,109.18 VRAM8.M12 ; 94.27,109.18 v2(94.64,108.81) 95.02,109.18 ; v2(48.64,153.78) VRAM2.T5 ; v2(65.45,141.78) 65.07,142.16 ; 65.07,142.16 64.76,142.47 v2(64.76,142.53) ; 65.07,142.16 VRAM3.V11 ; 75.13,149.66 VRAM4.L11 ; 75.13,149.66 75.51,149.28 v2(75.51,149.27) ; 75.13,149.66 v2(75.5,150.03) ; 75.13,149.66 v2(74.75,150.03) VRAM4.M12 ; VRAM6.C10 97.27,119.93 v2(97.64,120.31) ; VRAM1.V2 27.7,142.16 v2(28.08,142.53) ; v2(96.89,126.31) VRAM6.D1 v2(96.14,126.31) ; 50.51,150.41 v2(50.14,150.03) VRAM2.L4 v2(49.39,149.28) ; 50.51,150.41 VRAM2.M3 ; UG1.BL16 47.45,94.31 v2(47.49,94.35) ; VRAM5.F12 v2(19.51,125.45) VRAM5.G12 v2(19.51,124.7) VRAM5.F12 ; VRAM5.F12 v2(20.26,125.45) ; v2(63.86,154.01) 63.86,153.95 64.04,153.76 64.04,153.62 64.26,153.41 VRAM3.C10 ; v2(47.73,94.83) UG1.BJ17 ; v2(72.48,151.53) 72.85,151.16 VRAM4.N14 ; v2(59.45,154.53) VRAM3.A4 v2(60.2,155.28) ; VRAM4.V13 74.03,155.3 v2(74.03,155.6) ; VRAM4.V13 73.28,155.26 v2(73.28,155.6) ; v2(28.08,155.28) VRAM1.A2 v2(27.33,154.53) VRAM1.B1 v2(26.58,154.53) ; VRAM4.C10 75.88,143.66 76.31,143.23 76.31,142.57 v2(76.46,142.42) ; UG1.BE15 v2(47.11,97.71) ; v2(33.08,143.92) 33.35,143.66 VRAM1.T10 ; VRAM4.E4 80.38,145.16 v2(80.75,145.53) 81.13,145.91 ; v2(28.83,143.28) 28.8,143.28 28.45,143.63 VRAM1.T3 ; VRAM7.D3 12.78,110.89 12.78,110.96 v2(12.77,110.96) 12.38,110.57 VRAM7.C3 ; v2(72.45,144.06) 72.5,144.06 72.86,144.41 VRAM4.D14 72.88,144.41 73.21,144.08 v2(73.21,144.04) ; v2(82.25,141.78) VRAM4.A2 v2(81.5,142.53) ; v2(76.49,152.8) 75.88,153.41 VRAM4.T10 ; v2(100.35,118.72) 100.35,118.81 v2(100.33,119.5) ; v2(44.89,149.27) 44.89,149.28 VRAM2.L11 ; v2(60.2,149.28) VRAM3.H4 ; VRAM3.H4 60.13,149.97 v2(60.2,149.97) ; v2(96.89,111.08) 96.89,111.08 96.52,110.71 VRAM8.R14 96.6,110.6 v2(96.89,110.31) ; v2(93.9,110.28) 94.27,110.65 VRAM8.M14 94.64,111.06 v2(94.64,111.06) ; v2(98.39,124.81) VRAM6.A4 v2(99.14,124.06) ; v2(36.33,153.03) VRAM1.D14 ; 91.27,103.18 v2(90.91,102.83) VRAM8.G3 v2(90.14,102.06) VRAM8.F3 v2(89.39,102.81) VRAM8.E4 ; 91.27,103.18 VRAM8.H4 ; 91.27,103.18 v2(91.64,103.56) ; v2(91.64,119.56) VRAM6.L11 ; VRAM6.L11 v2(90.88,119.57) ; VRAM6.L11 90.92,118.83 v2(90.92,118.8) 90.89,118.8 VRAM6.M12 90.87,118.08 v2(90.91,118.08) ; v2(33.17,154.01) 33.17,153.98 33.31,153.84 33.31,153.8 VRAM1.C10 ; VRAM4.A11 75.13,142.16 ; 75.13,142.16 v2(75.5,141.78) ; 75.13,142.16 v2(74.75,142.54) ; VRAM4.G1 v2(83,146.28) VRAM4.F1 ; v2(96.14,125.56) VRAM6.D3 v2(96.89,124.81) VRAM6.C3 v2(97.64,125.56) ; v2(87.89,123.32) 87.89,123.38 87.59,123.68 VRAM6.T5 ; v2(43.39,141.78) 43.01,142.16 ; 43.01,142.16 VRAM2.A13 ; 43.01,142.16 42.64,142.53 v2(42.59,142.53) 42.59,142.58 VRAM2.B14 42.26,142.94 v2(42.62,143.29) ; v2(51.64,127.68) 51.64,127.68 51.65,127.7 51.65,128.15 UG1.B22 ; v2(11.84,115.3) 11.91,115.37 11.97,115.37 VRAM7.C10 ; VRAM2.L11 v2(44.89,150.03) ; UG1.T30 v2(57.6,118.7) UG1.T31 ; v2(36.33,151.53) VRAM1.F14 36.76,151.16 v2(37.14,150.78) 36.76,150.41 VRAM1.G14 ; v2(58.7,142.53) 58.32,142.16 VRAM3.V2 ; 95.02,109.18 VRAM8.N12 ; v2(50.14,155.28) VRAM2.V4 ; VRAM2.V4 v2(49.39,155.28) ; VRAM2.V4 v2(50.14,154.53) ; VRAM4.N12 v2(74.75,150.78) VRAM4.M12 ; VRAM4.N12 v2(74.75,151.53) 75.13,151.91 ; VRAM4.N12 v2(74,150.78) VRAM4.M12 ; 81.13,150.41 v2(80.75,150.03) VRAM4.L4 v2(80,149.28) ; 81.13,150.41 VRAM4.M3 ; v2(99.19,118.81) 99.14,118.81 VRAM6.A11 ; VRAM8.G14 v2(90.14,111.06) VRAM8.F14 v2(89.41,110.33) ; 72.88,142.91 73.21,142.58 v2(73.21,142.54) 73.24,142.54 73.63,142.16 ; 72.88,142.91 VRAM4.B14 ; 72.88,142.91 73.21,143.24 v2(73.21,143.26) ; v2(42.66,150.04) 42.29,150.41 VRAM2.M14 42.26,150.46 41.95,150.77 41.95,150.77 v2(41.93,150.79) ; v2(44.89,153.03) VRAM2.T10 45.46,153.21 45.97,153.21 v2(46.01,153.17) ; v2(73.23,145.53) 72.88,145.89 72.88,145.91 ; VRAM1.L11 v2(34.08,147.78) ; VRAM1.L11 34.45,147.38 v2(34.1,147.03) ; v2(22.69,127.08) 22.67,127.08 22.61,127.01 22.57,127.01 VRAM5.C10 ; VRAM6.C5 v2(97.65,123.3) ; v2(52.43,151.49) 52.35,151.49 VRAM2.N1 ; v2(27.33,150.03) 27.33,150.03 VRAM1.G1 v2(26.58,150.78) VRAM1.F1 v2(27.33,151.53) ; v2(42.98,127.73) 43.01,127.76 43.01,127.83 43.25,128.07 UG1.B10 ; v2(60.2,147.78) VRAM3.L4 v2(59.45,147.78) ; VRAM4.P11 75.13,151.91 ; 75.13,151.91 v2(74.75,152.28) VRAM4.R12 ; 81.13,145.91 VRAM4.F3 ; 81.13,145.91 81.51,146.28 ; v2(66.95,141.78) 66.57,142.16 ; 66.57,142.16 VRAM3.V13 ; 66.57,142.16 v2(66.2,142.53) ; v2(59.45,143.28) VRAM3.T3 ; VRAM3.T3 v2(58.7,144.03) ; VRAM3.T3 v2(59.44,144.03) 59.41,144.03 59.07,144.37 VRAM3.R3 v2(59.45,144.79) 59.82,145.16 VRAM3.P4 ; v2(97.06,107.06) 97.06,107.47 VRAM8.T10 v2(96.89,108.06) ; v2(99.14,125.56) 98.77,125.93 ; 98.77,125.93 v2(98.39,126.31) VRAM6.B1 98.38,127.04 v2(98.41,127.04) ; 98.77,125.93 v2(99.14,126.31) ; 98.77,125.93 VRAM6.A2 ; v2(81.5,152.28) 81.13,152.66 ; 81.13,152.66 VRAM4.R3 ; VRAM1.T3 v2(28.08,144.03) ; VRAM1.T3 v2(28.83,144.03) 28.77,144.03 28.45,144.35 VRAM1.R3 28.77,144.72 v2(28.83,144.72) 28.83,144.73 29.2,145.1 VRAM1.P4 ; v2(35.59,153.77) 35.24,153.41 VRAM1.C12 ; v2(42.62,145.55) VRAM2.F14 v2(41.87,146.3) 42.22,146.66 VRAM2.G14 ; 50.51,146.66 v2(50.89,146.28) 50.69,146.09 50.51,145.91 VRAM2.F3 ; 50.51,146.66 VRAM2.G3 ; 50.51,146.66 v2(50.13,147.04) VRAM2.H4 v2(49.39,147.78) ; VRAM2.A2 51.26,142.16 ; 51.26,142.16 v2(50.89,142.53) ; 51.26,142.16 v2(51.64,141.78) ; v2(87.14,124.81) VRAM6.T3 ; v2(29.58,147.79) 29.58,147.78 VRAM1.L4 ; VRAM4.F1 v2(82.25,145.53) ; VRAM4.F1 v2(83,145.53) ; VRAM3.T12 v2(66.2,144.03) VRAM3.R12 ; VRAM3.T12 v2(65.45,144.03) 65.44,144.04 65.81,144.41 VRAM3.R12 ; VRAM3.T12 v2(65.45,143.28) ; v2(81.5,155.28) 81.88,154.91 ; 81.88,154.91 VRAM4.V2 ; 81.88,154.91 v2(82.25,155.28) ; v2(36.33,144.81) 36.33,144.79 VRAM1.R14 ; UG1.T22 51.65,118.35 v2(51.3,118.7) UG1.T21 ; v2(28.83,154.58) 28.87,154.58 VRAM1.A4 v2(29.58,155.28) ; v2(89.38,127.07) VRAM6.N1 90.12,127.04 v2(90.12,127.08) VRAM6.M1 90.49,126.68 90.12,126.31 v2(90.11,126.31) ; v2(98.4,118.81) 98.77,119.18 VRAM6.A11 ; v2(87.14,102.06) VRAM8.C3 ; VRAM6.G12 v2(94.64,118.81) VRAM6.F12 95.02,118.43 v2(94.64,118.06) 94.64,118.06 94.27,118.43 VRAM6.G12 ; v2(51.64,144.03) 51.84,144.23 VRAM2.D1 ; v2(44.89,141.78) 44.51,142.16 ; 44.51,142.16 v2(44.14,142.53) ; 44.51,142.16 VRAM2.A11 ; VRAM4.G3 81.13,146.66 ; 81.13,146.66 v2(80.74,147.05) VRAM4.H4 v2(80,147.78) ; 81.13,146.66 81.5,146.28 ; v2(83.06,153.01) 82.7,152.66 VRAM4.R1 v2(82.25,153.03) ; v2(66.95,144.78) VRAM3.R14 ; v2(67.76,145.61) 67.62,145.61 VRAM3.N14 v2(66.95,146.28) VRAM3.M14 67.34,146.66 v2(67.71,146.29) ; VRAM5.T5 12.22,130.16 12.22,129.09 12.28,129.02 12.28,128.91 v2(12.3,128.91) ; UG1.T25 53.85,118.26 54.36,118.26 UG1.T26 54.77,118.67 v2(54.77,118.72) UG1.T27 ; v2(87.89,127.06) VRAM6.R1 v2(88.64,126.31) ; v2(57.95,144.78) VRAM3.R1 57.2,144.03 v2(57.17,144.03) ; 86.02,125.93 VRAM6.V2 ; 86.02,125.93 v2(86.39,125.56) ; 86.02,125.93 86,125.93 v2(85.61,126.32) ; VRAM2.C5 48.75,143.92 v2(48.39,143.92) ; v2(65.44,153.04) VRAM3.D12 65.83,152.66 v2(66.2,152.29) ; v2(85.64,117.31) VRAM6.V13 v2(86.39,118.06) ; 72.88,145.91 VRAM4.F14 ; 72.88,145.91 72.55,146.24 v2(72.45,146.24) 72.46,146.25 72.46,146.28 72.84,146.66 VRAM4.G14 ; v2(66.2,154.53) VRAM3.A13 v2(66.95,155.28) ; VRAM3.H11 64.71,150.02 v2(64.71,150.03) ; VRAM3.H11 v2(64.71,149.3) ; VRAM4.A13 73.63,142.16 ; 73.63,142.16 v2(74,141.78) ; UG1.T20 v2(49.9,118.7) UG1.T19 ; VRAM2.V13 v2(43.38,155.44) ; VRAM2.V13 v2(42.63,155.44) ; v2(86.39,127.09) 86.39,127.06 VRAM6.U1 v2(87.14,126.31) ; UG1.AD36 61.45,112.75 v2(61.1,112.4) 60.75,112.75 UG1.AD35 ; v2(64.56,99.08) 64.25,98.77 UG1.BE40 ; v2(58.7,153.78) VRAM3.C3 v2(59.45,153.03) VRAM3.D3 v2(58.7,152.28) ; v2(67.72,153.06) VRAM3.D14 v2(66.95,153.03) ; v2(12.75,127.05) 12.75,126.94 VRAM5.T10 ; 75.13,154.91 VRAM4.V11 ; 75.13,154.91 v2(74.75,154.53) ; v2(87.14,118.81) VRAM6.T12 ; v2(74,153.78) VRAM4.T12 v2(74.75,153.03) VRAM4.R12 ; v2(96.89,101.31) VRAM8.R1 96.87,100.58 v2(96.87,100.51) ; v2(21.72,123.16) 21.72,123.22 21.38,123.56 VRAM5.D14 21.71,123.91 21.72,123.91 v2(21.75,123.94) ; v2(51.64,151.53) VRAM2.N1 ; VRAM2.N1 52.04,151.16 v2(52.42,150.78) 52.04,150.41 VRAM2.M1 ; v2(66.95,151.53) VRAM3.F14 v2(67.71,151.55) ; v2(85.64,108.06) VRAM8.A11 v2(86.39,108.81) ; v2(95.39,111.09) 95.02,110.71 VRAM8.N14 95.39,110.31 v2(95.39,110.3) ; UG1.T24 53.05,118.35 v2(52.7,118.7) ; v2(67.81,150.76) 67.67,150.76 VRAM3.G14 ; v2(41.86,153.03) 42.23,152.66 VRAM2.R14 v2(42.64,153.03) ; v2(66.2,153.78) 65.83,153.41 VRAM3.C12 ; v2(51.64,154.53) VRAM2.U1 52.07,154.16 v2(52.45,154.53) ; v2(30.33,153.79) VRAM1.C5 ; v2(87.9,110.35) 87.94,110.35 VRAM8.D14 88.27,110.71 87.92,111.06 v2(87.92,111.11) ; v2(64.7,155.28) VRAM3.A11 ; v2(83.03,142.55) 82.68,142.91 VRAM4.B1 v2(82.25,142.53) ; v2(98.45,108.82) 98.45,108.75 VRAM8.V11 v2(99.14,108.06) ; v2(97.64,117.31) VRAM6.B14 v2(98.44,116.51) ; v2(36.33,153.78) VRAM1.B14 v2(37.13,154.58) ; UG1.P30 56.92,120.08 v2(56.87,120.08) UG1.P29 ; v2(71.43,114.29) 71.57,114.15 UG1.AB51 ; 50.51,153.41 v2(50.14,153.03) 50.51,152.66 ; 50.51,153.41 VRAM2.T3 ; 50.51,153.41 v2(50.89,153.78) ; UG1.P27 55.48,120.08 v2(55.52,120.08) UG1.P28 ; v2(97.64,104.3) VRAM8.T5 ; v2(95.35,100.52) VRAM8.N1 ; VRAM8.N1 v2(95.39,101.31) ; VRAM8.N1 95.02,100.9 v2(94.64,100.53) 94.27,100.9 VRAM8.M1 ; VRAM1.M3 28.83,146.28 v2(28.83,146.27) 28.83,146.25 28.48,145.91 VRAM1.N3 28.45,145.88 v2(28.08,145.51) ; v2(98.39,101.31) VRAM8.U1 v2(98.39,100.49) ; UG1.A26 54.4,128.9 54.4,129.05 v2(54.11,129.34) ; v2(30.39,143.86) 30.15,143.86 VRAM1.T5 29.95,143.59 30.25,143.29 v2(30.34,143.29) ; v2(44.88,155.28) VRAM2.V11 v2(44.14,154.53) ; v2(88.64,117.31) VRAM6.R14 ; v2(21.58,129.7) 22.13,130.26 VRAM5.C5 ; UG1.T35 60.75,118.35 v2(61.1,118.7) 61.45,118.35 UG1.T36 ; v2(88.64,102.06) 88.35,102.35 VRAM8.D3 ; v2(50.89,152.28) 50.51,152.66 ; 50.51,152.66 VRAM2.R3 ; VRAM3.F12 v2(65.42,151.56) VRAM3.E11 v2(64.7,152.28) ; UG1.T28 v2(56.2,118.7) UG1.T29 ; VRAM4.R12 v2(74,152.28) ; v2(87.89,101.31) VRAM8.D1 ; v2(95.39,126.31) VRAM6.F1 94.65,127.05 v2(94.64,127.05) 94.63,127.05 VRAM6.G1 v2(93.89,126.31) ; VRAM2.H11 v2(44.86,147.06) ; 81.51,146.28 v2(81.57,146.28) ; v2(73.25,153.03) 72.88,152.66 VRAM4.R14 72.85,152.66 v2(72.48,153.03) ; v2(67.75,154.58) VRAM3.B14 v2(66.95,153.78) ; v2(86.37,119.53) VRAM6.V11 v2(85.64,118.81) ; v2(42.89,108.86) 42.89,108.91 42.55,109.25 UG1.AJ9 ; v2(44.2,146.29) 44.15,146.29 ; 44.15,146.29 44.13,146.29 VRAM2.G12 v2(43.39,146.28) VRAM2.F12 ; 44.15,146.29 VRAM2.F12 ; v2(86.41,100.53) 86.77,100.89 VRAM8.B1 v2(86.39,101.31) ; v2(99.14,119.56) VRAM6.A11 ; v2(50.89,143.28) 50.51,143.66 VRAM2.C3 ; v2(52.42,142.53) 52.42,142.55 52.06,142.91 VRAM2.B1 v2(51.64,142.53) ; VRAM6.L4 v2(91.64,124.06) ; UG1.AL33 v2(59.7,108.2) ; VRAM8.H11 v2(90.92,108.09)
  TOP w0.305: v2(12.01,132.2) VRAM5.T3 12.38,131.83 v2(12.76,131.45) VRAM5.R3 v2(13.51,132.2) ; v2(22.51,123.93) 22.53,123.93 VRAM5.B14 22.95,123.58 v2(23.29,123.92) 23.29,123.99 VRAM5.A13 23.99,124.69 v2(24.01,124.69) ; PQ18.1 213.18,60.24 v1(212.85,60.24) ; VRAM7.P4 20.66,111.28 v2(21.02,110.92) 21.04,110.91 21.04,110.88 VRAM7.R3 ; PU8.28 115.75,153.61 v1(114.81,152.68) 114.01,151.88 PU8.4 ; v2(12.79,118.44) 12.79,118.44 VRAM7.D14 12.74,119.18 v2(12.74,119.18) ; v2(16.53,126.21) 16.15,125.83 VRAM5.L11 ; L13.1 89.16,26.08 89.3,26.08 89.63,25.75 v1(89.67,25.75) ; VRAM5.N1 14.3,133.67 v2(14.3,133.74) ; VRAM5.N1 14.63,133.36 v2(15.01,133.74) 15.38,133.36 VRAM5.M1 15.72,133 v2(15.77,133) ; VRAM5.N1 v2(14.26,132.95) ; v1(178.42,118.11) 178.83,117.7 179.11,117.7 179.33,117.47 Q9.1 ; R463.1 54.59,20.03 53.1,20.03 52.46,20.67 v1(52.46,21.15) ; v2(24.03,110.92) 24,110.95 23.97,110.95 VRAM7.V4 23.97,111.62 v2(23.97,111.66) ; Q51.1 74.58,13.11 74.34,13.35 74.34,14 73.93,14.41 Q51.4 ; VRAM7.F14 14.63,118.78 v2(14.26,119.15) ; VRAM7.F14 14.63,118.74 v2(14.28,118.38) ; VRAM7.F14 14.63,118.8 v2(15.03,119.19) 15.38,118.84 VRAM7.G14 ; v2(14.26,123.95) VRAM5.N14 14.26,123.2 v2(14.26,123.18) ; v2(21.01,109.41) VRAM7.R1 v2(21.01,108.66) ; v2(68.31,126.28) 68.31,126.61 UG1.D46 ; VRAM5.V13 v2(11.26,123.95) VRAM5.U14 11.22,123.17 v2(11.19,123.17) ; VRAM5.V13 10.5,123.95 v2(10.36,123.95) ; VRAM5.V13 10.52,124.7 v2(10.36,124.7) ; VRAM5.N12 14.26,125.45 v2(14.26,125.45) VRAM5.P11 13.88,125.83 v2(13.51,125.45) ; VRAM5.N12 14.63,125.08 v2(15.01,124.7) ; VRAM5.N12 v2(15.01,125.45) ; v2(12.78,133.76) 13.13,133.4 VRAM5.R1 v2(12.76,132.95) ; UG1.K2 37.91,122.55 v2(38.12,122.34) ; VRAM2.F3 v2(50.14,145.53) VRAM2.E4 ; VRAM7.F3 v2(14.24,110.93) VRAM7.E4 v2(13.51,111.66) ; VRAM7.F3 14.63,110.57 v2(14.99,110.93) VRAM7.G3 15.38,110.57 v2(15.74,110.93) 16.09,111.28 VRAM7.H4 v2(16.51,111.66) ; VRAM7.F3 v2(14.99,110.18) ; v1(214.45,28.31) 214.41,28.26 v1(213.79,28.26) ; U29.3 249.42,11.73 v1(249.73,11.42) ; v2(87.89,125.56) 87.89,125.55 87.9,125.55 VRAM6.R3 ; PU4.4 164.68,163.34 PU4.32 166.42,161.61 PU4.28 ; UG1.D24 53.36,127.06 v2(53.4,127.06) ; v2(15.74,109.43) 15.38,109.07 VRAM7.G1 15.03,108.68 15.02,108.68 15.01,108.66 v2(14.97,108.66) 14.97,108.69 14.94,108.71 14.94,108.73 14.63,109.03 VRAM7.F1 14.63,109.05 v2(14.26,109.43) ; v2(21.03,118.38) 21.03,118.43 VRAM7.R14 21.03,119.14 v2(21.03,119.16) ; v2(18.79,132.92) 18.79,132.98 VRAM5.G1 19.14,133.33 v2(19.53,133.72) 19.88,133.37 VRAM5.F1 20.25,132.97 v2(20.25,132.94) ; PC170.2 91.6,56.84 v1(92.82,56.84) ; PU5.28 135.25,161.56 v1(134.32,162.49) 133.52,163.29 PU5.4 ; v2(15.76,126.2) VRAM5.L11 ; VRAM5.L11 v2(15.76,125.45) ; VRAM7.A11 10.9,116.53 v2(11.29,116.92) ; VRAM7.A11 10.88,116.53 v2(10.51,116.16) ; VRAM7.A11 v2(10.51,116.91) ; 49.71,127.25 49.71,127.37 v2(49.43,127.65) 49.55,127.78 UG1.B19 ; v2(20.28,117.63) 19.97,117.33 19.93,117.28 VRAM7.N12 ; VRAM7.M3 19.13,110.57 v2(19.5,110.95) 19.88,110.57 VRAM7.N3 v2(20.24,110.18) ; v2(16.5,130.7) 16.13,131.07 VRAM5.L4 15.8,131.42 v2(15.78,131.42) 15.38,131.81 VRAM5.M3 ; v2(22.52,110.95) 22.52,110.95 22.13,110.56 VRAM7.T3 ; v2(10.51,126.2) VRAM5.V11 v2(11.23,125.48) ; v2(70.9,114.44) 71.28,114.44 v2(71.43,114.29) ; v2(70.9,114.44) 70.61,114.15 UG1.AB49 ; v2(70.9,114.44) 70.55,114.8 UG1.AA49 ; v2(65.45,154.54) 65.44,154.54 VRAM3.A11 65.07,154.91 v2(65.45,155.28) ; VRAM7.D3 13.5,110.17 v2(13.52,110.17) ; v2(13.51,117.66) 13.13,117.29 VRAM7.D12 13.13,117.28 v2(12.76,116.91) ; v2(47.4,127.63) 47.45,127.68 UG1.B16 ; v2(11.21,119.21) VRAM7.B14 v2(12.01,118.41) ; v2(18.03,130.67) 18.38,131.03 VRAM5.H4 18.39,131.08 v2(18.76,131.45) 19.13,131.83 VRAM5.G3 19.18,131.83 v2(19.55,132.2) 19.88,131.87 VRAM5.F3 v2(20.26,131.45) VRAM5.E4 ; VRAM5.N3 v2(14.26,131.45) ; VRAM5.N3 v2(15.01,131.45) VRAM5.M3 ; VRAM5.N3 v2(15.01,132.2) VRAM5.M3 ; v2(13.49,109.43) 13.49,109.39 VRAM7.D1 12.74,109.43 v2(12.75,109.43) ; VRAM7.A2 10.84,109.78 v2(10.44,110.18) ; VRAM7.A2 10.51,109.41 v2(10.45,109.41) ; VRAM7.A2 v2(11.24,109.43) VRAM7.B1 ; VRAM7.T3 v2(21.77,110.17) 21.4,110.53 VRAM7.R3 ; VRAM7.T3 21.76,110.91 VRAM7.R3 ; v2(19.51,108.66) 19.88,109.03 VRAM7.N1 ; v2(22.52,132.19) 22.5,132.19 VRAM5.C3 ; v2(71.39,107.66) 70.95,107.66 70.85,107.77 ; v2(24,116.9) 24,116.9 VRAM7.V11 23.63,116.5 23.29,116.16 v2(23.27,116.16) ; v1(144.78,162.67) 144.66,162.67 143.96,163.37 PU3.4 ; PU6.28 155.65,161.56 PU6.32 153.91,163.29 PU6.4 ; v2(11.24,110.93) VRAM7.A4 v2(10.51,111.66) ; v2(22.51,108.66) VRAM7.U1 v2(22.51,109.41) ; v1(130.97,124.79) 131.25,124.79 131.64,125.18 U3.V29 U3.V30 ; VRAM7.N12 20.28,116.89 v2(20.28,116.88) 20.63,116.53 VRAM7.P11 ; VRAM7.N12 19.88,117.24 v2(19.53,116.88) 19.13,117.28 19.13,117.28 v2(18.76,116.91) 18.76,116.91 VRAM7.L11 ; v2(15,123.09) 15,123.2 VRAM5.M14 15.38,123.61 v2(15.75,123.98) ; v2(21.02,132.19) VRAM5.D3 ; v1(240.94,55.46) 240.91,55.44 240.91,54.91 240.91,54.91 240.93,54.9 240.93,54.89 241.31,54.51 241.44,54.4 PC180.1 ; v2(10.51,132.95) VRAM5.V2 ; VRAM5.V2 10.88,132.58 v2(10.51,132.2) ; VRAM5.V2 v2(11.26,132.95) VRAM5.U1 11.26,133.7 v2(11.26,133.77) ; VRAM7.N14 19.88,118.74 v2(19.53,118.38) 19.13,118.78 VRAM7.M14 ; v2(24.05,118.38) 24.01,118.34 23.94,118.34 VRAM7.V13 23.28,117.68 v2(23.28,117.63) ; v2(20.26,125.45) VRAM5.E11 v2(21.01,126.2) ; v2(73.27,151.58) 73.27,151.55 VRAM4.N14 72.54,150.82 v2(72.54,150.77) 72.54,150.75 VRAM4.M14 ; v2(68.22,124.9) 68.22,125.12 UG1.F46 ; v2(18.79,116.12) 18.38,116.53 VRAM7.L11 ; U3.AA30 U3.AA29 134.03,125.59 134.03,124.69 v1(134.12,124.59) ; v2(11.98,112.42) 12.36,112.03 VRAM7.C5 ; PU3.32 144.76,162.51 145.59,161.68 PU3.28 ; Q15.1 178.75,104.86 v1(178.75,104.26) ; U8.14 18.08,49.06 v1(17.9,49.24) ; VRAM7.F12 14.98,117.63 v2(15.03,117.63) 15.37,117.28 VRAM7.G12 15.78,116.89 v2(15.78,116.88) ; VRAM7.P11 20.99,116.18 v2(20.99,116.18) ; VRAM7.P11 20.68,116.53 20.72,116.58 v2(21.03,116.88) 21.38,117.24 VRAM7.R12 21.43,117.28 21.76,117.62 v2(21.76,117.63) 21.78,117.63 VRAM7.T12 v2(22.54,116.88) ; VRAM7.L11 18.03,116.18 v2(18.03,116.13) ; v2(20.24,124) 20.24,123.94 VRAM5.F14 v2(19.51,123.2) VRAM5.G14 ; VRAM7.L4 18.38,111.31 18.04,111.66 v2(17.99,111.66) ; VRAM5.A2 v2(23.27,132.94) 23.23,132.94 22.88,133.29 VRAM5.B1 22.87,133.33 v2(22.49,133.71) ; VRAM5.A2 v2(24.01,132.95) ; VRAM5.A2 23.25,132.2 v2(23.25,132.15) ; v2(11.31,117.66) 10.93,118.03 VRAM7.A13 v2(10.51,118.41) ; 51.86,127.14 51.86,127.45 v2(51.64,127.68) ; v2(13.51,116.16) 13.88,116.53 VRAM7.E11 ; v2(22.5,112.42) 22.5,112.4 VRAM7.T5 ; v2(70.13,110.21) 70.4,109.95 UG1.AH49 ; v2(24.01,126.2) VRAM5.A11 v2(23.26,125.45) ; v1(128.55,124.89) 129.01,124.89 129.28,125.16 U3.R29 U3.R30 ; VRAM7.C3 12.34,110.53 v2(11.99,110.18) ; v1(177.7,115.83) Q9.4 ; v2(21.01,133.7) VRAM5.D1 21.39,133.33 v2(21.78,132.95) ; v2(22.53,119.16) 22.53,119.14 22.88,118.79 VRAM7.U14 22.53,118.43 v2(22.53,118.38) ; UG1.B13 45.35,127.79 v2(45.48,127.66) 45.48,127.53 v2(45.02,127.08) ; v2(96.14,119.56) VRAM6.E11 v2(95.39,118.81) 95.02,118.43 ; VRAM7.C12 12.01,117.66 v2(12.01,117.66) ; VRAM1.D14 v2(37.11,153.06) ; v2(19.52,109.43) 19.13,109.05 VRAM7.M1 ; v2(23.25,110.17) VRAM7.V2
  TOP w0.356: U3.BJ18 155.41,116.85 v1(155.15,116.59)
  TOP w0.381: v1(48.43,47.34) 48.09,47.34 PR287.2 ; v1(197.86,37.61) 197.86,37.1 198.55,36.41 199.19,36.41 R283.1 ; R75.2 v1(164.97,122.83) ; v1(166.58,126.88) 167.51,127.81 C55.2 ; R469.1 57,19.93 R467.1 56.66,20.27 v1(56.66,20.87) ; R559.1 277.18,16.21 v1(276.55,16.21) ; v1(40.03,35.95) 39.99,35.91 39.99,35.91 39.66,35.57 PC228.2 ; Q52.1 80.68,13.11 80.94,13.37 R592.1 ; RG42.1 52.24,85.4 v1(51.64,84.81) ; QG8.1 26.16,90.62 v1(26.13,90.59) ; PC123.2 101.47,91.29 v1(101.45,91.27) ; v1(261.83,60.07) 260.36,60.07 260.04,59.74 R131.2 ; Q51.1 75.7,13.11 76.09,12.72 v1(76.35,12.72) R590.1 ; v1(241.32,53.02) PQ22.1 ; C52.1 175.31,132.77 v1(175.13,132.58) ; v1(176.74,128.06) 176.99,128.06 D10.2 ; v1(230.91,24.23) C391.1 ; C404.2 88.74,23.31 88.84,23.41 88.86,23.41 v1(88.87,23.42) 88.87,23.42 88.88,23.42 88.91,23.42 89.22,23.74 89.49,23.74 R429.2 ; D40.2 67.39,36.1 C259.1 67.39,37.68 v1(67.18,37.9) ; v1(89.43,134.03) 89.34,133.94 RG2.1 ; C356.2 51.06,28.74 C348.2 ; C356.2 51.28,27.68 51.66,28.06 v1(51.66,28.08) ; C356.2 51.06,26.61 C363.2 ; PC273.2 121.18,18.85 v1(120.71,18.39) 120.04,19.06 PC272.2 ; v1(116.64,26.21) 116.64,26.56 116.29,26.91 PR369.2 ; R354.2 58.09,32.06 58.55,31.61 R353.2 58.71,31.58 v1(58.71,30.89) ; v1(176.5,137.31) 176.71,137.1 Q4.1 ; R464.2 65.68,20.79 v1(65.55,20.79) ; R48.1 115.53,130.25 v1(115.35,130.07) ; Q29.1 64.5,36.73 65.04,36.19 v1(65.04,35.78) ; R214.2 199.23,41.82 R218.1 198.98,42.24 v1(198.98,42.82) ; v1(20.14,96.1) 20.27,96.22 PC112.2 ; v1(188.31,39.11) 188.83,39.11 190.1,37.84 Q78.1 ; C60.1 168.73,126.84 v1(169.28,127.4) ; R44.1 v1(178.73,131.61) ; R97.1 166.11,108.43 166.11,110.23 v1(165.92,110.42) ; C387.2 7.29,24.67 v1(7.66,24.3) ; C430.1 90.33,20.84 v1(90.6,20.84) ; v1(88.21,134) 88.03,133.82 88.03,132.97 RG6.1 ; PC239.2 155.46,28.19 154.98,28.67 v1(154.98,28.85) ; v1(234.71,22.9) 234.29,22.9 234.23,22.84 C407.2 ; C426.2 87.93,20.87 v1(88.58,20.87) ; C400.2 8.5,23.99 8.35,24.15 7.82,24.15 v1(7.66,24.3) ; PR267.2 41.75,51.92 v1(41.7,51.98) ; R202.1 200.05,43.59 v1(200.32,43.32) ; v1(88.41,148.05) 88.75,148.05 89.4,148.69 R24.1 ; C408.2 51.41,22.53 v1(51.41,21.98) ; PQ1.1 7.58,172.29 v1(7.05,171.77) ; R591.1 77.54,14.33 78.52,14.33 Q52.4 78.75,14.56 v1(78.75,15.04) ; PC259.2 99.5,24.38 98.83,24.38 v1(98.75,24.45) 98.38,24.45 PC260.2 ; v1(7.66,24.3) 7.12,23.76 C402.2 ; Q17.1 178.83,101.72 v1(179.65,100.9) v1(180.35,100.9) ; v1(17.25,99.93) 16.76,100.42 QG4.1 ; v1(71.45,40.77) 71.17,40.5 R231.2 71.17,39.9 R257.1 ; v1(164.84,126.91) 164.59,126.66 R65.1 ; v1(91.04,34.04) 90.91,34.04 Q32.1 ; R128.2 262.63,58.94 v1(262.88,59.2) 263.13,58.94 R127.2 ; Q2.1 77.16,161.78 v1(76.78,162.17) ; v1(195.75,43.65) 195.84,43.56 R203.1 196.42,42.61 R207.1 ; v1(178.73,129.58) C53.2 C54.2 ; C365.1 231.09,26.79 v1(230.91,26.61) ; PR265.2 39.49,51.87 v1(39.62,51.99) 39.99,52.37 PC185.2 ; v1(39.31,22.52) 39.71,22.92 R431.2 ; R120.2 11.15,68.96 v1(11.11,68.96) 10.57,69.5 R119.2 ; C476.2 201.69,14.43 201.69,13.01 v1(201.85,12.86) 201.85,12.79 202.37,12.27 202.38,12.27 C488.2 ; R77.2 v1(164.94,121.86) ; PC40.2 143.88,166.42 v1(143.88,166.67) ; R1135.1 242.83,21.77 242.54,22.06 242.16,22.06 241.71,22.51 v1(241.71,22.81) ; v1(34.23,34.92) 34.46,35.14 34.46,35.31 C272.1 ; v1(89.67,25.75) 89.84,25.58 R410.1 ; v1(8.27,71.47) 8.18,71.47 7.58,70.87 R117.1 ; R69.1 166.96,124.32 v1(166.96,124.24) ; PC147.2 14.84,62.58 v1(14.22,62.58) ; v1(164.79,128.24) 164.24,127.69 C56.2 ; v1(91.46,134.03) 91.8,133.68 QG2.1 ; R43.1 115.53,132.33 v1(115.4,132.46) ; R26.1 93.87,146.96 v1(93.72,146.81) ; PC274.2 162.27,18.54 PC275.2 ; PC445.2 23.55,99.58 v1(23.77,99.58) ; Q54.1 v1(12.15,9.31) ; C275.2 70.33,35.92 70.58,36.17 v1(70.58,36.57) ; Q12.1 168.95,110.52 v1(168.47,110.99) ; R87.2 178.1,114.85 177.7,115.25 v1(177.7,115.83) ; R28.1 95.9,147.11 v1(96.24,146.78) ; v1(26.08,14.49) 26.27,14.69 C466.2 ; D53.2 84.56,19.01 84.79,18.77 84.79,18.28 84.85,18.22 84.85,17.74 D55.2 ; R589.1 71.93,13.01 v1(71.93,12.72) ; C270.1 284.83,36.36 v1(284.59,36.61) ; v1(159.78,22.23) 159.74,22.18 PC267.2 ; v1(28.72,44.7) 29.06,44.7 29.45,44.32 PQ29.1 ; v1(84.85,136.08) 83.56,136.08 82.93,135.46 QG1.1 ; R49.1 v1(178.73,130.6) ; v1(191.32,31.68) 190.79,31.14 Q34.1 191.41,31.08 191.66,31.08 v1(191.93,31.35) ; v1(204.87,9.31) 204.87,10.08 205,10.2 C489.2 ; v1(51.39,24.08) 50.85,24.62 C390.2 ; v1(202.91,18.38) 202.91,17.83 202.49,17.41 202.49,17.39 Q41.1 ; Q21.4 7.5,58.65 7.12,58.27 v1(6.8,58.27) ; v1(48.2,27.17) 48.67,26.7 C362.2 ; R30.1 97.94,147.75 v1(98.42,147.26) ; v1(157.93,28.81) 157.93,28.64 157.57,28.28 PC238.2 ; U3.BR38 v1(159.62,132.5) ; v1(98.17,27.8) 98.17,27.52 97.97,27.32 PC245.2 PC251.2 ; v1(198.73,52.06) 198.73,51.49 EC3.1 C163.1 ; v1(176.55,125.82) 176.96,125.82 D11.2 ; Q53.1 v1(9.48,9.31) ; PC276.2 v1(141.02,17.74)
  TOP w0.4: 66.72,112.36 v2(66.73,112.42)
  TOP w0.508: v1(231.87,28.97) 231.67,29.17 R378.1 R385.2 ; PR85.2 181.5,158.64 v1(181.32,158.83) ; v1(104.59,156.79) 104.46,156.66 PC74.2 ; v1(185.65,52.92) 185.65,53.09 185.75,53.19 PQ21.1 ; C432.1 C433.1 232.02,19.76 v1(232.02,19.12) ; PD4.2 75.77,51.27 76.87,50.16 v1(77.04,50.16) ; v1(180.85,149.52) 181.43,149.52 PQ11.1 ; v1(220.78,18.41) 220.47,18.73 C441.2 ; v1(113.1,103.96) 113.55,103.51 R105.1 R109.2 ; PC41.2 153.77,166.29 v1(153.77,166.77) ; v1(179.52,158.73) 180.09,158.16 PQ8.1 ; C351.1 v1(271.8,27.07) ; v1(270.27,14.93) 269.97,14.93 269.61,15.28 C465.2 ; PC16.2 18.07,169.63 v1(18.36,169.92) 18.82,170.38 PC10.2 ; v1(31.45,43.35) 31.35,43.35 PQ28.1 ; PU9.4 172.04,148.11 171.53,148.61 v1(171.32,148.61) ; v1(14.29,70.7) 13.99,71.01 C100.1 13.59,69.92 C101.1 ; v1(172.76,151.86) 172.99,151.63 PU9.2 ; v1(198.3,44.81) 198.36,44.76 R195.1 ; C331.2 37.48,31.78 v1(38.49,31.78) 38.23,31.52 38.23,30.5 C336.2 ; C62.1 176.56,125.15 v1(176.52,125.1) ; PC87.2 v1(108.59,148.91) ; C337.2 280.6,30.17 v1(281.04,29.72) ; R548.1 v1(205.13,15.6) 205.13,15.31 204.81,14.99 Q49.1 ; R126.2 268.69,58.99 v1(268.9,59.2) ; C455.1 R557.1 256.79,16.42 256.53,16.17 v1(256.41,16.17) ; v1(93.68,77.52) 92.96,76.79 PR151.2 ; Q21.1 9.3,60.53 v1(9.42,60.42) ; v1(198.44,33.29) 198.9,32.84 R345.1 ; v1(258.29,12.84) 258.31,12.82 258.31,12.65 C487.2 ; C428.1 C437.1 245.42,19.4 v1(245.1,19.4) ; R466.1 C444.1 255.67,19.22 v1(256.08,19.63) ; v1(262.22,27.52) 262.41,27.52 262.79,27.14 R399.1 ; PC121.2 95.9,91.9 PC122.2 95.71,92.17 v1(96.22,92.68) ; R586.1 206.18,14.4 v1(206.28,14.49) 206.28,14.12 R970.1 ; v1(279.49,14.8) 278.95,15.33 R561.2 ; R158.2 272.18,52.39 v1(272.52,52.05) ; v1(182.77,60.57) 182.77,60.56 182.26,60.05 PQ19.1 ; C341.1 265.96,28.52 v1(265.99,28.48) ; C205.1 198.72,45.5 v1(198.3,45.5) 198.09,45.71 R190.1 ; v1(253.59,28.31) 253.59,28.53 R376.1 ; v1(257.9,40.26) Y2.4 ; R347.2 268.73,32.55 v1(268.98,32.81) ; RG37.2 31.24,90.34 v1(31.21,90.36) ; PQ13.1 112.76,140.11 v1(112.76,139.41) ; R629.1 252.93,9.57 v1(252.57,9.92) ; v1(49.8,17.31) 48.85,17.31 C453.1 ; PR363.1 PC229.1 39.11,31.16 v1(38.96,31.31) ; PR193.2 99.73,60.35 100.86,59.22 100.86,57.47 ; v1(180.85,153.59) 181.04,153.77 PQ9.1 ; PC86.2 100.9,145.91 v1(100.83,145.84) ; Y1.2 266.19,41.74 265.68,41.23 v1(265.68,41.09) ; PC162.1 PC149.2 33.55,58.92 33.04,59.43 v1(33.04,59.6) ; D13.2 178.45,121.82 v1(178.64,121.63) ; v1(117.04,128.12) 116.86,128.3 R62.1 ; QG16.1 35.49,79.63 35.63,79.77 v1(35.63,80.13) 35.55,80.2 CG83.1 ; v1(167.99,160.11) 168.04,160.16 PC63.2 ; v1(176.73,122.62) 176.89,122.46 C66.1 ; v1(71.65,59.6) 71.65,59.43 72.15,58.92 PC153.2 PC166.1 ; v1(221.56,58.79) 220.83,58.06 PC155.2 ; v1(280.08,14.52) 280.91,14.52 C474.1 281.17,14.8 280.74,15.23 v1(280.13,15.23) ; R99.2 112.63,105.71 v1(112.57,105.76) ; EC5.1 236.6,32.35 v1(237.1,32.35) ; v1(25.22,53.97) 24.54,53.97 PC173.2 ; v1(260.88,40.22) 260.8,40.15 260.8,39.98 C238.2 ; PC246.2 160.55,27.86 160.98,28.29 v1(160.98,28.79) ; U2.2 67.19,160.9 66.91,161.19 C23.1 66.15,161.19 v1(65.89,160.92) ; PQ23.1 183.98,52.76 v1(184.04,52.7) ; PC21.2 7.08,167.38 v1(6.8,167.66) ; v1(31.21,90.36) 31.21,90.82 31.38,90.99 RG158.1 ; v1(31.21,90.36) 31.18,90.34 RG154.1 ; v1(257.85,36.26) 257.83,36.26 257.32,36.77 C260.1 ; C224.1 268.72,43.82 v1(268.75,43.86) ; v1(81.4,12.72) 81.4,12.77 81.43,12.79 R592.1 ; U9.4 249.36,51.83 v1(248.5,51.83) ; R397.1 268.9,27.07 v1(268.9,27.85) ; RG38.2 16.88,91.4 v1(16.5,91.02) ; v1(240.67,41.33) 240.81,41.47 R210.1 ; R155.2 v1(277.11,53.38) ; RG57.1 40.42,84.02 40.13,84.32 v1(40.13,84.93) ; PC60.2 147.36,160.98 147.9,160.44 v1(148.1,160.44) ; Q20.1 7.91,62.79 7.89,62.81 7.89,63.03 v1(7.51,63.41) ; v1(52.22,59.6) 52.9,58.92 PC151.2 PC164.1 ; PR133.2 93.05,96.43 v1(92.73,96.11) ; C157.2 v1(277.11,52.37) ; v1(254.73,26.61) 254.48,26.36 254.31,26.36 R405.2 C386.2 ; v1(36.79,85.08) 36.73,85.03 RG53.1 37.11,84.37 RG56.2 ; PQ14.1 108.74,96.78 108.65,96.68 107.79,96.68 107.76,96.65 v1(107.47,96.65) ; C175.1 181.42,48.71 C186.2 C197.2 181.42,46.1 v1(181,45.68) 180.77,45.45 C207.2 180.77,43.95 C210.1 ; v1(177.18,86.96) 177.31,87.09 R114.1 ; v1(47.49,78.22) 47,78.22 CG84.2 ; v1(239.79,55.54) 239.3,56.04 PR198.1 ; C287.2 37.14,33.95 v1(37.14,34.54) ; R334.1 236.42,33.87 237,34.46 v1(237,34.59) ; PC2.2 14.64,173.35 14.27,173.73 v1(14.01,173.73) ; D12.2 179.11,125.18 v1(179.21,125.08) ; R144.2 253.96,56.73 v1(253.33,56.73) ; v1(87.15,15.59) D74.2 87.27,16.42 87.27,17.27 D57.2 ; RG20.1 v1(31.26,99.95) ; R31.2 139.12,137.74 v1(139.8,137.05) ; v1(221.76,15.63) 221.76,15.98 R545.1 ; v1(209.17,11.71) 209.32,11.87 R605.1 ; C342.1 280.67,29.15 v1(280.7,29.17) ; SW1.4 88.19,39.11 88.7,38.6 v1(88.7,37.17) 88.7,36.67 88.19,36.16 SW1.3 ; PC48.2 116.06,164.82 115.7,165.19 v3(115.7,165.87) ; R432.2 198.34,23.28 v1(198.3,23.32) ; v1(257.59,24.64) 257.44,24.79 C383.1 ; C395.1 260.07,24.22 v1(260.6,24.22) ; CG82.2 RG74.1 v1(26.28,79.48) ; R143.2 251.85,57.24 v1(251.96,57.35) ; R447.2 191.15,21.26 v1(191.15,20.92) ; v1(270.17,52.87) 270.44,52.61 R157.2 ; RG34.2 24.27,91.29 v1(24.28,91.28) ; v1(60.12,33.22) 60.12,32.68 R350.2 ; Q7.1 v1(178.11,119.79) ; v1(223.64,57.88) 223.55,57.97 PC442.2 ; R487.1 207.21,18.48 207.28,18.41 v1(207.27,18.41) ; PQ33.1 38.15,37.01 v1(38.28,37.14) ; C492.1 205.82,9.56 v1(205.57,9.31) ; v1(30.33,98.27) 30.33,98.48 29.89,98.92 RG23.2 ; R299.2 281.21,34.19 v1(280.79,33.77) ; v1(230.01,38.17) 230.01,38.16 R271.2 ; v1(165.92,110.42) R92.2 ; v1(284.91,38.09) 285.11,38.09 285.44,37.76 C250.1 ; v1(164.56,166.69) 164.56,166.37 PC39.2 ; v1(91.28,17.09) 91.56,16.81 91.56,16.49 D73.2 ; R212.1 v1(242.97,41.42) ; v1(173.48,153.38) 174.01,152.85 PR101.2 ; v1(9.8,43.88) 10.29,44.37 C212.2 10.77,44.31 11.8,44.31 C213.2 ; C340.2 264.81,28.69 v1(264.92,28.59) ; v1(31.13,92.52) 31.53,92.52 RG31.1 ; v1(168.33,158.48) 168.07,158.73 PR78.1 ; RG14.1 v1(31.29,103.07) ; C143.1 99.42,63.81 98.89,64.34 v1(98.72,64.34) 98.44,64.06 C121.1 ; v1(192.64,30.55) 192.55,30.46 Q34.1 ; v1(213.33,13.28) R574.2 ; v1(252.69,16.23) C456.1 ; v1(266.41,43.86) 266.21,43.66 C223.1 ; v1(195.78,45.3) 195.22,44.75 R196.1 ; PC68.1 176.01,160.1 176.03,160.12 PC65.2 176.59,159.59 v1(176.7,159.48) 176.96,159.48 PR74.1 ; U12.4 236.8,35.6 v1(237.18,35.22) ; RG52.1 34.17,83.95 34.01,83.79 v1(34.01,83.76) 33.78,83.76 33.41,84.12 CG81.2 ; v1(169.08,134.79) 168.95,134.66 C48.2 ; C228.2 250.85,41.59 251.33,42.07 v1(251.33,42.64) ; v1(28.77,42.51) 29.24,42.51 29.36,42.63 PC217.2 ; v1(245.1,22.77) 245.36,23.03 R434.1 ; v1(180.86,18.28) 180.86,18.06 180.33,17.53 PC279.2 ; YG1.4 29.16,84.89 v1(28.95,85.11) ; 21.11,61.12 22.02,61.12 22.15,60.99 PC142.1 ; v1(14.2,63.24) 14.89,63.93 14.89,64.94 14.38,65.44 13.43,65.44 D15.2 ; v1(283.64,5.2) 283.26,5.57 D72.2 ; C288.2 54.09,33.7 v1(54.49,34.1) ; RG50.2 58.28,85.01 59.07,84.22 v1(59.07,82.19) ; v1(57.37,82.19) 56.97,82.19 56.29,82.86 UG2.4 ; CG2.2 36.22,160.76 36.9,160.09 D9.2 38.4,160.09 v1(38.53,160.21) ; R3.2 R6.2 60.52,163.59 v1(61.33,162.78) ; v1(232.71,16.15) 232.71,16.9 R533.1 ; v1(245.15,18.05) 244.84,18.05 Q37.1 ; PC158.1 91.15,58.85 90.64,59.36 v1(90.53,59.36) ; PC91.2 12.08,138.22 v1(12.21,138.09) 11.72,137.6 CG5.2 ; CG3.2 44.12,164.04 v1(43.76,164.41) ; R112.1 175.28,87.19 v1(175.43,87.04) ; v1(192.73,32.25) 192.88,32.1 193.84,32.1 194.02,31.92 R355.1 ; v1(256.84,28.13) Y3.2 ; v1(81.3,59.53) 81.3,59.43 81.81,58.92 PC154.2 PC167.1 ; v1(238.68,41.26) 238.68,41.97 R208.1 R209.1 ; 5.97,86.44 PC124.2 ; v1(260.5,11.62) 260.5,11.73 259.98,12.24 R610.1 ; C191.2 99.21,47.69 98.61,47.1 v1(98.61,45.93) ; R12.1 43.5,161.58 v1(43.5,161.99) 43.55,162.04 CG4.2 ; R116.1 179.62,87.76 v1(179.97,87.42) ; C442.1 202.91,18.59 v1(202.91,18.38) ; PC93.2 175.27,145.45 v1(175.91,146.09) ; v1(96.74,75.66) 96.76,75.66 97.34,76.24 PC132.2 ; v1(19.14,104.46) 18.93,104.67 RG10.2 ; v1(212.79,48.73) 212.79,49.99 R1150.1 ; C431.1 233.95,20.67 v1(234.46,20.67) 234.7,20.43 C438.1 ; C414.2 256.93,22.39 v1(256.36,22.39) ; R148.2 252.84,55.69 v1(253.33,55.69) 253.98,55.69 R147.2 ; v1(208.7,18.38) 208.76,18.43 R497.1 ; v1(200.77,24.44) 200.44,24.44 199.81,25.06 R417.1 ; C493.2 258.46,9.59 v1(258.77,9.9) ; v1(47.57,166.36) 47.57,165.79 47.98,165.37 48.3,165.37 C1.1 ; R33.2 175.06,137.81 v1(175.06,136.98) ; PC165.1 PC152.2 62.43,58.92 v1(61.87,59.48) ; v1(24.52,95.07) 24.52,95.07 24.85,94.73 QG7.1 ; PC161.1 PC148.2 23.99,59.51 23.36,60.14 v1(22.98,60.14) ; v1(259.89,27.73) 259.89,27.6 259.36,27.08 Y3.4 ; v1(83.76,16.3) 83.76,16.42 83.47,16.72 Q40.1 83.58,17.57 D55.2 ; v1(137.61,160.85) 137.47,160.99 PC61.2 ; R398.1 260.36,27.16 v1(260.72,27.52) ; v1(29.64,83.18) 29.7,83.24 QG11.1 ; Q1.1 40.69,162.33 40.46,162.57 v1(40.46,163.29) ; C344.1 87.91,29.11 88.41,28.61 v1(88.41,28.6) 88.9,28.11 C353.2 ; R23.1 91.62,147.71 v1(91.81,147.52) ; v1(42.85,54.43) PC175.2 ; PC186.2 89.73,52.24 88.94,53.02 88.94,53.74 v1(89.04,53.84) ; Y2.2 256.03,38.29 v1(256.23,38.09) ; PC179.2 82.31,53.76 v1(82.12,53.57) ; RG26.1 v1(33.34,96.9) ; v1(176.32,20.23) 175.87,19.78 PC270.2 175.65,19.79 PR413.2 ; PC168.2 184.39,57.9 v1(184.45,57.96) ; v1(166.29,20.54) 166.29,20.02 PC271.2 ; PR370.2 159.72,28.32 160.18,28.79 v1(160.27,28.79) ; R536.2 212.09,18.38 v1(212.01,18.46) 211.98,18.49 EC6.1 ; PC42.2 134.03,165.93 v1(133.57,166.39) ; v1(165.85,113.45) 165.74,113.35 Q10.1 ; SPAD2.1 197.55,15.63 R501.1 198.02,18.5 v1(198.32,18.2) ; PR261.2 45.97,52.27 v1(45.92,52.32) ; R88.2 v1(162.83,114.19) ; v1(178.2,41.06) 178.52,40.74 R224.2 C236.2 ; v1(266.13,27.5) 266.51,27.12 R396.1 ; v1(241.71,22.81) 241.39,23.14 U19.4 ; v1(32.31,81.28) 32.21,81.38 QG11.4 ; R364.1 198.32,30.52 198.24,30.6 v1(198.2,30.6) ; YG1.2 32.34,87.88 v1(32.63,87.88) ; R387.2 v1(272.82,27.12) ; C484.1 v1(267.99,11.45) ; v1(31.98,37.77) 31.98,37.53 C263.1 C264.1 ; v1(162.13,28.79) 162.48,28.79 PC241.2 ; v1(96.66,157.37) 96.59,157.3 96.59,157.08 R22.2 ; v1(69.23,61.04) 69.43,61.24 70.64,61.24 70.64,61.25 PC137.1 ; v1(33.2,54.43) PC174.2 ; PC293.2 v1(153.54,9.78) ; v1(214.14,18.51) R476.1 ; PC200.1 91.78,49.89 v1(91.47,50.19) 91.2,49.92 PC199.2 ; EC1.1 166.35,126.64 v1(166.58,126.88) ; PC163.1 PC150.2 43.22,58.92 42.71,59.43 v1(42.71,59.5) ; v1(9.69,57.23) 10.23,57.23 10.74,57.74 10.74,58.47 D19.2 D17.2 10.86,60.79 D16.2 ; R539.1 v1(219.96,15.61) 219.99,15.58 R578.1 ; PC17.2 v1(6.8,168.37) ; PC176.2 53.12,54.43 v1(52.39,55.16) ; D75.2 82.84,12.72 v1(82.77,12.72) ; PC78.2 v1(116.82,155.34) ; v1(71.81,54.43) PC178.2 ; R193.1 192.48,45.69 192.06,46.11 v1(191.74,46.11) ; v1(268.83,40.64) Y1.4 ; v1(26.03,98.31) 25.58,98.76 RG146.1 ; R593.1 82.11,13.04 v1(82.11,12.72) ; C495.2 v1(284.83,7.03) ; C237.1 259.35,39.74 v1(259.89,40.28) ; QG6.1 29.02,95.33 v1(29.41,95.33) ; v1(96.36,30.34) 96.41,30.3 97.13,30.3 97.46,30.63 C335.1 97.45,30.99 C330.1 ; v1(250.84,13.83) 250.74,13.83 250.31,14.27 C470.2 ; v1(151.96,24.15) 151.96,23.58 PR405.1 ; v1(254.53,39.44) C257.2
  IN1 w0.086: v1(259.66,42.41) 259.07,42.41 v1(258.95,42.28)
  IN1 w0.102: v2(42.19,107.54) 42.21,107.56 42.21,107.71 42.04,107.88 41.59,107.88 41.52,107.94 41.4,107.94 v2(41.37,107.96)
  IN1 w0.14: v2(41.37,107.96) 40.96,107.55 40.8,107.55 v2(40.79,107.53)
  IN2 w0.102: 94.3,33.32 98.36,33.32 98.97,33.94 104.88,33.94 105.18,33.65 111.5,33.65 112.22,32.93 148.62,32.93 148.94,33.25 166.23,33.25 166.66,33.68 176.35,33.68 180.13,37.45 185.62,37.45 187.44,35.63 v1(187.97,35.63) 188.19,35.85 188.19,36.49 187.95,36.73 187.37,36.73 185.88,38.22 179.76,38.22 176,34.47 166.23,34.47 165.74,33.97 148.55,33.97 148.29,33.71 112.64,33.71 111.87,34.49 105.66,34.49 105.48,34.67 98.55,34.67 v1(98.28,34.4) 98.27,34.41 v1(97.61,34.41) 97.33,34.13 94,34.13 93.49,33.63 91.45,33.63 v1(91.04,34.04) 85.51,34.04 85.32,33.85 82.85,33.85 81.37,32.37 76.77,32.37 75.5,31.1 73.85,31.1 73.52,30.76 70.49,30.76 68.79,32.46 66.83,32.46 65.78,33.51 62.53,33.51 61.85,32.84 60.51,32.84 v1(60.12,33.22) 60.12,33.25 56.26,37.11 55.36,37.11 53.26,39.21 52.86,39.21 52.51,39.56 52.51,40.02 52.95,40.46 52.95,41.6 52.47,42.07 52.47,42.84 53.6,43.96 53.6,45.68 52.2,47.07 50.49,47.07 48.96,48.6 48.26,48.6 47.99,48.33 47.99,47.78 v1(48.43,47.34) 49.34,46.43 51.79,46.43 52.89,45.33 52.89,44.24 51.72,43.07 51.72,41.76 52.24,41.24 52.24,40.8 51.75,40.31 51.75,39.32 52.6,38.46 52.97,38.46 54.96,36.47 56.05,36.47 59.37,33.15 59.37,32.75 59.83,32.29 61.98,32.29 62.57,32.88 65.07,32.88 v1(66.05,31.9) 66.35,31.9 66.52,31.73 68.36,31.73 70.06,30.03 73.87,30.03 74.21,30.36 75.77,30.36 77.01,31.6 81.76,31.6 83.27,33.11 86.62,33.11 v1(86.72,33.22) 87.44,33.22 v1(87.75,32.91) 87.76,32.9 93.88,32.9 94.3,33.32
  IN2 w0.16: v2(40.79,107.53) 40.77,107.55 40.61,107.55 40.16,108 40.03,108 v2(40,108.03)
  IN2 w0.2: v2(38.34,107.79) 38.61,107.92 39.88,107.92 v2(40,108.03) ; v2(41.37,107.96) 41.35,107.94 41.32,107.94 40.93,107.55 40.8,107.55 v2(40.79,107.53)
  IN2 w0.508: v1(94.88,158.15) 92.38,158.15 v1(91.66,158.87)
  IN4 w0.086: v1(248.07,42.27) 248.38,42.59 249.5,42.59 249.85,42.24 252.13,42.24 252.79,41.57 253.66,41.57 v1(254.53,40.71) 254.53,41.16 255.55,42.18 258.85,42.18 v1(258.95,42.28)
  BOTTOM w0.102: CG848.1 57.4,98.22 v2(57.58,98.39)
  BOTTOM w0.14: C778.1 202.25,44.64 v1(202.25,42.89) 202.25,42.08 202.79,41.55 202.84,41.55 203.47,40.91 203.57,40.91 206.44,38.04 206.44,37.51 207.03,36.92 207.89,36.92 v1(208.2,37.23) 208.2,38.83 v1(206.37,40.66) 206.04,40.66 204.27,42.42 204.27,43.33 204.11,43.5 204.11,44.33 204.19,44.41 204.19,46.14 v1(203.93,46.4) ; v2(64.72,112.02) 64.88,112.19 CG581.2 ; v2(64.86,114.05) 64.93,113.98 CG566.1 ; v2(65.92,108.06) 65.87,108.11 CG681.1 ; v1(201.29,44.59) 200.96,44.26 198.95,44.26 198.77,44.44 198.77,45.66 Y5.4 ; 53.36,101.97 v2(53.4,101.94) ; CG641.1 65.85,109.81 CG649.2 66.34,109.66 v2(66.71,109.66) ; v2(50.59,103.26) 50.5,103.17 CG765.1 50.5,102.83 CG761.1 ; CG640.1 66.88,110.79 v2(66.71,110.97) ; v2(52,101.9) 51.93,101.97 ; CG602.1 63.71,112.21 v2(63.9,112.4) 64.07,112.57 CG570.1 ; 240.63,28.97 240.61,28.94 v1(240.61,28.01) ; v2(33.17,154.01) 33.19,153.99 ; v2(26.58,144.03) 26.52,144.09 CG245.2 ; CG550.1 63.84,113.86 v2(63.9,113.8)
  BOTTOM w0.152: QG17.1 22.6,148.5 23.85,148.5 24.35,148 25.39,148 v2(25.43,147.96) 25.43,148.5 25.22,148.72 25.22,149.74 RG83.2
  BOTTOM w0.2: v2(12.75,127.05) 12.85,126.94 CG329.2 ; CG364.1 48.56,123.57 v2(48.5,123.57) ; v2(37.08,143.99) 37.08,143.99 37.1,144.01 37.79,144.01 CG244.2 ; CG225.2 37.2,145.64 v2(37.1,145.54) ; v2(16.5,130.7) 16.48,130.7 16.4,130.78 CG300.2 ; CG622.2 86.58,110.53 v2(86.4,110.35) ; CG138.2 26.12,154.26 26.3,154.26 v2(26.58,154.53) ; CG404.2 97.68,120.64 97.64,120.61 v2(97.64,120.31) ; v2(13.51,111.66) 13.54,111.66 13.84,111.96 CG583.2 ; CG212.2 26.67,146.38 v2(26.56,146.26) ; CG693.1 v2(59.7,108.2) ; v2(95.39,111.09) 95.33,111.15 CG589.2 ; CG153.2 26.56,153.05 v2(26.58,153.03) ; CG214.2 27.4,146.35 v2(27.33,146.28) ; v2(14.99,110.93) 14.95,110.96 CG612.2 ; v2(52.4,145.53) 52.5,145.43 CG233.2 ; v2(28.08,155.28) v2(27.33,155.28) ; v2(60.2,147.78) v2(59.45,147.78) ; v2(21.72,123.16) 21.72,123.16 21.95,122.93 CG373.2 ; v2(74.03,155.6) v2(73.28,155.6) ; CG175.2 64.73,150.57 64.73,150.07 64.71,150.05 v2(64.71,150.03)
  BOTTOM w0.203: v2(23.25,110.17) 23.79,109.63 CG648.2 ; CG418.1 64.71,119.53 v2(64.82,119.42) ; CG632.1 58.79,110.51 58.39,110.91 58.34,110.91 v2(58.3,110.95) ; CG508.2 86.53,116.42 v2(86.39,116.55) ; v1(90.6,20.84) 90.55,20.79 C909.2 ; v1(43.28,51.69) 43.28,51.12 43.54,50.86 PC414.2 ; CG669.1 48.76,109.13 CG653.1 48.5,109.34 v2(48.5,109.6) 48.55,109.65 CG626.1 ; v2(48.5,112.37) 48.32,112.2 CG594.1 ; CG597.1 51.18,111.14 v2(51.3,111.02) ; v1(286.8,31.17) 286.8,31.48 D103.1 286.4,31.7 286.15,31.94 285.77,31.94 v1(285.51,31.69) ; v1(286.8,31.17) 286.24,31.17 v1(286.05,31.36) ; v1(286.8,31.17) 287.64,31.17 D104.1 287.75,31.39 287.32,31.82 v1(287.22,31.82) ; v1(288.18,45.37) D24.1 ; D24.1 287.57,45.84 v1(287.52,45.89) ; D24.1 v1(286.94,45.37) ; v1(271.16,15) 271.71,14.46 C929.2 ; CG774.1 CG775.1 23.09,101.99 23.09,101.99 22.76,101.99 ; CG249.2 52.54,144.16 v2(52.41,144.03) ; CG635.1 54.76,110.96 v2(54.8,111) 54.76,111.04 CG608.1 ; CG847.2 43.12,97.89 v2(42.92,97.69) ; v2(63.9,110.97) 64.23,111.3 CG617.2 ; C930.2 280.54,12.18 281.12,11.6 v1(281.45,11.6) 281.04,11.19 C936.2 C930.2 ; C930.2 C938.2 280.41,13.56 v1(280.13,13.83) ; CG604.1 62.28,111.26 v2(62.52,111.02) ; CG480.1 43.34,118.47 CG460.1 43.23,118.59 v2(42.86,118.59) ; CG576.1 56.35,112.93 56.18,113.1 v2(56.15,113.1) 56.15,113.38 CG559.1 CG558.1 ; R758.2 266.97,55.85 R757.1 266.31,55.67 266.62,55.36 v2(266.62,55.29) ; CG591.1 46.89,111.21 v2(47.1,111) ; C778.1 201.64,44.94 v1(201.29,44.59) ; v1(288.23,43.09) 287.83,43.49 D25.1 ; CG308.1 54.1,129.36 v2(54.11,129.34) ; PR514.2 37.32,52.28 v1(37.24,52.36) ; v2(49.9,113.1) 50.1,113.3 CG557.1 ; CG572.1 63.36,112.56 v2(63.2,112.4) 63,112.2 CG603.1 ; CG533.1 61.07,115.87 v2(61.1,115.9) 61.15,115.95 CG494.1 ; CG821.2 88.15,99.58 CG823.2 ; v2(62.47,99.84) 62.21,100.1 CG809.1 ; v2(61.81,111.01) 61.57,111.25 CG605.1 ; CG732.1 v2(59.7,105.4) CG720.1 ; v2(59.7,113.85) 60.1,113.45 CG578.2 ; CG694.1 58.98,106.82 v2(59,106.8) 58.98,106.78 CG721.1 ; v2(24.01,126.2) 24.09,126.13 CG336.2 24.63,126.03 25.16,125.5 CG340.2 ; CG303.2 12.27,129.82 CG307.2 11.86,129.35 v2(12.3,128.91) ; v1(280.71,48.94) 280.84,48.81 R799.1 ; CG365.1 45.03,122.85 v2(45.02,122.87) ; CG700.1 51.44,108.06 v2(51.3,108.2) 51.3,108.42 CG663.1 ; v2(19.51,123.2) 19.27,122.97 CG363.2 19.05,123.25 18.81,123.49 18.35,123.49 CG349.2 ; CG542.1 66.42,114.86 66.42,114.97 v2(66.67,115.22) 66.27,115.62 CG520.1 ; v1(222.19,38.45) 222.19,37.99 221.89,37.68 C801.1 ; PQ45.1 15.42,94.88 15.03,95.26 PR476.2 ; PR505.1 71.36,52.46 71.34,52.44 ; CG839.2 59.7,98.61 v2(59.7,98.35) ; v2(63.9,109.6) 63.69,109.39 CG671.1 ; D30.1 288.07,39.17 v1(288.18,39.28) ; D30.1 v1(287.57,38.65) ; D30.1 v1(286.91,39.17) ; v1(285.18,12.72) 284.89,12.72 D80.2 ; CG643.1 43.01,110.15 v2(42.85,110.3) ; CG674.1 61.54,109.3 v2(61.8,109.55) 62.02,109.78 CG636.2 ; v1(95.56,60.33) 95.59,60.3 PR490.2 ; v2(59.7,103.96) 59.7,103.96 CG754.1 ; PU23.37 94.25,54.93 PR493.2 ; v1(288.08,28.79) 288.08,29.18 D105.1 286.96,29.5 v1(286.81,29.66) 286.56,29.66 v1(286.2,30.01) ; CG453.1 56.46,118.96 v2(56.2,118.7) 56.38,118.51 CG473.1 ; CG299.2 18.26,130.91 v2(18.03,130.67) ; v1(286.93,43.68) 287.12,43.49 D25.1 ; v1(286.98,40.83) 287.2,41.05 D29.1 ; D76.2 284.11,7.78 v1(284.02,7.87) ; D76.2 285.2,7.78 v1(285.24,7.81) ; D76.2 284.63,7.23 v1(284.83,7.03) ; CG446.1 50.34,119.14 v2(49.9,118.7) ; v1(77.56,21.43) 77.56,21.78 77.48,21.86 C890.2 ; CG631.1 59.53,110.8 v2(59.69,110.96) 59.95,111.23 CG614.1 59.96,111.46 CG616.1 ; v1(88.58,20.87) 88.47,20.87 88.12,20.51 C907.2 ; v2(49.9,118.7) 49.68,118.92 CG435.1 ; v2(49.9,118.7) 50.08,118.52 CG477.1 ; CG672.1 62.97,109.37 63.15,109.55 v2(63.2,109.55) ; v1(89.78,30.39) 89.5,30.68 C830.2 ; v1(288.18,41.16) 288.07,41.05 D29.1 ; CG474.1 55.67,117.47 v2(55.5,117.3) ; CG573.1 61.77,113.44 v2(61.77,113.8) ; C881.2 229.83,23.94 v1(230.27,24.39) ; CG454.1 61.1,118.75 v2(61.1,118.7) 61.1,118.53 CG465.1 ; v1(234.46,20.67) 234.69,20.67 235,20.35 R1032.1 ; CG472.1 57.1,117.5 v2(56.9,117.3) 57.1,117.1 CG500.1 ; CG316.2 21.79,129.21 21.58,129.42 v2(21.58,129.7) ; C679.2 C678.2 182.63,91.26 v1(182.9,90.99) ; PR478.2 17.81,94.94 17.65,94.78 v1(17.37,94.78) ; CG628.1 49.99,110.9 v2(49.91,110.99) 49.91,111.32 CG596.1 ; CG405.1 43.07,120.61 v2(42.78,120.32) ; R1034.2 218.05,20.37 v1(218.32,20.64) 218.6,20.36 R1031.2 ; CG367.2 8.55,122.66 CG358.2 ; CG662.1 52.27,109.27 v2(51.98,109.56) 52.27,109.85 CG633.2 ; CG318.2 64.28,127.65 v2(64.28,127.64) ; v2(59,109.6) 59.41,109.19 CG665.1 ; PC425.2 79.09,28.95 v1(78.61,29.43) 78.33,29.15 PC426.2 ; CG466.1 60.66,117.56 v2(60.4,117.3) 60.44,117.26 CG496.1 ; 207.27,18.4 206.77,17.91 R1053.2 ; 207.27,18.4 v1(207.27,18.41) ; 207.27,18.4 207.27,18.09 207.41,17.95 R1045.1 ; R1095.2 218.88,17.03 R1081.2 ; CG610.1 56.9,111.02 v2(56.89,111.01) ; CG548.1 42.84,114.43 v2(42.81,114.4) ; CG637.1 53.34,109.63 v2(53.38,109.58) 53.5,109.58 53.7,109.38 CG659.1 ; v1(47.12,31.1) 47.12,31.45 47.59,31.92 C824.1 C822.1 C815.2 ; CN10.27 v1(175.85,125.25) ; CG853.1 68.71,97.68 v2(68.83,97.68) ; 99.2,117.37 99.23,117.39 99.73,117.39 CG485.2 ; CG638.1 54.05,109.63 v2(54.11,109.57) 54.41,109.26 CG658.1 ; CG514.2 89.89,115.74 CG534.2 ; CG459.1 38.09,118.27 v2(38.11,118.29) ; CG571.1 62.64,113.66 v2(62.5,113.8) 62.51,113.81 CG546.1 ; CG634.1 55.48,109.62 v2(55.5,109.6) ; CG661.1 56.55,108.54 v2(56.9,108.2) ; CG375.1 51.84,123.08 v2(51.8,123.12) ; D80.2 284.89,13.19 v1(285.13,13.43) ; D80.2 284.42,12.51 v1(284.7,12.23) ; v2(68.11,116.63) 68.07,116.63 67.52,117.18 RG112.1 ; C917.2 279.43,19.09 v1(279.47,19.05) ; D78.2 284.84,9.66 285.16,9.97 v1(285.16,10.38) ; D78.2 283.95,9.66 v1(283.89,9.72) ; D78.2 284.63,10.76 v1(284.8,10.94) ; CG385.1 CG372.1 47.63,123.08 v2(47.61,123.1) ; CG475.1 63.79,117.45 v2(63.91,117.34) 64.01,117.23 CG495.1 ; CG360.1 49.58,123.11 v2(49.58,123.1) ; v1(273.16,11.18) 273.06,11.27 C934.2 ; CG697.1 50.02,108.06 v2(49.9,108.18) 49.9,108.44 CG670.1 ; D29.1 v1(287.57,41.57) ; v2(50.6,112.4) 50.46,112.26 CG598.1 ; CG545.1 62.86,115.06 CG524.1 62.63,115.37 v2(62.45,115.2) 62.27,115.39 CG530.1 ; CG469.1 59.95,118.48 v2(59.71,118.72) 60.02,119.03 CG450.1 ; v2(56.2,108.2) 55.84,108.56 CG654.1 ; PR551.2 40.9,37.73 v1(41.07,37.56) ; CG479.1 v2(63.17,117.32) 63.29,117.19 CG491.1 CG492.1 ; C933.2 275.89,13.21 v1(275.6,12.92) 275.06,12.39 C932.2 ; D25.1 v1(287.57,42.97) ; v2(71.14,116.2) 71.33,116.01 CG517.1 ; PC423.2 PC424.2 ; v2(19.5,110.95) 19.59,111.03 CG611.2 ; v1(19.14,104.46) 19.14,104.31 18.84,104.01 CG744.1 ; CG351.1 43.74,124.14 v2(43.53,124.35) ; CG615.1 58.52,111.18 v2(58.3,110.95) ; CG664.1 60.12,109.33 v2(60.4,109.61) 60.24,109.77 CG629.1 ; v2(47.8,108.2) 47.99,108.39 CG651.1 ; v2(58.3,110.95) 57.98,111.27 CG613.1 ; v2(56.9,109.55) 56.55,109.91 CG639.2 ; CG344.2 38.06,124.43 v2(38.07,124.43) ; CG590.1 47.61,112.21 v2(47.78,112.38) ; CG377.1 56.37,122.69 v2(56.03,123.04) ; R704.2 172.86,96.76 172.59,96.49 C675.2 172.59,95.98 C677.2 ; CN16.1 56.59,32.75 56.44,32.6 56.44,31.87 CN16.76 ; v2(46.38,122.89) 46.64,122.64 CG374.1 ; U42.3 234.21,21.84 234.33,21.96 v1(234.41,21.96) 234.46,21.96 234.47,21.96 R1006.1 ; v1(286.91,34.21) 286.58,33.87 D101.1 286.58,33.41 286.26,33.41 285.72,33.95 285.72,34.2 v1(285.64,34.28) ; CG529.1 58.22,114.58 v2(58.3,114.5) 58.52,114.28 CG551.1 ; CG569.1 61.22,112.52 v2(61.1,112.4) ; CG625.1 49.15,110.66 v2(49.15,111) 49.15,111.05 49.04,111.16 CG599.1 ; CG361.1 54.12,123.52 v2(53.97,123.52) ; v2(50.58,109.58) 50.85,109.31 CG666.1 ; v1(175.84,123.59) 175.68,123.75 CN10.24 ; PC416.2 46.22,40.09 v1(45.47,39.33) 45.01,38.87 PC417.2 ; v1(288.33,34.15) 288.63,34.45 D45.1 288.94,34.74 288.87,34.81 v1(288.28,34.81) ; CG368.2 14.2,122.56 CG388.2 ; CG471.1 57.81,118.49 v2(57.6,118.7) 57.88,118.98 CG447.1 ; v2(59.69,122.22) 59.93,122.46 CG381.1 60.17,122.46 60.17,122.87 v2(60.27,122.96) ; CG577.2 22.27,112.65 v2(22.5,112.42) ; v1(289.55,32.57) D48.1 288.94,32.3 v1(289.25,32) ; CG378.1 57.38,122.64 v2(57.62,122.88) ; v2(63.21,119.4) 63.57,119.04 CG456.1 ; v1(88.03,18.3) 88.15,18.42 CN19.2 ; CG493.1 61.87,117.23 v2(61.8,117.3) 61.8,117.51 CG468.1 ; C937.2 275.41,11.72 v1(275.46,11.77) ; v2(64.86,114.05) 64.83,114.08 CG541.1 64.53,115.01 CG536.1 ; CG650.1 45.85,108.3 v2(45.73,108.19) 45.73,107.9 CG698.1 ; R914.2 208.07,29 208.18,28.89 C851.1 ; v2(52.7,108.2) 52.99,108.49 CG655.1 ; CG532.1 60.36,114.51 v2(60.37,114.5) 60.61,114.27 CG552.1 ; EC8.1 235.99,38.11 235.79,37.91 C799.2 ; CG95.2 63.7,156.56 v1(63.8,156.66) ; CG627.1 60.95,109.75 v2(61.1,109.6) 60.83,109.33 CG675.1 ; v3(99.82,159.07) 100.55,159.8 C511.1 ; v2(60.4,120.1) 60.73,119.77 CG452.1 ; v2(54.83,113.09) 55.25,112.67 CG580.1 55.25,112.12 CG607.1 ; v2(14.81,107.72) 15.16,108.07 CG686.2 ; v2(58.3,108.2) 58.7,108.6 CG667.1 ; CG815.2 60.28,100.38 v2(60.35,100.38) 60.47,100.26 CG810.2 ; CG244.2 39.15,144.01 PC330.2 ; CG328.2 22.57,127.59 CG325.2 22.62,127.16 22.63,127.15 22.63,127.14 v2(22.69,127.08) ; CG841.1 60.77,98.68 v2(61.05,98.39) ; v2(49.9,105.35) 49.9,105.6 CG722.2 50.59,105.85 v2(50.59,105.35) ; v1(240.61,28.01) PU32.11 ; v1(51.15,37.07) 51.08,37 CN16.18 ; v1(37.84,48.09) 37.45,48.48 36.71,48.48 36.05,49.14 PR517.2 ; CG609.1 56.18,111.04 v2(56.2,111.03) ; CG668.1 57.98,109.17 v2(57.6,109.55) 57.27,109.22 CG660.1 ; v2(49.91,97) 50.1,97.2 CG858.1 ; C688.2 173.63,87.77 v1(173.42,87.57) ; Y5.4 199.39,46.57 199.97,47.15 C771.1 203.18,47.15 v1(203.93,46.4) ; CG696.1 49.2,107.16 v2(49.2,106.78) 49.3,106.68 CG719.1 ; v2(264.64,56.68) 264.69,56.68 265.12,56.25 R759.2 ; PR535.1 31.37,43.78 31.45,43.69 v1(31.45,43.35) 30.91,43.35 PR536.2 ; CG600.1 52.61,111.1 v2(52.69,111.02) ; C527.2 96.45,150.69 v1(96.16,150.39) ; v2(63.15,118.7) 62.97,118.88 CG457.1 ; v1(88.72,18.33) 88.65,18.4 CN19.1 ; 67.41,98.94 v2(67.06,99.29) ; CG539.2 87.83,114.89 CG509.2 87.83,116.49 v2(87.89,116.55) ; CG464.1 64.68,118.25 64.82,118.39 v2(64.82,118.64) 65.37,119.19 RG110.1 ; CG525.1 50.83,114.73 v2(50.6,114.5) 50.6,114.25 CG556.1 ; v2(50.6,106.8) 50.73,106.93 CG699.1 ; CG266.2 61.97,142.25 CG262.2 61.97,143.22 61.71,143.48 61.28,143.48 61.1,143.29 v2(60.96,143.29) ; CG376.2 20.02,123.16 CG359.2 19.99,123.68 20.24,123.94 v2(20.24,124)
  BOTTOM w0.225: v2(99.43,122.61) 99.39,122.57 CG371.2 ; v2(19.52,109.43) 19.48,109.47 CG645.2 ; v2(88.67,104.31) 88.61,104.25 88.57,104.25 88.48,104.15 CG740.2 ; CG540.2 11.95,115.19 v2(11.84,115.3) ; v2(90.12,127.08) 90.12,127.07 90.44,126.76 CG333.2 ; v2(94.64,116.5) 94.56,116.42 CG512.2 ; v2(23.26,125.45) 24.01,124.7 v2(24.01,124.69) ; CG588.2 87.95,111.14 v2(87.92,111.11) ; CG353.2 85.5,123.92 v2(85.64,124.06) ; v2(60.2,141.78) 60.3,141.68 CG277.2 ; v2(21.01,108.66) 21.04,108.63 CG684.2 ; CG338.2 14.87,125.59 v2(15.01,125.45) ; v2(93.89,119.56) 93.9,119.56 CG433.2 ; v2(22.53,119.16) 22.53,119.18 22.64,119.29 CG427.2 ; v2(44.14,148.57) 44.14,148.4 43.73,148 CG195.2 ; v2(95.35,100.52) 95.33,100.5 95.33,99.93 CG819.2 ; v2(96.87,100.51) 96.85,100.49 96.85,99.93 CG820.2 ; CG301.2 10.47,130.75 v2(10.51,130.7) ; CG273.2 64.46,142.22 64.76,142.52 v2(64.76,142.53) ; CG155.2 48.33,152.59 48.41,152.52 49.15,152.52 v2(49.39,152.28) ; CG687.2 12.6,108.54 v2(12.74,108.68) ; v2(97.64,104.3) 97.73,104.39 97.73,104.91 CG730.2 ; CG131.2 37.24,154.47 v2(37.13,154.58) ; v2(99.14,101.31) 99.2,101.36 99.7,101.36 CG805.2 ; CG514.2 90.06,116.53 v2(90.09,116.55) ; v2(99.3,110.32) 99.37,110.39 CG624.2 ; CG369.2 12.58,122.99 v2(12.76,123.18) ; CG677.2 14.9,108.7 14.94,108.66 v2(14.97,108.66) ; CG117.2 37.55,155.82 v2(36.98,155.82) ; v2(99.14,117.31) 99.2,117.37 ; v2(94.64,127.05) 94.64,127.06 94.98,127.4 CG326.2 ; CG321.2 93.33,127.32 v2(93.14,127.12) ; v2(22.15,115.21) 22.21,115.14 CG544.2 ; CG331.2 10.35,126.57 10.51,126.4 v2(10.51,126.2) ; CG323.2 98.38,127.07 v2(98.41,127.04) ; CG584.2 24.16,111.76 24.08,111.69 23.99,111.69 v2(23.97,111.66) ; v2(20.99,116.18) 21.06,116.24 21.12,116.3 CG505.2 ; v2(10.36,123.95) 10.22,123.81 CG354.2 ; v2(10.51,118.41) 10.24,118.15 10.22,118.15 CG478.2 ; CG822.2 94.54,100.43 v2(94.64,100.53) ; CG319.2 89.51,127.19 v2(89.38,127.07) ; v2(90.13,124.79) 90.11,124.78 CG347.2 ; CG337.2 19.5,125.46 v2(19.51,125.45) ; CG295.2 12.55,133.98 v2(12.78,133.76) ; v2(17.27,125.47) 17.49,125.25 CG342.2 ; v2(94.66,124.79) 94.7,124.75 CG346.2 ; CG623.2 24.68,110.92 v2(24.03,110.92) ; v2(14.26,123.18) 14.19,123.1 CG368.2 ; v2(19.51,108.66) 19.43,108.58 19.01,108.58 CG678.2 ; v2(15.78,116.13) 15.78,116.14 15.75,116.17 15.26,116.17 CG506.2 ; v2(11.98,112.42) 12.09,112.53 CG568.2 ; CG324.2 96.91,127.63 96.91,127.07 v2(96.89,127.06) ; v2(11.24,108.68) 10.95,108.39 CG688.2 ; CG109.2 49.32,155.61 49.39,155.54 v2(49.39,155.28) ; CG462.2 85.28,117.65 85.31,117.65 v2(85.64,117.31) ; CG341.2 91.3,125.24 v2(91.63,125.56) ; v2(86.41,100.53) 86.33,100.44 CG817.2 ; v2(14.26,119.15) 14.26,119.3 14.09,119.47 CG426.2 ; CG103.2 42.53,155.53 v2(42.63,155.44) ; CG619.2 90.08,111.12 v2(90.14,111.06) ; CG430.2 10.88,119.54 v2(11.21,119.21) ; v2(87.91,100.53) 87.8,100.43 87.8,99.93 CG821.2 ; CG173.2 28.87,150.83 v2(28.83,150.78) ; v2(98.39,100.49) 98.35,100.46 CG818.2 ; v2(22.5,112.42) 22.65,112.57 CG574.2 ; CG330.2 12.41,127.05 v2(12.75,127.05) ; CG113.2 45.13,155.53 v2(44.88,155.28) ; v2(13.51,116.16) 14.06,115.6 14.06,115.13 CG537.2 ; CG515.2 89.37,115.91 89.37,116.45 v2(89.47,116.55) ; v2(13.51,130.7) 14.07,130.15 CG304.2 ; v2(18.79,116.12) 18.83,116.16 CG507.2 ; v2(90.14,100.56) 90.14,100.45 CG816.2 ; v2(11.19,123.17) 10.98,122.95 CG370.2 ; v2(23.29,123.92) 23.22,123.85 CG357.2 ; v2(99.14,126.31) 99.71,126.31 CG334.2 ; v2(96.14,124.06) 96.22,123.98 CG355.2 ; v2(11.26,133.77) 11.23,133.8 CG296.2 ; CG586.2 9.94,111.66 v2(10.51,111.66) ; v2(99.14,124.06) 99.22,124.13 CG348.2 ; v2(22.51,108.66) 22.55,108.62 CG683.2 ; CG431.2 12.45,119.46 v2(12.74,119.18)
  BOTTOM w0.24: v2(42.82,116.46) 43.22,116.46 CG503.1
  BOTTOM w0.254: 111.92,46.72 JDIM4.230 ; CG206.2 34.08,147.01 v2(34.1,147.03) ; CG523.2 18.48,115.68 v2(18.03,116.13) ; v2(59.45,147.78) 59.41,147.75 CG204.2 ; v2(52.42,142.53) 52.43,142.55 CG264.2 ; CG425.2 90.8,119.65 v2(90.88,119.57) 90.95,119.64 CG416.2 ; 114.92,46.66 JDIM4.218 ; v1(191.74,46.11) 191.58,46.27 190.62,46.27 190.39,46.5 CN15.27 ; CG197.2 60.36,147.95 v2(60.2,147.78) 60.2,147.65 59.95,147.4 CG203.2 ; v1(54.58,52.35) CN16.77 ; JDIM3.99 146.67,49.23 v1(147.08,48.83) ; CG128.2 53.61,154.4 CG129.2 52.58,154.4 v2(52.45,154.53) ; JDIM3.107 144.67,48.89 v1(145.33,48.23) ; v1(188.31,39.11) 188.41,39 CN15.57 190.62,39 190.9,39.28 190.9,40.17 190.57,40.5 CN15.51 ; CN16.39 56.33,42.25 v1(56.23,42.36) ; v2(72.48,151.53) 72.34,151.67 CG160.2 ; CG682.2 90.91,108.09 v2(90.92,108.09) ; JDIM4.39 161.67,38.44 161.43,38.69 v1(161.43,38.73) ; v2(42.68,99.34) 42.96,99.34 CG838.1 ; v2(26.52,151.53) 26.14,151.91 CG159.2 ; v2(57.95,151.5) 57.75,151.29 CG167.2 ; v2(71.73,149.82) 71.63,149.82 71.08,150.36 RG81.2 ; CG711.2 97.38,106.74 v2(97.06,107.06) 97.34,107.34 CG701.2 ; v1(55.07,46.85) 55.23,46.69 55.92,46.69 55.99,46.75 CN16.57 ; 241.45,16.04 241.43,16.06 U44.23 ; CN10.19 v1(175.94,121.25) ; JDIM4.103 145.67,36.22 145.31,35.86 v1(145.31,34.88) ; v2(89.39,102.81) 89.96,103.37 CG748.2 ; CG133.2 38.3,154.44 38.27,154.47 CG131.2 ; D110.2 84.6,21.63 84.26,21.97 83.52,21.97 83.22,21.67 83.22,20.93 v1(82.82,20.54) ; v2(66.73,112.42) 66.5,112.65 CG579.1 ; v2(57.14,149.29) 56.78,149.65 CG183.2 ; v1(26.03,98.31) 26.32,98.03 RG161.1 ; v1(188.11,51.07) 188.18,51 CN15.9 ; CG844.1 51.73,98.9 51.53,99.1 v2(51.33,99.1) 51.54,99.32 CG825.1 ; JDIM3.103 145.67,51.5 146.36,52.19 v1(146.87,52.19) ; v2(34.83,146.28) 34.79,146.24 CG220.2 ; CG234.2 78.68,144.75 v2(78.96,144.47) 79.25,144.76 CG237.2 ; v2(99.43,122.61) 99.66,122.38 CG383.2 ; CG111.2 76.02,155.85 v2(75.75,155.58) ; v2(29.58,149.28) 29.61,149.31 CG189.2 ; v2(96.1,106.71) 96.38,106.43 CG723.2 ; PQ40.1 12.08,170.04 11.55,170.57 v1(11.55,170.76) ; JDIM4.248 107.42,46.67 ; CG190.2 60.23,149.25 v2(60.2,149.28) ; CG182.2 44.97,149.95 v2(44.89,150.03) ; CN8.9 32.85,162.37 33.25,162.77 35.95,162.77 v1(36.05,162.67) ; CG428.2 19.88,119.57 19.55,119.24 v2(19.55,119.17) 18.92,119.8 RG108.2 ; UG6.3 40.23,82.42 40.81,83 40.81,84.62 v1(40.99,84.8) ; v2(31.03,155.57) 31.05,155.55 CG120.2 31.75,155.56 CG119.2 ; CG258.2 48.84,143.75 48.67,143.92 v2(48.39,143.92) 48.26,143.78 CG248.2 ; v2(26.58,142.53) 26.36,142.53 26,142.89 CG259.2 ; 109.92,46.67 JDIM4.238 ; CG180.2 49.98,149.88 v2(50.14,150.03) ; PQ54.1 90.22,50.86 89.69,50.33 PR516.2 ; CN16.45 56.33,43.75 v1(56.22,43.65) ; JDIM4.15 167.67,35.71 ; CG236.2 26.11,144.98 26.58,145.45 v2(26.58,145.53) ; PC447.2 23.27,94.49 23.27,93.27 v1(23.21,93.21) ; 116.92,46.73 JDIM4.210 ; CN20.17 27.65,16.73 28.41,15.98 v1(28.41,15.82) ; RG109.2 15.03,119.51 v2(15.03,119.19) ; JDIM4.205 118.17,35.5 ; CG193.2 69.04,148.15 v2(68.98,148.09) 68.49,147.61 RG90.2 ; v2(41.85,151.57) 41.73,151.45 CG166.2 ; CG163.2 83.09,151.54 v2(83.04,151.49) ; v1(176.72,118.36) 176.61,118.25 CN10.13 ; CG158.2 79.81,152.08 v2(80,152.28) ; v2(100.33,119.5) 100.28,119.55 CG415.2 ; CG242.2 67.94,144.26 v2(67.71,144.03) 68.21,143.53 CG254.2 ; CG132.2 33.16,154.02 33.17,154.01 v2(33.17,154.01) ; v2(37.14,150.78) 37.14,150.79 CG178.2 ; JDIM4.193 121.17,35.55 ; C500.1 v1(97.25,165.58) ; v1(11.25,174.01) 11.17,173.93 PR426.2 ; v2(63.86,154.01) 63.81,153.96 CG134.2 ; v2(29.58,152.28) 29.91,151.96 CG165.2 ; CG144.2 44.97,153.11 v2(44.89,153.03) ; CG216.2 46.63,146.15 46.13,146.15 v2(46.12,146.15) 46.11,146.15 46.11,145.73 46.52,145.32 CG238.2 ; U13.79 251.83,35.88 C807.1 ; CG121.2 41.38,155.06 v2(41.82,154.63) ; CN18.57 191.3,13.95 v1(191.36,14.01) 191.36,14.82 190.73,15.45 CN18.51 ; CG145.2 72.46,153.05 v2(72.48,153.03) ; 120.42,46.71 JDIM4.196 ; CG824.1 52.26,100.31 v2(52.06,100.51) ; 148.92,59.62 JDIM3.90 ; v2(47.1,101.9) 46.93,102.07 CG769.1 ; v2(88.74,129.07) 88.8,129.12 CG310.2 ; v1(162.54,38.8) 162.54,38.48 162.67,38.35 JDIM4.35 ; v2(67.71,146.29) 67.86,146.14 CG222.2 ; v2(60.2,155.28) 60.4,155.49 CG110.2 ; v2(91.65,115.02) 91.46,114.82 CG549.2 ; v2(96.14,119.56) 96.16,119.57 CG417.2 ; CG343.2 9.62,124.46 9.75,124.33 CG354.2 ; v1(227.66,32.64) 227.55,32.75 C816.2 ; v2(96.89,111.08) 97.15,111.34 CG593.2 ; CG107.2 67.06,155.4 v2(66.95,155.28) ; CN17.14 11.21,20.5 v1(10.92,20.21) ; CN16.19 56.57,37.25 ; 56.57,37.25 56.1,37.25 54.97,38.39 v1(54.97,39.39) ; 56.57,37.25 56.32,37 56.32,36.01 56.57,35.75 CN16.13 ; CN18.21 188.51,22.95 188.39,23.08 v1(188.33,23.08) ; 166.92,59.56 JDIM3.18 ; CG676.2 90.19,108.86 v2(90.14,108.81) ; 124.17,35.52 JDIM4.181 ; v1(58.87,45.38) 58.74,45.25 CN16.51 ; CG621.2 90.26,110.94 v2(90.14,111.06) ; CG228.2 67.97,145.4 v2(67.76,145.61) ; CG147.2 52.46,153.03 v2(52.44,153.01) ; CG270.2 42,141.94 v2(42.59,142.53) ; v1(238.88,16.09) 238.45,16.52 U44.16 ; CG172.2 44.31,150.95 v2(44.14,150.78) ; JDIM4.1 171.17,35.82 ; v1(192.14,16.37) 192.04,16.27 191.38,16.27 190.7,16.95 CN18.45 ; JDIM4.57 157.17,38.56 v1(157.29,38.67) ; v1(23.77,99.58) 23.52,99.83 CG777.2 ; v1(29.06,15.81) 29.15,15.9 CN20.14 ; CG691.2 99.44,107.76 v2(99.14,108.06) ; v1(188.39,26.05) 188.48,25.95 CN18.9 ; CG826.1 50.83,99.37 v2(50.58,99.12) 50.13,99.56 CG827.1 ; v1(81.48,18.2) 81.43,18.2 81.15,18.48 CN19.16 ; CG200.2 75.78,147.37 v2(75.48,147.06) ; v2(93.14,103.56) 93.02,103.68 CG734.2 ; CG100.2 64.68,155.3 v2(64.7,155.28) ; 53.36,101.97 CG764.1 53.36,102.38 CG759.1 ; 51.93,101.97 CG760.1 ; v2(28.83,146.27) 28.84,146.28 CG215.2 ; v2(73.21,142.54) 72.71,142.04 CG269.2 ; v2(86.39,127.09) 86.39,127.31 86.73,127.65 CG322.2 ; v2(49.39,149.28) 49.23,149.28 48.97,149.54 CG185.2 ; JDIM4.9 169.17,35.69 ; CG231.2 32.35,144.7 32.49,144.56 CG250.2 33.07,143.92 33.08,143.92 v2(33.08,143.92) ; CG140.2 68.12,153.46 v2(67.72,153.06) 67.92,152.87 CG154.2 ; JDIM4.5 170.17,35.63 ; R770.2 97.79,54.25 98.7,54.25 99.31,54.86 99.31,56.33 98.82,56.81 PR492.2 ; v1(155.21,38.72) 155.21,38.62 155.17,38.58 JDIM4.65 ; 124.42,46.64 JDIM4.180 ; CG184.2 78.87,150.4 v2(78.91,150.43) 78.95,150.48 CG171.2 ; v2(37.11,153.06) 37.12,153.07 CG152.2 ; v2(85.64,108.06) 85.47,107.89 CG690.1 ; v2(62.27,155.16) 62.19,155.08 CG125.2 ; CG260.2 37.64,143.09 v2(37.09,142.53) 37.51,142.11 CG267.2 ; 162.42,59.68 JDIM3.36 ; CG829.1 CG828.1 49.41,100.3 v2(49.25,100.45) ; RG97.2 55.96,146.26 v2(57.17,146.26) 57.11,146.32 CG207.2 ; CG256.2 41.19,143.42 v2(41.83,144.06) 41.48,144.41 CG240.2 ; 161.42,59.65 JDIM3.40 ; JDIM3.6 169.92,59.6 ; JDIM4.99 146.67,38.48 v1(146.92,38.72) ; CG97.2 81.54,155.32 v2(81.5,155.28) ; CG232.2 57.08,145.44 v2(57.17,145.53) ; CG217.2 40.71,146.86 v2(41.02,147.18) ; CG198.2 74.1,147.89 v2(74.74,148.53) ; v1(165.75,38.81) 165.75,38.59 165.67,38.51 JDIM4.23 ; CG743.1 46.38,103.3 v2(46.4,103.3) ; CG209.2 44.16,146.33 v2(44.2,146.29) ; v2(85.64,102.81) 85.31,103.14 CG753.1 ; CG280.2 44.98,141.69 v2(44.89,141.78) ; CG202.2 45.08,147.28 v2(44.86,147.06) ; C803.1 250.73,37 U13.82 ; v2(83.03,142.55) 83.17,142.55 83.49,142.88 CG261.2 ; v1(35.63,80.13) 35.63,80.21 36,80.58 UG8.3 ; CN18.39 190.39,18.45 191.15,19.22 v1(191.15,20.92) 190.98,20.92 190.44,21.45 CN18.27 ; v2(96.14,103.56) 96.34,103.75 CG735.2 ; R951.2 230.89,26.59 v1(230.91,26.61) ; v1(188.1,48.01) 188.11,48.01 188.12,48 CN15.21 ; CG463.2 91.1,118.27 v2(90.91,118.08) ; v2(51.64,155.28) 51.79,155.43 CG108.2 ; v2(81.5,155.28) v2(80.75,155.28) 80.8,155.33 CG101.2 ; v2(81.5,155.28) v2(82.25,155.28) 82.27,155.3 CG99.2 ; 108.42,46.6 JDIM4.244 ; CG770.1 46.22,102.1 v2(46.4,101.92) ; CG199.2 30.85,147.71 30.76,147.79 30.4,147.79 30.36,147.75 CG196.2 29.62,147.75 v2(29.58,147.79) ; UG11.3 39.67,78.02 39.73,77.96 v1(39.73,77.76) ; CG188.2 82.74,149.01 v2(82.26,148.53) ; v1(144.37,59.78) 144.62,59.78 144.92,59.48 JDIM3.106 ; JDIM4.189 122.17,35.57 ; JDIM3.168 127.42,57.23 127.53,57.12 v1(127.53,56.96) ; CG230.2 83.01,145.52 v2(83,145.53) ; v1(56.23,51.25) CN16.75 ; JDIM3.172 126.42,56.6 127.36,55.66 v1(127.55,55.66) ; CG339.2 85.47,126.17 v2(85.61,126.32) ; v2(50.13,147.04) 50.08,147 CG208.2 ; v1(227.48,31.02) 227,31.5 C825.2 ; v2(44.88,144.81) 45.39,144.31 CG246.2 ; v2(34.09,142.52) 33.87,142.3 CG275.2 ; v1(56.18,33.51) 56.21,33.54 56.21,33.85 56.61,34.25 CN16.7 ; v1(125.59,125.07) 125.27,125.07 125.1,124.91 C582.1 124.86,125.39 124.88,125.41 C575.1 ; CG401.2 88.01,120.86 87.95,120.79 v2(87.95,120.52) ; CN8.18 37.35,161.15 37.35,162.05 36.75,162.65 v1(36.72,162.65) ; UG7.3 48.26,81.1 v1(47.64,80.48) 47.96,80.17 QG23.1 49.33,80.17 49.41,80.09 UG10.3 ; v1(146.92,59.8) JDIM3.98 ; 110.92,46.72 JDIM4.234 ; JDIM4.213 116.17,35.57 ; CG127.2 72.39,154.56 v2(72.45,154.62) ; C905.2 79.53,20.06 79.65,19.94 CN19.19 79.65,18.25 v1(79.7,18.2) ; 163.92,59.6 JDIM3.30 ; CG96.2 74.11,155.69 v2(74.03,155.6) ; v1(176.09,116.4) 175.74,116.75 CN10.10 ; RG172.1 15.85,90.24 16.5,90.89 v1(16.5,91.02) ; v1(188.39,20.13) 188.57,19.95 CN18.33 ; v2(29.58,141.78) 29.74,141.62 CG282.2 ; v2(91.64,103.56) 91.55,103.65 CG747.2 ; v2(72.45,146.24) 72.25,146.04 CG224.2 ; v2(79.25,153.78) 79.24,153.79 CG137.2 ; v2(76.49,152.8) 76.49,152.95 76.24,153.21 CG142.2 ; v1(127.55,51.69) 127.67,51.57 JDIM3.167 ; CG320.2 88.13,127.3 v2(87.89,127.06) ; v2(9.8,117.33) 9.74,117.27 CG490.2 ; v1(56.23,49.75) CN16.69 ; 118.92,46.7 JDIM4.202 ; CG511.2 96.98,116.47 v2(96.92,116.53) ; CG219.2 83.04,146.24 v2(83,146.28) ; v1(164.68,38.74) 164.67,38.73 JDIM4.27 ; CG205.2 77.21,146.43 77.21,146.43 76.85,146.43 v2(76.77,146.5) 76.71,146.43 CG229.2 ; v1(16.21,103.23) 16.21,103.13 17.62,101.71 CG811.2 ; CG176.2 34.08,150.04 v2(34.08,150.03) ; CG213.2 57.96,146.28 v2(57.94,146.26) ; v2(21.03,119.16) 21.02,119.17 CG429.2 ; v2(58.7,155.28) 58.72,155.31 CG105.2 ; JDIM4.197 120.17,35.59 ; v2(86.37,119.53) 86,119.91 CG421.1 ; CG279.2 75.78,141.51 v2(75.5,141.78) ; JDIM4.226 112.92,46.68 ; JDIM4.184 123.42,46.76 ; v2(17.99,111.66) 17.89,111.56 CG620.2 ; v2(48.64,153.78) 48.5,153.92 CG135.2 ; v2(41.93,150.79) 41.9,150.82 CG174.2 ; JDIM3.171 126.67,52.21 127.4,52.94 v1(127.55,52.94) ; v1(104.59,156.79) 104.64,156.83 R1169.2 ; CG836.1 63.27,98.41 v2(63.25,98.4) ; CG126.2 56.87,154.85 v2(57.2,154.53) 56.75,154.09 CG136.2 ; CG141.2 60.96,153.79 v2(60.95,153.78) ; v1(254.4,43.37) 254.17,43.6 C781.1 ; v2(71.68,147.27) 71.69,147.29 CG201.2 ; JDIM3.102 145.92,56.84 146.36,56.4 146.36,56.2 146.73,55.83 v1(146.85,55.83) ; CG302.2 9.11,131.19 v2(9.19,131.26) ; 113.92,46.72 JDIM4.222 ; v1(143.96,34.88) 143.96,35.55 144.67,36.27 JDIM4.107 ; CG685.2 94.82,108.63 v2(94.64,108.81) ; v2(85.64,101.31) 85.58,101.24 CG806.2 ; v1(56.23,48.25) CN16.63 ; JDIM4.185 123.17,35.53 ; RG165.2 23.94,95.65 v1(24.52,95.07) ; CG146.2 30.86,153.26 v2(30.33,153.79) 30.7,154.16 30.9,154.16 CG130.2 ; CG170.2 26.23,151.13 v2(26.58,150.78) ; v2(57.95,155.28) 57.93,155.3 CG106.2 ; v2(84.56,148.82) 84.56,149.08 84.8,149.31 CG186.2 ; v2(10.51,116.16) 10.44,116.09 CG516.2 ; CN15.45 188.51,42 v1(188.33,41.82) ; UG9.3 42.6,80.47 43.2,79.87 43.25,79.87 43.35,79.77 v1(43.43,79.77) ; 159.42,59.54 JDIM3.48 ; v2(58.7,142.53) 58.07,141.9 CG274.2 ; CG164.2 52.44,151.51 v2(52.43,151.49) ; CG745.2 99.16,103.57 v2(99.14,103.56) ; 125.42,46.68 JDIM4.176 ; v1(190.77,43.25) 190.67,43.25 190.42,43.5 CN15.39 ; JDIM3.78 151.92,59.61 ; CG649.2 65.85,109.02 v2(66.68,108.2) ; CG276.2 51.8,141.62 v2(51.64,141.78) ; CG563.1 66.54,113.7 v2(66.78,113.94) ; C555.1 125.37,128.59 v1(125.73,128.59) ; 149.92,59.59 JDIM3.86 ; 164.92,59.57 JDIM3.26 ; CG181.2 80.17,149.45 v2(80,149.28) ; v2(30.39,143.86) 30.47,143.86 30.69,144.08 CG247.2 ; v2(57.17,144.03) 57.05,143.91 CG251.2 56.5,143.91 CG252.2 ; v2(67.71,142.53) 67.71,142.53 CG263.2 ; 150.92,59.62 JDIM3.82 ; v1(51.39,24.08) 51.37,24.1 51.37,24.18 50.95,24.6 v1(50.95,24.71) R972.2 ; v2(47.33,98.96) 47.33,98.97 47.27,99.02 CG831.1 CG830.1 ; CN18.15 190.75,24.45 v1(190.9,24.3) ; CG223.2 59.59,146.07 v2(59.44,146.22) ; v2(83.03,144.05) 83.22,144.24 CG243.2 ; CN17.23 12.19,25 12.47,24.72 12.71,24.72 v1(13.07,24.35) ; v2(74.75,154.53) 74.69,154.6 CG123.2 ; 33.19,153.99 CG149.2 ; 170.92,59.63 JDIM3.2 ; v1(257.04,52.9) 257.04,52.9 256.79,53.16 R774.1 ; CG148.2 83.06,153.02 v2(83.06,153.01) ; CG814.2 43.22,99.82 CG813.2 42.87,99.82 42.61,100.07 v2(42.61,100.09) ; 154.42,59.62 JDIM3.68 ; v2(80,155.28) 79.9,155.39 CG104.2 ; v2(12.75,127.05) 12.75,127.38 CG327.2 ; v1(58.9,40.75) CN16.33 ; QG23.4 47.2,78.87 47.49,78.58 v1(47.49,78.22) ; JDIM4.192 121.42,46.66 ; 115.92,46.7 JDIM4.214 ; JDIM4.201 119.17,35.53 ; CG227.2 42.61,145.56 v2(42.62,145.55) ; CG278.2 81.88,141.16 82.25,141.54 v2(82.25,141.78) ; CG513.2 98.55,116.41 v2(98.44,116.51) ; 155.42,59.62 JDIM3.64 ; CG510.2 95.56,116.39 v2(95.41,116.54) ; v2(66.67,106.79) 66.41,107.04 CG703.2 ; 153.42,59.62 JDIM3.72 ; JDIM4.209 117.17,35.51 ; CN15.15 188.51,49.5 v1(188.1,49.91) ; v2(61.02,143.86) 60.96,143.8 v2(60.96,143.29) ; JDIM4.47 159.67,38.36 159.5,38.53 v1(159.5,38.74) ; CG239.2 72.22,144.29 v2(72.45,144.06) 72.04,143.65 CG255.2 ; v1(176.01,115.25) CN10.7 ; 147.92,59.64 JDIM3.94 ; CG210.2 41.91,146.35 v2(41.87,146.3) ; CG521.2 23.6,115.83 v2(23.27,116.16) ; CN15.33 188.46,45 188.36,44.9 v1(188.28,44.9) ; v2(74.75,146.28) 74.54,146.5 CG211.2 ; CN10.21 v1(175.9,122.25) ; v1(20.14,96.1) 20.15,96.09 PC448.2 20.18,95.11 PC334.2 ; CN10.16 v1(175.84,119.75) ; JDIM4.217 115.17,35.53 ; JDIM4.252 106.42,46.73 ; v2(85.64,109.56) v2(86.39,108.81) ; 122.42,46.67 JDIM4.188
  BOTTOM w0.3: v2(50.14,155.28) 50.3,155.12 50.72,155.12 v2(50.89,155.28) v2(51.64,155.28) ; v2(59.45,154.53) v2(58.7,155.28) ; RG116.2 94.65,112.1 94.65,111.07 v2(94.64,111.06) ; v2(44.14,142.53) v2(43.39,141.78) ; v2(52.42,150.78) v2(52.43,151.49) ; v2(34.09,142.52) 34.09,142.52 v2(34.83,141.78) 35.57,142.53 v2(35.57,142.53)
  BOTTOM w0.305: CG297.2 10.45,133.01 v2(10.51,132.95) ; v1(224.94,26.93) 225.1,26.93 225.65,27.48 R940.1 ; v1(82.11,20.59) 82.11,20.44 82.15,20.4 CN19.14 ; v1(82.82,20.54) 82.82,20.49 82.65,20.32 CN19.13 ; v1(157.29,112.52) 157.11,112.69 C659.1 ; C945.2 98.48,18.04 98.09,18.43 ; v1(11.04,36.14) 11.18,36 CN17.45 ; RG91.2 85.03,148.35 v2(84.56,148.82) ; UG5.3 7.09,87.2 6.79,87.51 6.79,88.03 ; v1(11.04,34.22) 11.32,34.5 CN17.42 ; v2(57.95,143.28) 57.22,142.56 v2(57.17,142.56) ; v2(80.75,141.78) 80.75,141.61 80.1,140.95 CG286.2 ; CG366.2 86.99,122.82 87.28,123.11 87.67,123.11 v2(87.89,123.32) ; v1(10.99,26.57) 11.06,26.5 CN17.26 ; D112.3 282.24,13.3 v1(282.24,13.73) ; v2(18.65,122.35) 19.02,121.98 RG106.2 ; CN20.21 37.14,17.45 38.14,16.45 v1(38.14,15.26) ; v1(11.02,28.09) 11.12,28 CN17.29 12.25,28 12.62,28.36 v1(12.67,28.36) ; CN17.20 12.25,23.5 12.52,23.77 v1(12.74,23.77) ; CN17.36 11.06,31.5 v1(11.04,31.48) ; v1(11.04,32.93) 11.11,33 CN17.39 ; v1(185.45,38.65) 185.45,37.8 184.77,37.11 J1.2 ; CN17.32 v1(10.58,29.5) ; RG104.2 15,122.2 v2(15,123.09) ; CG352.2 24.74,124.62 24.07,124.62 v2(24.01,124.69) ; v1(13.15,21.76) 12.91,22 CN17.17
  BOTTOM w0.381: C845.1 214.78,28.63 v1(214.45,28.31) ; v1(94.61,26.46) 94.12,26.95 R1158.1 93.56,27.26 C873.2 ; PQ38.1 7.55,171.15 v1(7.7,171.3) ; v1(79.75,53.99) 79.75,53.92 78.95,53.12 PC409.2 ; v1(96.66,157.37) 96.21,156.92 C526.2 ; v1(26.41,53.96) 26.41,54.06 25.67,54.8 PC388.2 ; v1(222.03,33.13) 222.03,33.39 C814.1 ; v2(17.89,107.75) 17.89,107.46 CG702.2 ; v2(46.01,153.17) 46.07,153.11 CG139.2 ; CG162.2 78.14,151.21 v2(78.15,151.2) ; CG834.2 46.17,99.73 46.17,99.26 46.38,99.05 v2(46.4,99.05) ; v2(41.51,96.26) 41.51,96.37 42.16,97.02 RG150.2 ; CN17.46 v1(9.72,12.5) ; v1(209.29,37.17) 209.29,37.8 C793.1 ; RG172.1 15.82,90.05 15.42,89.65 RG174.1 ; RG137.2 40.81,101.28 v2(40.81,101.85) ; RG113.2 93.15,115.7 v2(93.83,115.03) 93.63,114.83 CG553.2 ; RG163.1 40.81,95.57 v2(40.99,95.75) ; C898.2 77.12,21.43 v1(77.56,21.43) 77.56,20.78 D111.2 ; v2(34.83,141.78) 34.93,141.68 CG287.2 ; RG84.2 68.37,150.25 67.86,150.76 v2(67.81,150.76) ; CG179.2 53.28,150.31 v2(53,150.03) ; PQ39.1 12.13,170.76 v1(11.55,170.76) ; v1(94.75,24.95) 95.75,23.96 Q77.1 ; R1010.2 65.17,22.05 65.17,22.78 v1(65.21,22.82) ; v2(45.04,99.03) 45.1,98.98 RG149.1 ; CG265.2 30.91,142.86 30.48,143.29 30.34,143.29 v2(30.34,143.29) ; QG22.1 29.87,80.38 v1(30.13,80.12) ; v1(213.79,28.26) 213.79,28.6 C846.1 ; v2(14.81,107.72) 14.81,107.29 RG119.2 ; RG142.2 90.32,99.33 v2(89.91,98.92) ; R783.1 205.01,51.46 v1(204.34,50.79) ; RG168.1 43,94.19 v2(43,94.38) ; R727.1 176.39,63.35 v1(176.24,63.19) ; v1(90.82,61.28) 90.82,62.57 R725.1 90.99,63.41 C692.1 90.99,64.49 C693.1 ; CG484.2 38.13,116.35 v2(38.14,116.35) ; R802.1 106.25,47.49 ; R647.2 v1(90.72,159.81) v1(91.66,158.87) ; R947.2 46.95,26.72 v1(46.35,27.32) 45.97,26.94 R949.2 ; RG101.1 13.37,134.34 v2(12.78,133.76) ; RG157.2 40.64,97.09 40.77,96.96 v2(40.8,96.96) ; CG294.2 11.41,136.32 v2(11.19,136.54) ; RG93.2 54.21,148.66 CG191.2 54.12,149.12 v2(53.87,149.36) ; RG100.2 v2(12.62,136.62) ; v1(8.4,114.78) 8.5,114.78 CG555.2 8.58,113.32 v1(8.4,113.32) ; CG862.2 49.01,95.17 v2(49.35,94.83) ; RG156.1 45.36,96.87 45.52,97.02 v2(45.69,97.02) ; v1(65.89,160.92) 65.79,160.82 U37.3 v1(62.72,160.82) ; v2(47.11,97.71) 46.47,97.07 CG856.2 ; v2(24.41,151.15) 24.36,151.19 U38.5 ; RG166.1 45.87,93.89 45.46,94.3 v2(45.18,94.3) ; v1(62.59,164) U33.3 v1(64.96,164) ; v2(38.14,120.4) 38.14,120.62 CG402.2 ; RG89.2 40.57,147.63 v2(41.02,147.18) ; v2(47.72,97.02) 47.87,97.02 48.25,97.4 RG148.1 ; v1(97.5,73.19) 97.48,73.17 C691.2 ; v1(13.15,26.23) 13.7,25.68 R956.2 ; C508.2 76.6,161.99 v1(76.78,162.17) ; RG87.2 38.55,149.58 v2(38.56,149.59) ; 98.09,18.43 v1(98.09,18.94) ; R994.2 53.1,23.11 v1(52.58,23.63) ; v2(50.58,99.12) 50.58,98.41 RG144.1 ; v2(93.18,99.08) 93.07,99.18 CG835.2 ; R1058.2 211.2,20.72 v1(211.1,20.82) ; v1(280.36,19.05) 280.44,19.14 R1030.1 ; v1(17.54,93.86) 17.63,93.86 17.63,93.86 18.4,93.86 18.41,93.86 18.44,93.86 PC335.1 ; RG177.1 46.36,84.26 46.91,84.8 v1(47.14,84.8) ; v2(95.9,113.78) 96.67,113.02 RG115.2 ; v2(41.42,101.79) 41.83,101.38 CG779.1 ; v1(13,105.55) 13.03,105.59 13.31,105.59 13.31,105.59 QG19.1 ; v2(40.2,150.33) 39.94,150.06 RG85.2 ; CG865.1 41.97,94.31 41.23,94.31 v2(41.15,94.39) 41.15,93.76 RG169.1 ; R697.1 179.44,107.23 R696.1 ; v1(91.47,50.19) 90.81,50.86 PQ54.1 ; v1(13.79,92.96) 14.39,92.96 PQ45.1 ; RG167.1 40.07,93.93 39.66,93.52 39.44,93.52 39.42,93.5 v2(39.41,93.5) ; U35.2 71.12,160.76 71.86,160.03 Q58.1 ; v2(49.43,127.65) 48.94,128.14 CG387.2 ; v1(46.48,91.96) 45.87,92.57 RG170.1 ; v1(89.04,53.84) 89.04,54.03 90.33,55.32 PQ50.1 ; CG726.2 v1(100.15,106.31) ; R992.2 38.95,22.87 v1(39.31,22.52) ; C905.2 79.53,21.16 79.96,21.59 C895.2 79.96,22.77 80.27,23.08 PC437.2 ; C676.2 182.56,95.43 182.76,95.22 v1(182.76,94.85) ; v1(24.99,155.67) 25.4,156.08 CG102.2 ; v1(22.98,60.14) 22.9,60.14 22.9,60.09 22.51,59.69 PC355.2 ; v1(43.38,26.89) 43.34,26.93 C858.1 ; RG164.1 52.46,94.88 51.98,94.88 v2(51.84,94.75) ; v2(64.59,96.99) 64.82,97.22 64.87,97.22 CG854.2 ; D109.2 74.06,21.83 74.44,21.45 74.44,21.43 v1(74.54,21.33) 74.54,21.09 C906.2 ; R708.1 182.75,93.27 v1(182.99,93.03) ; CG644.2 71.59,110.08 v2(71.41,109.89) ; v2(12.6,120.25) 11.78,121.07 CG403.2 ; v1(185.45,38.65) 186.07,38.65 R848.1 ; CG849.2 61.84,98.37 v2(61.82,98.39) ; v2(38,95.64) 37.96,95.67 RG160.1 ; R960.1 230.24,24.39 v1(230.27,24.39) ; v1(83.93,162.19) 84.07,162.05 84.07,161.86 84.22,161.71 ESD1.3 v1(84.22,159.65) ; RG102.2 91.4,129.72 v2(92.04,129.07) ; v2(257.51,55.62) 257.51,54.98 R763.2 ; v2(55.71,149.17) 55.68,149.15 CG192.2 ; v1(91.04,34.04) 90.56,34.04 89.74,34.86 Q73.1 ; R648.2 56.52,159.05 v1(56.79,159.05) 56.81,159.06 C515.1 ; v1(200.4,51.22) 200.4,51.07 199.78,50.45 R789.1 ; v2(65.99,120.74) 65.99,120.28 RG107.1 ; R926.2 40.35,28.75 40.73,28.37 v1(40.73,28.21) ; v2(38.64,97.1) 38.35,97.1 37.98,97.46 RG151.1 ; v1(87.47,161.97) 86.98,161.49 86.98,161.27 R643.1 ; CG272.2 56.2,142.46 CG271.2 ; RG136.1 39.41,101.96 v2(39.59,101.77) ; CG893.1 51.59,84.25 51.59,84.76 v1(51.64,84.81) ; v1(80.32,160.98) 80.81,161.46 R640.1 ; CG575.2 84.56,117.31 v2(85.64,117.31) ; v1(83.89,22.65) 84.07,22.83 D108.2 ; v2(71.68,147.27) 71.36,147.27 71.27,147.37 RG92.2 ; R961.2 201.09,25.7 v1(201.09,26.18) ; v2(61.81,106.84) 61.67,106.84 61.32,107.18 CG709.2 60.73,107.18 v2(60.35,106.8) ; C787.1 212.16,39.54 211.58,38.95 v1(211.58,38.83) ; v2(37.14,150.78) 37.09,150.83 v2(37.09,151.55) ; v1(52.5,28.14) 52.69,28.14 53.1,27.74 R938.2 ; v1(71.51,23.88) 70.91,23.88 C877.2 ; R1029.2 v1(277.89,21.07) ; v2(64.56,99.08) 64.21,98.72 CG842.2 64.2,98.02 v2(63.89,97.71) ; v1(282.64,4.85) 282.7,4.91 R1142.1 ; v2(62.27,127.2) 62.75,127.68 CG312.2 ; RG94.2 37.16,147.05 v2(37.13,147.08) ; v1(211.16,22.83) 211.33,23 R988.1 ; v1(219.96,15.61) 220.11,15.46 R1164.2 ; v1(48.2,27.17) 48.72,26.65 R955.2 ; v1(174.91,98.18) 175.23,97.86 R703.2 ; R752.2 261.63,56.62 v2(261.68,56.67)
  BOTTOM w0.4: v2(9.54,131.94) 8.81,132.66 CG298.2 ; v2(50.51,155.72) 50.14,155.35 v2(50.14,155.28)
  BOTTOM w0.406: RV3.2 71.1,165.39 69.69,163.97 v1(69.69,163.5)
  BOTTOM w0.508: CG226.2 54.19,146.29 52.4,146.29 v2(52.4,146.28) ; v2(98.62,128.95) 98.92,129.25 CG309.2 ; PR510.2 233.95,50.18 v1(234.11,50.03) ; R1036.2 217.06,19.19 217.06,18.21 v1(217.29,17.97) ; v1(71.81,54.43) 71.88,54.37 72.6,54.37 PC178.2 ; R865.2 259.49,36.7 v1(259.94,37.15) ; v1(87.88,43.98) 87.28,44.58 PJ22.11 ; C705.1 180.84,59.14 181.95,60.26 181.95,60.26 182.27,60.57 v1(182.77,60.57) 182.77,62.72 SW2.2 ; QG21.1 45.09,82.96 v1(44.64,83.4) ; CG289.2 74.03,141.76 v2(74,141.78) ; R686.1 155.79,133.18 v1(155.66,133.06) ; CG422.2 8.2,121.15 8.54,121.49 v2(8.54,121.75) 8.52,121.77 CG358.2 ; v1(180.85,153.59) 180.85,153.91 PQ41.1 ; CG143.2 40.97,152.78 41.22,153.03 v2(41.86,153.03) ; PC397.2 73.68,54.21 v1(73.68,53.74) 73.75,53.66 74.8,53.66 PC410.2 ; v2(63.95,152.28) 63.82,152.41 CG161.2 ; U13.75 246.69,36.12 246.18,36.63 R870.1 ; v1(44.6,53.74) 44.6,54.08 PC400.2 ; R903.2 280.57,31.83 v1(280.23,32.17) ; v2(37.09,151.55) 37.63,151.55 37.85,151.77 CG156.2 ; v1(212.9,15.69) 213,15.79 213,16.12 R1104.2 ; R871.2 236.63,35.56 236.84,35.56 v1(237.18,35.22) ; v1(82.12,53.57) 81.76,53.94 PC389.2 ; PC438.2 77.44,23.22 v1(77.02,23.64) 76.48,23.11 PC441.2 ; v2(59.45,141.78) 59.45,141.46 59.32,141.33 CG290.2 ; v1(202.28,37.1) 202.28,37.87 C800.2 ; C785.2 98.55,41.5 98.29,41.76 v1(98.29,41.85) ; v1(64.46,45.15) 64.13,45.47 PJ22.12 ; R1020.2 261.39,20.99 v1(261.87,20.51) ; v1(248.76,46.14) 248.46,45.84 R813.2 ; PC175.2 43.64,54.37 42.92,54.37 v1(42.85,54.43) ; C696.2 12.87,51.63 13.66,50.84 v1(13.66,50.03) ; CG384.2 97.47,122.71 97.65,122.89 v2(97.65,123.3) ; PQ58.1 179.1,37.87 PR582.2 179.55,39.1 179.55,40.76 180.49,41.7 180.49,45.16 v1(181,45.68) ; C711.1 205.88,54.91 v1(206.27,54.52) ; 33,82.77 33.91,83.69 33.94,83.69 v1(34.01,83.76) ; 33,82.77 32.31,82.77 32.29,82.76 RG184.2 ; 33,82.77 CG899.2 ; v1(198.3,23.32) 198.34,23.36 R990.2 ; R661.2 82.96,157.39 v1(82.54,156.98) ; v2(87.89,123.32) 87.89,123.24 88.06,123.07 CG379.2 ; CG313.2 8.73,128.64 8.12,129.25 v1(8.12,129.38) ; v1(8.15,118.69) 8.2,118.64 CG483.2 ; v2(16.59,129.28) 17.12,128.75 CG314.2 ; v2(38.13,114.15) 38.13,114.53 38.34,114.74 CG535.2 ; v1(273.5,26) 273.59,25.92 R963.1 ; PC328.2 119.63,147 v3(119.17,146.55) ; R884.1 245.31,34.07 245.23,33.99 v1(245.02,33.99) ; RG117.2 91.56,112.04 v2(91.36,111.84) ; PC396.2 83.08,53.76 v1(83.2,53.64) ; PC353.2 42.7,61.88 v1(43,61.58) ; v2(40.79,107.53) 40.99,107.33 RG120.2 40.99,106.64 v2(41.49,106.14) ; v1(221.56,58.79) 221.07,58.3 PR486.2 220.3,58.3 218.96,56.96 PQ49.1 ; CG565.2 16.13,113.83 v2(16.76,113.83) ; CG288.2 49.79,140.33 49.79,140.92 50.01,141.14 50.01,141.65 v2(50.14,141.78) ; CG585.2 98.57,111.17 v2(98.51,111.11) ; v1(223.64,57.88) 222.74,58.78 PQ48.1 ; R877.1 227.68,34.96 v1(227.68,34.36) ; v1(201.29,44.59) 200.96,44.93 Y5.2 ; v2(100.32,126.19) 100.32,126.19 CG332.2 ; R1052.2 208.94,18.61 v1(208.7,18.38) ; CG221.2 38.38,146.77 38.1,147.05 RG94.2 ; C927.1 225.34,15.13 v1(225.34,15.71) 225.19,15.86 C922.2 ; PC401.2 35.69,54.41 v1(36.21,53.89) ; v2(45.69,143.26) 45.91,143.26 46.49,142.68 CG268.2 ; R1092.1 260.25,15.65 260.19,15.59 v1(260.19,15.51) ; CG292.2 43.24,139.18 CG285.2 43.24,141.64 v2(43.39,141.78) ; v1(222.02,13.03) 221.35,13.71 R1124.1 ; CG150.2 54.55,151.64 v2(54.7,151.49) ; CG284.2 65.64,141.35 65.45,141.54 v2(65.45,141.78) ; D107.2 83.99,24.15 v1(83.81,23.97) ; C874.1 262.63,23.83 v1(262.63,23.69) 262.03,24.29 R976.1 ; C919.2 R1042.2 261.54,19.6 v1(261.89,19.24) ; R852.1 229.55,37.71 v1(230.01,38.17) ; v1(25.22,53.97) 24.87,53.97 PC395.2 ; R655.1 R656.1 50.2,157.44 v1(49.95,157.19) ; CG94.2 73.03,156.06 73.28,155.82 v2(73.28,155.6) ; v1(99.05,155.01) 98.57,155.49 R665.1 ; C502.2 72.04,163.54 72.48,163.1 72.55,163.1 72.56,163.09 73.51,163.09 Q56.1 v1(73.75,165.03) RV2.2 73.45,165.93 v1(73.81,166.28) ; v1(234.71,39.67) 234.94,39.44 235.56,39.44 235.99,39.01 EC8.1 ; R978.2 200.67,24.35 v1(200.77,24.44) ; R770.2 97,54.38 PU23.32 ; v1(211.2,35.62) 210.97,35.62 210.58,36.01 EC9.1 ; R1071.2 220.95,18.25 v1(220.78,18.41) ; C911.1 265.91,19.47 v1(265.22,18.79) ; v1(80.79,159.68) 80.79,159.79 C509.2 ; PC177.2 64.21,54.43 PC398.2 64.66,53.99 v1(65.06,53.99) ; v1(179.22,106.39) 179.57,106.75 R696.1 ; v1(266.01,17.47) 266.68,16.8 R1082.2 ; PC295.2 181.67,170.77 181.23,171.21 v1(181.19,171.21) ; v1(54.28,53.78) 54.28,54.12 PC399.2 ; v1(189.25,61.71) 189.5,61.96 SW2.1 ; v1(32.95,29.75) 32.95,29.28 C850.2 ; R867.1 208.42,37 v1(208.2,37.23) ; v1(247.8,27.58) 247.8,28.11 247.29,28.62 R918.1 ; R850.1 227.67,37.79 v1(227.67,38.61) ; CG116.2 68.55,155 68.14,154.58 v2(67.75,154.58) ; v1(25.48,145.51) 25.26,145.51 24.95,145.19 RG98.1 ; v1(273.31,59.19) 273.31,58.48 C703.2 ; CG293.2 34.91,140.38 CG287.2 ; v1(172.33,91.25) 172.15,91.43 171.69,91.43 171.35,91.77 170.61,91.77 170.16,92.21 R709.1 ; C786.1 202.51,39.65 v1(202.51,39.31) ; R1095.2 218.34,15.79 v1(218.37,15.76) ; CG93.2 65.72,155.75 65.45,155.47 v2(65.45,155.28) ; CG859.2 66.53,96.27 v2(66.53,95.84) ; CG702.2 17.6,106.73 17.76,106.57 RG125.2 ; v1(13.99,101.57) 14.11,101.45 Q64.1 ; v2(60.2,149.97) 60.35,150.12 CG177.2 ; v2(95.9,113.78) 95.43,114.25 CG538.2 ; v1(97.82,59.2) 97.31,59.2 C700.2 ; PQ42.1 181.26,150.73 v1(180.85,150.32) ; v1(237.76,51.73) 237.16,51.13 PR508.2 ; v1(206.8,22.29) 206.71,22.39 206.71,22.78 C887.1 ; v1(256.43,51.77) 256.1,51.77 R784.2 ; SW2.5 186.93,64.43 v1(187.39,64.43) ; v1(171.19,137.16) 171.91,136.44 C536.2 ; CN12.6 200.63,56.5 v1(200.63,55.54) ; PQ59.1 178.39,18.7 v1(178.81,18.28) ; v2(100.35,118.72) 100.66,118.72 100.97,119.02 CG432.2 ; v1(76.43,157.1) 76.6,157.26 C522.2 ; CG729.2 17.75,104.73 v1(17.01,103.99) 16.57,103.99 16.21,103.62 v1(16.21,103.23) ; PC174.2 33.99,54.37 33.27,54.37 v1(33.2,54.43) ; v2(98.77,114.62) 98.45,114.62 98.1,114.28 CG564.2 ; PQ57.1 248.62,18.89 v1(249.12,18.39) 249.31,18.2 249.31,17.82 R1076.1 ; C707.2 197.12,55.69 v1(198.32,54.5) ; CG704.2 12.35,106.99 v1(11.75,107.59) ; v2(52,96.97) 52.02,96.94 RG152.1 ; C836.1 222.51,30.12 v1(221.99,29.6) ; C525.1 R652.2 46.97,157.51 v1(46.34,158.14) ; C813.1 210.76,34.43 v1(211.02,34.69) ; PC336.2 7.99,89.87 v1(7.89,89.78) 7.27,89.16 PC337.2 6.79,88.61 6.79,88.03 ; R1111.1 39.59,15.83 v1(39.59,15.31) ; CG291.2 51.58,140.05 v2(50.7,140.92) ; v2(57.17,142.56) 56.79,142.56 56.68,142.45 CG272.2 ; CG187.2 v1(88.28,148.78) ; v1(269.61,36.92) 269.52,37.02 R853.1 ; v1(207.87,20.72) 207.54,20.39 R1054.1 ; Y5.4 198.95,46.28 198.85,46.38 v1(198.3,46.38) ; v1(43.38,78.55) 43.11,78.29 43.11,77.97 CG900.1 ; v1(237.1,32.35) 237.1,32.65 R889.2 ; v1(127.27,112.39) 127.2,112.46 C668.2 ; CG169.2 87.82,150.38 v1(88.11,150.38) ; C896.2 71.63,22.52 72.63,22.52 v1(72.65,22.53) 72.84,22.34 C901.2 ; R944.1 230.63,27.11 230.91,26.83 v1(230.91,26.61) ; v2(76.46,142.42) 76.46,142.55 76.97,143.06 CG253.2 ; RG106.2 19.34,121.28 CG398.2 ; CG218.2 v1(88.43,146.59) ; R920.1 252.25,29.12 C854.1 253.4,28.5 v1(253.59,28.31) ; CG281.2 36.43,141.69 v2(36.33,141.78) ; v2(83.07,154.53) 83.15,154.61 CG122.2 ; R858.2 205.54,36.99 v1(205.98,36.55) ; CG194.2 v1(88.41,148.05) ; RV3.2 71.09,165.49 RV4.2 69.59,165.49 v1(69.49,165.59) ; R704.2 v1(172.86,99.4) 173.93,100.47 v1(174.72,100.47) ; v1(248.12,13.65) 248.12,13.89 247.89,14.12 C928.1 ; PC354.2 33.12,61.88 v1(33.37,61.63) ; v1(52.39,55.16) 53.12,54.43 PC176.2 ; v2(66.95,141.78) 66.95,141.64 67.22,141.36 CG283.2 ; R695.1 181.39,107.09 v1(181.6,107.31) ; R1051.1 R1050.1 224.69,20.45 v1(224.53,20.61) ; v1(91.22,15.66) 90.74,15.66 CN19.45 ; CG157.2 57.1,152.94 v2(57.2,153.03) ; CG335.2 8.51,127.77 v2(8.57,127.83) ; v1(199.51,59.55) 199.44,59.62 CN12.4 ; PC440.2 PC439.2 241.18,23.02 241.39,22.81 v1(241.71,22.81) ; PQ55.1 38.02,36.7 38.27,36.95 38.27,37.13 v1(38.28,37.14) ; v1(175.51,49.09) 174.73,48.31 C759.2 ; CG311.2 12.49,128.72 v2(12.3,128.91) ; R1040.1 221.64,20.79 221.74,20.9 v1(221.74,21.21) ; R1116.2 247.89,15.93 v1(247.67,16.15) ; C912.1 252.49,18.53 v1(252.29,18.33) 252.24,18.28 R1083.1 ; v1(186.53,59.66) 186.4,59.52 SW2.6 ; v1(23.59,61.38) 23.33,61.65 PC378.2 ; v1(108.15,126.61) 108.51,126.61 109.02,127.12 C559.1 ; U35.2 69.28,160.76 69.06,160.98 v1(69.06,160.98) ; v2(85.64,124.81) 84.7,124.81 84.34,124.44 CG350.2 ; QG24.1 28.86,77.23 v1(28.39,77.7) ; R1041.1 222.65,20.35 223.04,20.74 v1(223.04,20.83) ; C798.1 213.4,37.28 v1(213.46,37.21) ; v2(10.44,110.18) v1(9.73,110.18) CG587.2 ; C838.1 209.18,30.06 v1(208.68,29.56) 208.6,29.48 R914.2 ; v2(44,92.12) 43.58,92.54 CG869.1 ; CG151.2 69.43,153.24 v2(69.89,153.69) 70.31,154.12 CG115.2 ; PQ51.1 v1(222.33,53.57) v1(223.49,52.42) ; EC10.1 203.21,28.8 v1(203,28.59) ; v1(211.52,29.05) 211.43,28.96 C852.1 ; v2(85.64,118.81) 85.12,119.34 CG423.2 ; TP116.1 252.24,22.14 v1(251.73,21.63) ; C701.2 195.48,58.78 195.48,58.44 v1(195.48,58.43) ; CG168.2 68.39,151.55 v2(67.71,151.55) ; RG178.1 33.23,84.59 v1(33.55,84.91) ; v1(24.73,77.66) 24.73,76.96 QG25.1 ; CN16.76 57.94,31.65 v1(58.71,30.89) ; C538.2 v1(171.97,134.21) ; C811.1 221.04,35.16 221.46,34.74 v1(221.46,34.61) ; v1(98.57,160.87) 98.11,160.42 U36.2 ; v1(178.77,156.26) PC319.2 ; CG543.2 24.97,116.72 CG487.2 24.07,116.83 v2(24,116.9) ; CN8.20 39.79,163.95 v1(40.46,163.29) ; C729.2 R778.2 177.78,50.65 v1(176.14,52.29) ; v1(228.47,13.58) 228.47,13.92 EC12.1 ; CG345.2 100.66,124.75 v2(100.26,125.15) ; C848.2 98.17,28.18 v1(98.17,27.8) 98.12,27.85 98.06,27.85 97.83,28.08 97.83,28.14 97.5,28.47 C849.2 ; R1080.2 277.73,17.65 277.52,17.44 v1(277.28,17.44) ; C931.2 250.96,13 250.84,13.12 v1(250.84,13.83)
  vias: v1(1.29,54.65) v1(1.29,51.86) v1(3.57,55.67) v1(5.28,77.69) v1(5.28,72.48) v1(5.28,64.66) v1(5.36,144.03) v1(5.36,141.06) v1(5.36,131.11) v1(5.36,128.54) v1(5.36,123.38) v1(5.36,120.87) v1(5.36,118.36) v1(5.36,115.76) v1(5.36,105.6) v1(5.34,90.4) v1(5.32,87.93) v1(5.36,85.31) v1(5.35,75.07) v1(5.3,70.15) v1(5.34,62.41) v1(5.34,59.87) v1(5.34,57.33) v1(5.48,108.3) v1(5.52,174.19) v1(5.52,171.65) v1(5.52,169.11) v1(5.52,166.57) v1(5.52,164.03) v1(5.52,161.49) v1(5.52,158.95) v1(5.52,156.41) v1(5.52,153.87) v1(5.52,151.33) v1(5.52,148.79) v1(5.52,146.25) v1(5.52,136.09) v1(5.52,133.55) v1(5.52,125.93) v1(5.52,113.23) v1(5.52,110.69) v1(5.52,103.07) v1(5.52,100.53) v1(5.52,82.75) v1(5.52,80.21) v1(5.52,35.47) v1(5.52,32.93) v1(5.52,30.39) v1(5.52,27.85) v1(5.56,26.94) v1(5.52,25.31) v1(5.52,22.77) v1(5.52,20.23) v1(5.52,17.69) v1(5.52,15.15) v1(5.52,12.61) v1(5.52,10.07) v1(5.86,55.16) v1(5.91,37.98) v1(6.21,176.64) v1(6.62,52.62) v1(7,8.02) v1(7.38,50.59) v1(7.38,48.3) v1(7.38,46.02) v1(7.38,43.73) v1(7.38,41.7) v1(7.38,39.67) v1(8.05,17.42) v1(8.12,164.71) v1(8.15,157.65) v1(8.15,35.98) v1(8.25,81.65) v1(8.26,77.36) v1(8.39,15.39) v1(8.43,82.72) v1(8.75,176.68) v1(8.78,175.17) v1(8.73,82.13) v1(8.81,164.28) v1(9.19,159.24) v1(9.16,74.97) v1(9.16,73.83) v1(9.28,28.31) v1(9.54,148.91) v1(9.54,8.02) v1(9.8,157.65) v1(10.01,159.12) v1(10.05,74.08) v1(10.28,166.01) v1(10.56,157.65) v1(10.56,74.97) v1(10.81,159.17) v1(10.81,73.32) v1(10.95,165.92) v1(10.94,45.78) v1(11.39,40.69) v1(11.54,175.41) v1(11.58,159.17) v1(11.51,46.15) v1(11.55,42.05) v1(11.87,54.4) v1(12.04,53.76) v1(12.08,8.02) v1(12.64,58.95) v1(12.72,23.03) v1(13.17,169.68) v1(13.14,168.59) v1(13.14,164.19) v1(13.14,163.55) v1(13.65,164.9) v1(13.63,159.17) v1(13.63,157.9) v1(13.73,169.13) v1(13.85,10.35) v1(13.86,8.06) v1(14.08,175.41) v1(14.25,169.7) v1(14.24,168.57) v1(14.52,159.17) v1(14.52,157.9) v1(14.55,43.88) v1(14.69,12.39) v1(15.28,159.17) v1(15.28,157.9) v1(15.51,48.71) v1(15.64,18.08) v1(16.09,17.43) v1(16.17,159.17) v1(16.17,157.9) v1(16.56,17.9) v1(16.62,175.41) v1(16.66,166.28) v1(16.61,43.51) v1(16.66,42.82) v1(16.83,164.79) v1(17.06,159.17) v1(17.16,99.25) v1(17.14,61.21) v1(17.34,60.57) v1(17.34,43.58) v1(17.42,158.18) v1(17.47,42.87) v1(17.62,167.22) v1(17.85,61.18) v1(17.87,50.11) v1(17.82,37.03) v1(18.08,60.57) v1(18.43,65.22) v1(18.56,61.18) v1(18.75,49.95) v1(18.76,49.24) v1(18.81,60.57) v1(18.84,58.21) v1(18.84,57.55) v1(18.94,63.29) v1(19.16,175.41) v1(19.3,61.18) v1(19.32,12.82) v1(19.6,102.18) v1(19.7,157.9) v1(19.7,60.6) v1(19.93,156.33) v1(20,61.19) v1(20.34,68.88) v1(20.34,67.99) v1(20.47,70.91) v1(20.41,60.62) v1(20.79,144.9) v1(21.08,60.62) v1(21.7,175.41) v1(21.86,101.92) v1(21.86,36.36) v1(21.81,12.75) v1(22.14,34.84) v1(22.41,18.25) v1(22.55,34.23) v1(22.9,167.17) v1(22.95,166.49) v1(23.03,171.95) v1(23.08,171.26) v1(23.01,165.8) v1(23.03,165.12) v1(23.03,164.41) v1(23.03,163.62) v1(23.11,170.58) v1(23.11,169.87) v1(23.11,169.08) v1(23.25,18.25) v1(23.55,18.89) v1(23.67,167.15) v1(23.79,171.92) v1(23.72,166.46) v1(23.77,165.78) v1(23.79,165.09) v1(23.79,164.38) v1(23.79,163.59) v1(23.84,171.24) v1(23.87,170.55) v1(23.87,169.84) v1(23.87,169.05) v1(23.84,12.67) v1(23.97,18.27) v1(24.24,175.41) v1(24.24,18.89) v1(24.58,171.21) v1(24.5,165.75) v1(24.53,165.07) v1(24.53,164.35) v1(24.53,163.57) v1(24.53,162.63) v1(24.56,99.61) v1(24.53,60.11) v1(24.61,170.53) v1(24.61,169.82) v1(24.61,169.03) v1(25.16,19.12) v1(25.29,99.58) v1(25.37,104.61) v1(25.42,171.49) v1(25.55,107.13) v1(25.55,61.79) v1(25.72,106.24) v1(25.8,106.98) v1(25.97,99.58) v1(26.05,61) v1(26.41,106.21) v1(26.56,106.85) v1(26.78,175.41) v1(26.82,61) v1(27.03,12.92) v1(27.58,61) v1(27.83,99.58) v1(28.16,39.21) v1(28.34,61) v1(28.52,99.58) v1(28.72,59.99) v1(28.89,36.05) v1(28.97,58.59) v1(28.97,57.91) v1(28.97,40.86) v1(29,57.24) v1(29,29.73) v1(29.02,27.78) v1(29.1,61) v1(29.22,31.75) v1(29.32,175.41) v1(29.48,60.34) v1(29.48,56.56) v1(29.57,12.92) v1(29.86,61.06) v1(29.89,35.64) v1(30.24,60.37) v1(30.5,157.98) v1(30.59,14.39) v1(30.63,105.88) v1(30.63,61.06) v1(30.99,27.75) v1(31.04,31.73) v1(31.01,29.76) v1(31.15,16.15) v1(31.26,107.99) v1(31.24,14.38) v1(31.3,105.89) v1(31.86,175.41) v1(31.84,16.1) v1(32,158.64) v1(32.11,12.92) v1(32.69,158.61) v1(32.97,27.72) v1(33.04,31.7) v1(34.31,60.11) v1(34.4,175.41) v1(34.48,32.88) v1(34.65,12.92) v1(35.71,61) v1(35.71,60.19) v1(36.47,61) v1(36.65,157.35) v1(36.72,18.84) v1(36.94,175.41) v1(37.23,61) v1(37.31,157.35) v1(37.74,40.81) v1(37.99,61) v1(38.08,40.24) v1(38.25,60.24) v1(38.25,59.5) v1(38.63,58.59) v1(38.63,57.93) v1(38.64,57.27) v1(38.79,85.27) v1(38.75,61) v1(38.75,14.6) v1(39.13,60.34) v1(39.26,46.52) v1(39.26,44.62) v1(39.48,175.41) v1(39.52,61.06) v1(39.64,14.52) v1(39.9,60.37) v1(40.15,45.66) v1(40.28,61.06) v1(40.33,157.95) v1(40.91,175.43) v1(40.98,157.96) v1(41.17,46.52) v1(41.17,44.62) v1(42.41,84.8) v1(43.12,84.78) v1(43.35,156.63) v1(43.45,34.84) v1(43.45,33.95) v1(43.56,166.57) v1(43.96,59.86) v1(44.09,84.88) v1(44.09,34.46) v1(44.09,21.38) v1(44.24,159.17) v1(44.29,25.05) v1(44.36,26.89) v1(44.33,25.95) v1(44.72,34.84) v1(44.72,33.82) v1(44.85,159.93) v1(44.96,160.9) v1(44.9,159.17) v1(45.1,84.85) v1(45.36,61) v1(45.36,60.19) v1(46.12,84.85) v1(46.12,61) v1(46.88,61) v1(47.64,61) v1(47.9,60.11) v1(48.15,59.48) v1(48.29,58.63) v1(48.29,57.94) v1(48.29,57.27) v1(48.41,61) v1(48.79,60.34) v1(49.18,61.05) v1(49.42,18.08) v1(49.55,60.37) v1(49.94,61.05) v1(50.39,164.59) v1(50.38,163.51) v1(50.39,162.28) v1(50.59,52.38) v1(51.35,12.77) v1(51.4,164.59) v1(51.4,163.51) v1(51.41,162.28) v1(51.93,176.68) v1(51.94,87.27) v1(52.39,14.19) v1(52.55,164.59) v1(52.54,163.51) v1(52.55,162.28) v1(53.36,164.13) v1(53.49,60.11) v1(53.62,12.76) v1(53.86,163.5) v1(53.96,164.53) v1(53.92,162.31) v1(54.33,177.49) v1(54.33,172.41) v1(55.01,61) v1(55.01,60.19) v1(55.16,91.63) v1(55.16,89.58) v1(55.77,61) v1(55.9,168.7) v1(56.16,12.92) v1(56.42,92.22) v1(56.44,90.17) v1(56.53,61) v1(57.3,61) v1(57.3,43.98) v1(57.42,26.99) v1(57.5,28.11) v1(57.5,25.95) v1(57.5,24.94) v1(57.52,23.74) v1(57.67,60.04) v1(57.93,58.59) v1(57.93,57.89) v1(57.94,57.23) v1(58.06,61) v1(58.44,60.34) v1(58.59,23.74) v1(58.68,87.94) v1(58.64,28.11) v1(58.67,26.97) v1(58.67,25.95) v1(58.66,24.92) v1(58.7,12.92) v1(58.83,61.06) v1(59.29,89.29) v1(59.2,60.37) v1(59.3,91.36) v1(59.6,61.06) v1(59.96,60.37) v1(60.12,40.89) v1(60.21,158.19) v1(60.49,91.08) v1(60.5,89.03) v1(60.8,157.06) v1(60.98,158.28) v1(61.24,12.92) v1(61.39,40.86) v1(61.51,156.48) v1(61.7,89.49) v1(62.12,40.89) v1(62.78,12.26) v1(62.9,89.65) v1(62.96,40.86) v1(63.26,59.99) v1(63.65,84.31) v1(63.85,27.6) v1(63.82,25.37) v1(63.8,24.17) v1(63.97,29.92) v1(64.03,18.28) v1(64.1,90.26) v1(64.11,88.21) v1(64.38,11.27) v1(64.41,84.31) v1(64.41,23.31) v1(64.66,61) v1(64.66,60.19) v1(64.67,18.08) v1(64.95,165.49) v1(64.92,162.5) v1(65.01,26.96) v1(65.17,84.31) v1(65.2,90.45) v1(65.33,88.31) v1(65.35,29.06) v1(65.42,61) v1(65.93,84.31) v1(66.12,163.87) v1(66.19,61) v1(66.53,90.43) v1(66.68,88.3) v1(66.95,61) v1(66.92,11.27) v1(67.31,165.31) v1(67.3,60.3) v1(67.46,59.6) v1(67.57,164.18) v1(67.58,58.59) v1(67.57,57.89) v1(67.58,57.24) v1(67.61,90.62) v1(67.71,61) v1(67.86,88.63) v1(68.09,60.34) v1(68.47,61.04) v1(68.57,17.85) v1(68.67,120.24) v1(68.85,60.37) v1(69.14,84.31) v1(69.27,90.47) v1(69.42,89.22) v1(69.9,84.31) v1(70.07,168.83) v1(70.22,91.28) v1(70.38,52.62) v1(70.34,11.29) v1(70.67,84.31) v1(71.19,89.79) v1(71.31,91.28) v1(71.43,84.31) v1(71.87,172.9) v1(72.03,41.44) v1(72.19,84.31) v1(72.28,43.09) v1(72.66,60.11) v1(72.85,177.78) v1(72.81,90.43) v1(72.88,11.29) v1(72.95,84.31) v1(72.94,43.05) v1(73.71,84.3) v1(73.98,39.82) v1(74.31,61) v1(74.31,60.19) v1(74.47,84.3) v1(74.82,168.95) v1(75.08,167.43) v1(75.08,61) v1(75.23,84.3) v1(75.39,177.78) v1(75.42,11.29) v1(75.84,61) v1(76,84.3) v1(76.22,26.59) v1(76.6,61) v1(76.73,125.39) v1(76.83,168.32) v1(76.89,60.26) v1(77.29,177.76) v1(77.23,176.04) v1(77.23,170.96) v1(77.25,58.67) v1(77.25,57.99) v1(77.23,57.32) v1(77.36,61) v1(77.49,59.73) v1(77.64,18.2) v1(77.74,60.34) v1(77.74,56.81) v1(77.84,26.43) v1(77.96,11.29) v1(78.11,61.07) v1(78.17,17.8) v1(78.58,84.3) v1(78.5,60.37) v1(78.5,26.44) v1(78.89,92.24) v1(78.88,61.07) v1(79.19,17.8) v1(79.34,84.3) v1(79.47,26.33) v1(79.9,52.11) v1(80.1,84.3) v1(80.39,90.96) v1(80.5,11.29) v1(80.86,84.3) v1(80.9,91.54) v1(81.81,25.82) v1(82.44,60.11) v1(83.04,11.29) v1(83.6,90.77) v1(83.84,59.48) v1(83.97,61) v1(83.97,60.19) v1(84.24,91.18) v1(84.77,91.69) v1(84.73,61) v1(85.07,36.55) v1(85.18,154.44) v1(85.49,61) v1(85.58,11.29) v1(86.25,61) v1(86.59,60.28) v1(86.89,58.69) v1(86.86,57.93) v1(86.89,57.22) v1(87.01,61) v1(87.39,60.29) v1(87.78,61) v1(88.16,60.32) v1(88.12,11.29) v1(88.54,61) v1(88.97,162.04) v1(89.57,94.46) v1(89.55,68.49) v1(89.63,161.97) v1(89.91,157.98) v1(90.23,94.44) v1(90.66,11.29) v1(91.12,161.94) v1(91.1,24.54) v1(91.75,25.22) v1(92.17,162.02) v1(92.56,156.42) v1(93.62,162.04) v1(93.77,68.27) v1(94.02,159.38) v1(94.35,162.04) v1(94.51,68.55) v1(94.51,67.89) v1(94.66,69.23) v1(94.78,25.62) v1(95.83,161.99) v1(96.48,176) v1(96.57,170.28) v1(96.56,158.02) v1(96.99,167.77) v1(97.32,177.78) v1(97.81,166.54) v1(97.82,80.45) v1(98.56,80.47) v1(98.6,148.81) v1(98.67,44.29) v1(98.75,44.97) v1(98.77,18.94) v1(99.36,51.1) v1(99.86,177.78) v1(100.09,78.55) v1(100.15,76.9) v1(100.24,147.81) v1(100.96,147.49) v1(101.49,84.27) v1(101.42,83.1) v1(101.42,81.93) v1(101.54,69.76) v1(101.54,46.22) v1(101.75,76.62) v1(101.77,71.77) v1(101.97,84.74) v1(102.18,45.94) v1(102.4,177.78) v1(102.59,8.02) v1(102.74,80.68) v1(102.81,75.33) v1(103.02,94.35) v1(103.17,77.28) v1(103.22,63.57) v1(103.52,84.47) v1(103.54,74.24) v1(103.57,53.11) v1(103.78,81.93) v1(103.98,141.72) v1(103.9,52.5) v1(104.16,142.41) v1(104.11,98.67) v1(104.27,141.12) v1(104.31,140.45) v1(104.34,99.48) v1(104.34,94.35) v1(104.41,108.88) v1(104.46,75.78) v1(104.79,128.44) v1(104.79,124.12) v1(104.79,123.36) v1(104.79,122.6) v1(104.79,121.83) v1(104.79,121.05) v1(104.84,114.62) v1(104.84,113.97) v1(104.87,113.31) v1(104.85,112.66) v1(104.84,112.01) v1(105.05,141.39) v1(105.13,8.02) v1(105.29,47.88) v1(105.68,75.02) v1(105.63,47.34) v1(106.34,60.58) v1(106.71,94.71) v1(106.95,133.9) v1(106.99,75.95) v1(107.48,177.78) v1(107.48,87.87) v1(107.54,134.2) v1(107.53,133.39) v1(107.67,8.02) v1(107.89,39.3) v1(108.52,40.77) v1(108.68,60.25) v1(108.74,93.23) v1(108.74,92.56) v1(108.98,102.53) v1(108.94,56.73) v1(108.94,54.7) v1(108.94,53.71) v1(109.68,124.49) v1(109.68,112.65) v1(109.68,111.93) v1(109.75,121.75) v1(109.86,103.56) v1(109.99,119.7) v1(109.92,114.16) v1(110.02,177.78) v1(110.05,118.73) v1(110,39.53) v1(110.21,8.02) v1(110.49,55.48) v1(110.51,167.94) v1(110.74,126.13) v1(110.89,150.66) v1(110.8,116.2) v1(110.97,108.85) v1(111.03,110.68) v1(111.11,107.82) v1(111.14,106.75) v1(111.55,60.46) v1(111.54,59.81) v1(111.63,124.5) v1(111.63,111.71) v1(111.7,110.72) v1(111.83,118.86) v1(111.97,121.51) v1(111.92,114.16) v1(112.07,122.48) v1(112.04,56.92) v1(112.28,41.61) v1(112.56,177.78) v1(112.51,116.81) v1(112.64,126.41) v1(112.75,8.02) v1(112.9,127.65) v1(113.05,168.44) v1(113.28,119.5) v1(113.37,114.29) v1(113.59,57.03) v1(115.25,54.51) v1(115.25,52.15) v1(115.29,8.02) v1(116.45,152.04) v1(116.45,151.27) v1(116.45,150.51) v1(116.45,149.75) v1(116.83,108.07) v1(116.81,106.57) v1(116.97,126.73) v1(116.91,56.89) v1(117.06,31.61) v1(117.14,42.12) v1(117.21,152.92) v1(117.21,152.04) v1(117.21,151.27) v1(117.21,150.51) v1(117.21,149.75) v1(117.64,177.78) v1(117.78,66.43) v1(117.77,65.77) v1(117.78,65.13) v1(117.73,31.61) v1(117.84,108.02) v1(117.83,8.02) v1(118.13,149.14) v1(118.51,144.19) v1(118.64,12.36) v1(118.74,31.61) v1(119.14,128.14) v1(119.12,106.57) v1(119.22,57.03) v1(119.57,41.38) v1(120.18,177.78) v1(120.37,8.02) v1(120.49,54.03) v1(120.89,106.2) v1(120.9,66.45) v1(120.9,65.79) v1(120.9,65.1) v1(121.15,41.25) v1(121.13,31.61) v1(121.22,126.12) v1(121.21,124.56) v1(121.41,27.53) v1(122.51,111.17) v1(122.72,177.78) v1(122.91,8.02) v1(123.16,121.41) v1(123.16,120.62) v1(123.16,119.05) v1(123.16,118.25) v1(123.14,105.86) v1(123.11,31.61) v1(123.64,103.01) v1(123.67,100.89) v1(123.81,122.21) v1(123.81,119.83) v1(123.93,107.16) v1(123.93,106.49) v1(124.54,101.74) v1(124.78,31.61) v1(125.26,177.78) v1(125.28,102.47) v1(125.45,8.02) v1(126.06,46.98) v1(126.23,103.34) v1(126.38,31.61) v1(126.48,99.78) v1(127.29,111.74) v1(127.26,111.09) v1(127.27,110.41) v1(127.87,101.17) v1(127.91,31.92) v1(127.99,8.02) v1(128.16,165.78) v1(128.11,128.95) v1(128.19,112.37) v1(128.11,105.86) v1(128.2,110.42) v1(128.42,161.2) v1(129.28,102.51) v1(129.32,40.18) v1(129.69,168.06) v1(129.69,138.98) v1(130.04,111.11) v1(130.02,110.46) v1(130.28,177.24) v1(130.53,8.02) v1(130.96,124.13) v1(130.96,123.41) v1(130.97,122.64) v1(130.98,121.8) v1(130.98,120.98) v1(130.98,120.16) v1(130.93,119.32) v1(130.98,118.53) v1(130.98,117.71) v1(130.98,116.89) v1(130.98,116.07) v1(131.24,100.74) v1(131.34,160.9) v1(131.34,160.14) v1(131.59,158.79) v1(132.03,127.29) v1(132.1,160.9) v1(132.1,160.14) v1(132.34,41) v1(132.62,102.12) v1(132.76,111.07) v1(132.79,110.43) v1(132.86,160.9) v1(132.86,160.14) v1(132.83,109.75) v1(132.87,40.21) v1(133.07,8.02) v1(133.16,105.86) v1(133.17,103.9) v1(133.29,66.57) v1(133.26,65.93) v1(133.26,65.27) v1(133.58,99.13) v1(133.62,160.9) v1(133.62,160.14) v1(133.73,41.34) v1(133.88,30.01) v1(134.27,100.82) v1(134.38,31.61) v1(134.51,160.14) v1(134.6,111.74) v1(134.92,41) v1(135.15,46.79) v1(135.23,104.34) v1(135.25,102.38) v1(135.61,8.02) v1(136.18,40.74) v1(136.52,38.89) v1(136.97,99.71) v1(137.11,124.83) v1(137.45,64.46) v1(137.46,31.61) v1(137.59,123.48) v1(137.59,122.7) v1(137.53,121.65) v1(137.52,120.87) v1(137.54,119.94) v1(137.5,118.93) v1(137.52,118.13) v1(137.51,62.25) v1(137.75,104.38) v1(137.74,103.08) v1(137.77,99.76) v1(137.81,124.84) v1(137.82,116.93) v1(137.82,115.94) v1(137.82,115.12) v1(138.07,124.12) v1(138.06,38.71) v1(138.15,8.02) v1(138.25,121.68) v1(138.23,120.91) v1(138.23,119.94) v1(138.23,118.96) v1(138.22,118.13) v1(138.27,109.73) v1(138.34,46.78) v1(138.52,124.86) v1(138.52,123.47) v1(138.51,122.69) v1(138.7,161.2) v1(138.96,113.07) v1(139.16,112.37) v1(139.33,38.87) v1(139.46,166.41) v1(140.25,104.39) v1(140.24,103.04) v1(140.27,101.1) v1(140.64,106.51) v1(140.64,105.86) v1(140.6,40.21) v1(140.69,8.02) v1(140.99,113.02) v1(141.03,109.76) v1(141.62,159.17) v1(141.85,161.03) v1(141.85,160.27) v1(141.88,65.47) v1(141.88,64.79) v1(141.88,64.13) v1(142.13,31.61) v1(142.59,175.88) v1(142.61,161.03) v1(142.61,160.27) v1(142.65,99.21) v1(142.77,174.41) v1(142.7,104.31) v1(143.06,97.34) v1(143.17,107.16) v1(143.23,8.02) v1(143.38,161.03) v1(143.38,160.27) v1(143.66,31.61) v1(143.79,111.08) v1(143.77,110.44) v1(144.14,161.03) v1(144.14,160.27) v1(144.17,40.94) v1(144.23,124.52) v1(144.77,38.74) v1(145.03,160.27) v1(145.05,123.74) v1(145.05,122.6) v1(145.05,121.2) v1(145.05,119.68) v1(145.05,118.28) v1(145.05,117.01) v1(145.05,116.25) v1(145.05,115.1) v1(145.05,114.34) v1(145.13,175.88) v1(145.18,140.5) v1(145.18,30.65) v1(145.2,124.72) v1(145.38,101.24) v1(145.42,131.84) v1(145.42,131.19) v1(145.42,130.54) v1(145.42,129.89) v1(145.42,129.24) v1(145.42,128.59) v1(145.42,127.94) v1(145.42,127.29) v1(145.43,46.8) v1(145.67,99.45) v1(145.61,40.34) v1(145.73,104.5) v1(145.77,8.02) v1(145.88,124.72) v1(146.16,65.49) v1(146.15,64.82) v1(146.14,64.18) v1(146.45,125.9) v1(146.49,110.46) v1(146.49,109.8) v1(146.52,31.61) v1(147.35,124.96) v1(147.67,175.88) v1(148.18,100.36) v1(148.25,105.86) v1(148.28,104.46) v1(148.3,112.38) v1(148.31,8.02) v1(148.5,48.03) v1(148.5,31.61) v1(149.22,112.37) v1(149.25,111.72) v1(149.39,124.93) v1(149.57,26.18) v1(149.74,31.26) v1(150.14,112.37) v1(150.18,64.7) v1(150.21,175.88) v1(150.21,65.35) v1(150.21,64.06) v1(150.39,141.39) v1(150.41,31.26) v1(150.76,107.81) v1(150.76,105.86) v1(150.78,103.88) v1(150.84,101.94) v1(150.85,8.02) v1(151.07,31.26) v1(151.28,26.2) v1(151.28,24.19) v1(151.22,22.56) v1(151.33,97.7) v1(151.49,124.93) v1(151.6,100.5) v1(151.78,160.82) v1(151.78,160.06) v1(151.78,122.34) v1(151.78,121.58) v1(151.78,120.82) v1(151.78,118.79) v1(151.78,117.64) v1(151.78,116.88) v1(151.78,116.12) v1(151.91,123.49) v1(151.96,113.67) v1(151.99,111.75) v1(151.97,110.43) v1(151.97,109.77) v1(152.36,102.47) v1(152.44,107.81) v1(152.55,160.82) v1(152.55,160.06) v1(152.55,118.79) v1(152.67,123.49) v1(153.28,105.86) v1(153.28,103.9) v1(153.31,160.82) v1(153.31,160.06) v1(153.31,118.79) v1(153.3,31.49) v1(153.39,8.02) v1(153.43,123.49) v1(153.7,101.07) v1(153.81,113.67) v1(153.99,42.31) v1(153.97,31.49) v1(154.07,160.82) v1(154.07,160.06) v1(154.07,118.79) v1(154.08,64.71) v1(154.1,65.37) v1(154.1,64.06) v1(154.2,123.49) v1(154.47,102.14) v1(154.63,31.49) v1(154.71,162.47) v1(154.71,111.06) v1(154.71,110.4) v1(154.72,109.74) v1(154.96,160.06) v1(155.08,115.66) v1(155.29,175.88) v1(155.24,104.14) v1(155.38,100.47) v1(155.62,111.72) v1(155.77,107.81) v1(155.72,24.45) v1(155.98,47.52) v1(155.93,8.02) v1(156.1,31.49) v1(156.48,24.45) v1(156.48,23.69) v1(156.59,102.71) v1(156.51,48.08) v1(157.29,123.54) v1(157.29,119.6) v1(157.29,116.45) v1(157.48,106.96) v1(157.63,31.49) v1(157.72,105.34) v1(157.83,175.88) v1(157.88,11.73) v1(157.94,121.97) v1(157.94,119.6) v1(157.94,112.52) v1(157.94,111.73) v1(157.91,101.23) v1(158.01,99.57) v1(158.19,108.44) v1(158.47,8.02) v1(158.59,129.05) v1(158.59,128.27) v1(158.59,125.9) v1(158.59,118.03) v1(158.59,116.46) v1(159.15,31.49) v1(159.24,128.27) v1(159.24,125.9) v1(159.24,121.97) v1(159.24,121.18) v1(159.24,116.46) v1(159.24,109.37) v1(159.28,40.35) v1(159.79,103.09) v1(159.89,121.97) v1(160,22.94) v1(160.29,138.98) v1(160.37,175.88) v1(160.38,101.86) v1(160.56,109.16) v1(160.67,130.52) v1(160.65,42.17) v1(160.67,31.49) v1(160.72,121.73) v1(160.97,129.93) v1(160.93,65.47) v1(160.93,64.76) v1(160.93,64.06) v1(161.01,8.02) v1(161.89,109.55) v1(161.86,47.87) v1(162.07,107.33) v1(162.17,110.9) v1(162.19,31.49) v1(162.38,48.26) v1(162.32,22.65) v1(162.58,160.85) v1(162.58,160.09) v1(162.52,41.99) v1(162.91,175.88) v1(163.21,22.65) v1(163.34,160.85) v1(163.34,160.09) v1(163.55,8.02) v1(163.7,31.49) v1(163.98,105.5) v1(164.1,160.85) v1(164.1,160.09) v1(164.16,110.92) v1(164.1,22.65) v1(164.46,31.49) v1(164.51,53.17) v1(164.86,160.85) v1(164.86,160.09) v1(164.97,117.49) v1(164.91,116.81) v1(165.45,175.88) v1(165.51,162.49) v1(165.75,160.09) v1(166.09,8.02) v1(167.78,52.85) v1(167.99,175.88) v1(167.91,48.34) v1(168.63,8.02) v1(169.39,30.43) v1(169.53,87.8) v1(169.62,87.09) v1(169.61,47.73) v1(169.97,48.31) v1(170.36,39.46) v1(170.53,175.88) v1(171.17,8.02) v1(171.24,113.39) v1(171.38,112.75) v1(171.3,108.89) v1(171.3,108.25) v1(171.3,107.6) v1(171.44,122.24) v1(171.65,120.59) v1(171.65,118.96) v1(171.65,117.6) v1(171.62,115.97) v1(171.92,127.37) v1(171.98,105.45) v1(172.48,22.27) v1(172.71,51.55) v1(173.07,175.88) v1(173.12,55.93) v1(173.12,42.93) v1(173.25,22.27) v1(173.37,159.17) v1(173.36,63.45) v1(173.71,8.02) v1(174.01,159.4) v1(174.26,22.27) v1(174.36,63.48) v1(174.77,60.13) v1(174.95,134.66) v1(175.22,106.81) v1(175.51,49.75) v1(175.61,175.88) v1(175.79,10.2) v1(175.81,167.53) v1(175.81,166.51) v1(175.81,165.5) v1(176.2,108.58) v1(176.24,23.84) v1(176.25,8.02) v1(176.83,167.53) v1(176.83,166.51) v1(176.83,165.5) v1(176.85,108.48) v1(177.11,78.96) v1(177.26,44.14) v1(177.67,101.54) v1(177.69,99.31) v1(177.69,97.05) v1(177.74,116.53) v1(177.84,167.53) v1(177.84,166.51) v1(177.84,165.5) v1(178.15,175.88) v1(178.12,78.96) v1(178.35,57.76) v1(178.35,54.88) v1(178.88,134.79) v1(178.89,54.4) v1(178.99,57.62) v1(179.46,125.74) v1(179.53,134.76) v1(179.7,54.4) v1(180.18,54.88) v1(180.19,25.65) v1(180.18,23.11) v1(180.35,98.51) v1(180.33,20.77) v1(180.69,175.88) v1(180.98,128.08) v1(180.95,125.83) v1(181.4,24.78) v1(181.55,22.44) v1(182.49,47.49) v1(182.44,44.53) v1(182.53,48.54) v1(182.54,22.52) v1(182.75,43.09) v1(183.14,38.66) v1(183.2,175.48) v1(183.38,172.94) v1(183.38,170.4) v1(183.38,167.86) v1(183.38,165.32) v1(183.38,162.78) v1(183.38,160.24) v1(183.38,157.7) v1(183.38,155.16) v1(183.38,152.62) v1(183.38,150.08) v1(183.38,137.38) v1(183.38,134.84) v1(183.38,132.3) v1(183.38,129.76) v1(183.38,127.22) v1(183.38,124.68) v1(183.38,122.14) v1(183.38,119.6) v1(183.38,117.06) v1(183.38,114.52) v1(183.38,111.98) v1(183.38,109.44) v1(183.38,106.9) v1(183.38,104.36) v1(183.39,101.82) v1(183.38,46.55) v1(183.35,45.45) v1(183.44,24.62) v1(183.51,99.29) v1(183.56,49.22) v1(183.79,96.76) v1(184.22,94.26) v1(184.35,43.37) v1(184.42,44.49) v1(184.42,21.3) v1(184.52,45.91) v1(184.52,22.62) v1(184.81,91.79) v1(185.36,46.9) v1(185.55,89.36) v1(185.54,49.37) v1(185.57,43.73) v1(185.54,42.28) v1(186.38,21.38) v1(186.43,86.98) v1(187.34,34.2) v1(187.47,84.66) v1(187.85,7.94) v1(188.11,13.5) v1(188.39,34.54) v1(188.38,27.45) v1(188.55,29.25) v1(188.51,7.94) v1(188.64,82.4) v1(188.69,30.24) v1(189.12,30.78) v1(189.25,30.78) v1(190.44,55.13) v1(190.71,70.47) v1(190.77,23.03) v1(190.77,9.36) v1(190.9,53.08) v1(190.9,52.39) v1(191.05,68.38) v1(191.66,24.3) v1(191.66,22.75) v1(192.45,7.96) v1(192.56,66.34) v1(193.69,49.43) v1(193.72,50.08) v1(193.77,21.81) v1(194.21,65.56) v1(194.43,21.81) v1(195.14,21.81) v1(197.78,65.53) v1(198.32,53.83) v1(199.11,8.02) v1(199.22,66.27) v1(200.68,42.1) v1(200.81,39.92) v1(201.26,43.27) v1(201.42,40.94) v1(201.65,8.02) v1(202.05,67.51) v1(202.81,24.71) v1(203.83,49.42) v1(204.19,22.64) v1(204.19,8.02) v1(204.6,66.84) v1(204.68,46.34) v1(204.8,22.64) v1(204.93,22) v1(205,47.49) v1(205.33,46.35) v1(205.36,35.57) v1(205.56,49.37) v1(205.51,45.25) v1(206.06,51.05) v1(206.7,65.5) v1(206.7,36.34) v1(206.73,8.02) v1(207.69,48.12) v1(207.74,49.9) v1(207.74,44.16) v1(208.04,43.57) v1(208.03,42.89) v1(208.49,33.1) v1(208.63,26.84) v1(208.71,39.36) v1(209.02,64.47) v1(209.04,49.27) v1(209.01,46.17) v1(209.04,34.46) v1(209.27,8.02) v1(209.37,39.36) v1(209.3,33.16) v1(209.62,47.24) v1(209.83,44.16) v1(209.85,24.86) v1(210.11,31.72) v1(210.64,43.47) v1(210.6,25.91) v1(210.86,47.36) v1(210.89,45.41) v1(210.86,42.76) v1(211.41,63.6) v1(211.4,40.89) v1(211.7,29.66) v1(211.86,35.57) v1(211.88,34.89) v1(211.81,8.02) v1(211.91,43.32) v1(212.16,42.61) v1(212.69,37.2) v1(212.67,31.82) v1(213.68,47.11) v1(213.8,63.12) v1(214.19,43.48) v1(214.34,49.93) v1(214.35,8.02) v1(215.28,48.4) v1(215.28,43.81) v1(215.36,41.92) v1(215.46,43.15) v1(215.54,39.89) v1(215.79,36.46) v1(215.79,31.79) v1(215.92,46.3) v1(216.27,48.56) v1(216.35,51.45) v1(216.42,62.49) v1(216.56,39.62) v1(216.57,36.47) v1(216.56,31.79) v1(216.71,49.67) v1(216.89,8.02) v1(216.93,46.8) v1(217.06,42.03) v1(217.35,36.45) v1(217.32,31.66) v1(217.62,51.32) v1(217.96,46.87) v1(218.05,49.9) v1(218.03,47.57) v1(218.08,39.28) v1(218.03,29.63) v1(218.14,36.46) v1(218.11,31.79) v1(218.53,43.68) v1(218.82,61.87) v1(218.89,31.82) v1(219.09,39.79) v1(219.12,36.05) v1(219.35,38.24) v1(219.43,8.02) v1(220.21,39.39) v1(220.77,51.71) v1(220.87,39.39) v1(221.28,61.81) v1(221.58,39.41) v1(221.84,51.78) v1(221.97,8.02) v1(222.09,40.94) v1(222.09,35.95) v1(222.09,31.89) v1(222.47,10.68) v1(223.13,10.68) v1(223.74,37.66) v1(223.94,61.71) v1(224.3,50.49) v1(224.51,8.02) v1(224.61,52.44) v1(225.06,50.49) v1(226.38,50.59) v1(226.42,61.48) v1(226.84,46.4) v1(227.05,8.02) v1(227.35,22.36) v1(227.53,46.59) v1(227.5,45.94) v1(228.31,48.38) v1(228.42,43.45) v1(228.52,42) v1(228.96,61.48) v1(229.2,49.83) v1(229.59,8.02) v1(229.63,17.57) v1(229.75,18.89) v1(229.77,18.23) v1(230.37,43.32) v1(230.47,42) v1(230.93,49.88) v1(231.5,61.48) v1(231.9,42.54) v1(232.02,48.53) v1(232.13,8.02) v1(232.5,43.68) v1(232.94,25.19) v1(233.11,48.53) v1(233.14,42.04) v1(233.93,47.73) v1(234.04,61.48) v1(234.67,8.02) v1(235.58,9.29) v1(236.26,9.29) v1(236.58,61.48) v1(237.21,8.02) v1(237.84,9.29) v1(238.52,57.45) v1(238.52,9.29) v1(238.91,14.77) v1(239.12,61.48) v1(239.19,9.29) v1(239.72,26.23) v1(239.75,8.02) v1(239.85,9.29) v1(240.18,15.92) v1(240.38,26.23) v1(241.1,26.24) v1(241.45,15.92) v1(241.76,26.21) v1(241.95,45.38) v1(242.12,19.91) v1(242.29,8.02) v1(242.97,53.76) v1(243.55,53.28) v1(243.96,16.34) v1(244.21,53.28) v1(244.62,16.44) v1(244.87,53.28) v1(244.83,8.02) v1(245.28,10.74) v1(245.38,9.31) v1(245.92,41.91) v1(245.93,30.83) v1(247.36,13.68) v1(247.37,8.02) v1(248.66,27.6) v1(249.24,27.07) v1(249.7,22.65) v1(249.7,21.63) v1(249.7,20.73) v1(249.91,8.02) v1(250.06,27.75) v1(250.69,22.6) v1(250.72,21.63) v1(250.72,20.68) v1(250.84,61.38) v1(251.15,27.07) v1(251.48,34.71) v1(251.73,22.65) v1(251.76,20.68) v1(252.24,26.99) v1(252.45,8.02) v1(253.07,61.47) v1(254.99,8.02) v1(255.29,61.51) v1(255.54,34.97) v1(255.8,32.93) v1(255.9,47.49) v1(256.3,39.79) v1(256.81,61.42) v1(257.53,8.02) v1(259.08,61.49) v1(260.07,8.02) v1(260.24,46.4) v1(260.24,34.97) v1(260.24,33.57) v1(260.24,32.17) v1(260.75,32.81) v1(261.07,61.49) v1(261.28,42.49) v1(261.26,41.49) v1(261.64,33.57) v1(261.64,32.17) v1(261.77,34.97) v1(261.71,17.54) v1(262.15,40.94) v1(262.1,29.12) v1(262.27,17.06) v1(262.63,11.65) v1(262.61,8.02) v1(262.78,42.51) v1(262.78,41.44) v1(262.93,61.49) v1(263.16,34.97) v1(263.16,33.57) v1(263.16,32.17) v1(263.54,17.29) v1(263.77,18.81) v1(263.8,20.46) v1(263.92,40.78) v1(264.31,41.39) v1(264.41,42.49) v1(264.6,40.8) v1(264.66,26.46) v1(264.69,17.21) v1(264.76,11.6) v1(265.14,20.51) v1(265.15,8.02) v1(265.27,61.47) v1(265.73,42.51) v1(266.97,13.76) v1(267.3,9.92) v1(267.61,61.53) v1(267.69,8.02) v1(267.79,28.24) v1(268.02,60.45) v1(268.12,41.7) v1(268.7,56.17) v1(268.88,18.23) v1(268.96,17.41) v1(269.35,56.21) v1(269.39,16.76) v1(269.49,52.85) v1(269.46,9.9) v1(269.89,51.86) v1(269.84,32.55) v1(269.92,31.08) v1(270,56.16) v1(270.09,13.63) v1(270.28,60.49) v1(270.27,33.8) v1(270.23,8.02) v1(271.24,30.06) v1(271.65,39.82) v1(272.3,60.49) v1(272.77,8.02) v1(273.93,35.06) v1(273.93,33.51) v1(273.91,31.85) v1(274.47,60.49) v1(275.1,54.52) v1(275.1,40.02) v1(275.31,8.02) v1(275.48,35.06) v1(275.48,33.44) v1(275.46,31.83) v1(275.8,40.04) v1(276.24,12.2) v1(276.5,40.05) v1(276.73,54.68) v1(276.88,12.91) v1(277.02,60.48) v1(277.06,35.05) v1(277.07,33.45) v1(277.07,31.86) v1(277.28,12.21) v1(277.41,54.68) v1(277.51,34.2) v1(278.07,54.65) v1(278.2,8.02) v1(278.78,54.65) v1(279.48,18.23) v1(279.56,60.48) v1(279.55,54.65) v1(280.36,18.23) v1(280.5,6.95) v1(281.22,4.51) v1(281.22,1.97) v1(281.73,33.21) v1(281.7,30.9) v1(281.78,29.86) v1(282.1,60.48) v1(282.44,47.24) v1(282.42,43.35) v1(282.52,17.59) v1(282.64,31.92) v1(282.85,55.29) v1(282.95,39.18) v1(282.9,35.75) v1(282.9,34.59) v1(282.9,9.06) v1(283.11,18.6) v1(283.28,11.24) v1(283.36,37) v1(283.57,1.02) v1(283.61,45.51) v1(283.94,36.64) v1(284.07,30.93) v1(284.3,45.51) v1(284.37,16.81) v1(284.56,43.39) v1(284.64,60.48) v1(285.13,51.73) v1(285.29,19.83) v1(285.29,19.17) v1(285.29,18.51) v1(285.26,17.82) v1(285.26,17.16) v1(285.26,16.5) v1(285.62,45.41) v1(285.9,51.73) v1(286.11,1.02) v1(286.78,51.98) v1(286.91,50.97) v1(287.18,60.48) v1(287.24,18.46) v1(287.67,50.97) v1(288.65,1.02) v1(288.94,22.52) v1(289.12,39.06) v1(289.61,19.82) v1(289.66,4.08) v1(289.72,60.48) v1(289.91,39.06) v1(290.01,41.67) v1(290.59,39.03) v1(291.19,1.02) v1(291.24,39.15) v1(291.31,45.56) v1(291.31,42.76) v1(291.43,38.52) v1(291.94,19.57) v1(291.93,4.05) v1(293.01,48.68) v1(293.73,1.02) v1(295.16,48.88) v1(295.79,60.66) v1(296.27,1.02) v1(297.18,59.6) v1(297.18,34.69) v1(297.18,20.29) v1(297.18,3.39) v1(297.3,48.33) v1(297.53,36.74) v1(298.54,33.57) v1(298.58,22.41) v1(298.68,31.47) v1(298.77,29.68) v1(298.74,27.57) v1(298.74,25.14) v2(29.09,156.33) v2(34.88,109.95) v2(35.58,110.72) v2(35.68,125.4) v2(35.65,112) v2(35.8,108.77) v2(35.93,126.7) v2(36.13,129.64) v2(36.12,124.55) v2(36.15,109.96) v2(36.65,100.5) v2(37.15,101.69) v2(37.18,99.46) v2(37.29,110.99) v2(37.3,126.44) v2(37.32,109.58) v2(37.99,125.69) v2(38.06,99.79) v2(38.39,101.77) v2(38.47,103.9) v2(38.67,118.61) v2(38.66,112.32) v2(38.74,126.4) v2(38.7,109.65) v2(39.05,129.82) v2(39.36,128.51) v2(39.39,113.78) v2(39.35,108.9) v2(39.39,106.14) v2(39.45,127.1) v2(39.43,125.72) v2(39.48,110.17) v2(39.42,99.83) v2(39.53,120.24) v2(39.52,105.58) v2(39.89,112.16) v2(39.97,120.58) v2(40.07,126.39) v2(40.06,118.61) v2(40.09,116.54) v2(40,109.64) v2(40.1,127.75) v2(40.12,101.9) v2(40.75,125.69) v2(40.8,127.07) v2(40.81,121.45) v2(40.89,116.08) v2(40.89,114.29) v2(40.9,128.99) v2(40.91,111.9) v2(41,105.55) v2(41.17,120.45) v2(41.23,156.27) v2(41.36,124.44) v2(41.34,114.03) v2(41.45,122.27) v2(41.48,118.05) v2(41.49,117.27) v2(41.49,116.64) v2(41.58,123.04) v2(41.52,103.98) v2(42.17,125.71) v2(42.24,117.29) v2(42.2,115.18) v2(42.23,103.95) v2(42.61,123.99) v2(42.69,103.65) v2(42.78,105.54) v2(42.82,115.93) v2(42.93,122.51) v2(43.09,126.3) v2(43.45,125.78) v2(44.6,120.29) v2(44.85,117.06) v2(44.93,103.14) v2(44.93,101.8) v2(45.03,108.91) v2(45.13,124.36) v2(45.13,94.85) v2(45.27,125.83) v2(45.43,124.8) v2(45.69,114.47) v2(45.71,113.82) v2(46.38,109.57) v2(46.4,106.8) v2(47.08,109.58) v2(47.08,104.67) v2(47.13,123.58) v2(47.13,120.1) v2(47.1,106.8) v2(47.24,95.67) v2(47.21,94.83) v2(47.65,126.27) v2(47.63,124.39) v2(47.74,125.72) v2(47.78,120.12) v2(47.79,115.88) v2(47.79,103.27) v2(47.8,116.63) v2(47.8,114.47) v2(47.82,105.39) v2(48.51,126.44) v2(48.53,125) v2(48.51,120.12) v2(48.5,116.61) v2(48.51,105.42) v2(48.5,101.9) v2(49.28,126.36) v2(49.2,120.12) v2(49.21,116.64) v2(49.22,115.91) v2(49.22,115.23) v2(49.2,114.47) v2(49.2,113.83) v2(49.21,104.74) v2(49.2,103.35) v2(49.89,120.8) v2(49.9,115.9) v2(49.9,101.9) v2(50.6,117.3) v2(51.27,126.41) v2(51.29,105.36) v2(51.34,120.97) v2(51.31,117.35) v2(51.3,116.64) v2(51.33,115.88) v2(51.33,113.8) v2(51.3,103.27) v2(51.44,124.92) v2(51.99,117.26) v2(51.97,115.88) v2(51.96,113.79) v2(51.99,106.8) v2(52,112.4) v2(52.69,117.28) v2(52.69,115.9) v2(52.7,122.92) v2(52.7,105.35) v2(52.73,104.71) v2(53.39,106.77) v2(53.35,98.4) v2(53.37,97.69) v2(53.41,124.27) v2(53.4,120.05) v2(53.4,112.38) v2(53.41,104.69) v2(53.42,99.05) v2(53.51,155.89) v2(53.54,94.81) v2(53.62,125.91) v2(53.89,124.85) v2(53.89,97.1) v2(54.09,112.38) v2(54.09,105.36) v2(54.06,99.03) v2(54.13,120.08) v2(54.1,103.25) v2(54.1,101.9) v2(54.59,130.76) v2(54.77,107.5) v2(54.8,108.2) v2(54.81,104.74) v2(54.8,101.9) v2(55.48,129.79) v2(55.49,104.72) v2(55.48,103.29) v2(55.53,115.9) v2(55.5,114.45) v2(55.5,106.84) v2(55.5,101.9) v2(55.51,97.71) v2(55.67,124.81) v2(55.7,126.26) v2(56.05,124.38) v2(56.17,128.49) v2(56.2,120.75) v2(56.21,115.9) v2(56.21,99.14) v2(56.89,104.74) v2(56.91,106.84) v2(57.01,130.56) v2(57.2,150.78) v2(57.54,127.1) v2(57.55,112.4) v2(57.65,130.09) v2(57.61,101.94) v2(57.61,97.71) v2(57.7,124.35) v2(57.95,150.03) v2(58.16,124.87) v2(58.18,123.52) v2(58.29,128.55) v2(58.28,127.78) v2(58.28,126.36) v2(58.26,121.4) v2(58.3,120.1) v2(58.34,106.11) v2(58.34,105.4) v2(58.34,104.72) v2(58.31,101.93) v2(59.04,127.1) v2(59,120.1) v2(59,117.31) v2(59,115.86) v2(59,102.55) v2(59.1,129.96) v2(59.68,126.44) v2(59.69,115.86) v2(59.71,97.74) v2(60,127.69) v2(60.19,125.81) v2(60.68,121.01) v2(61.1,125.03) v2(61.1,123.64) v2(61.86,125.71) v2(61.89,124.37) v2(61.85,120.99) v2(61.8,104.75) v2(62.38,124.96) v2(62.49,123.56) v2(62.9,120.93) v2(63.23,124.28) v2(63.21,104.73) v2(63.25,102.61) v2(63.25,100.95) v2(63.89,106.76) v2(63.92,126.42) v2(63.95,106.1) v2(63.9,94.94) v2(64.02,124.92) v2(64.33,126) v2(64.37,123.49) v2(64.47,120.97) v2(64.52,127.14) v2(64.99,103.41) v2(65.09,116.18) v2(65.46,123.08) v2(66.03,126.42) v2(66.04,94.82) v2(66.31,123) v2(66.45,124.59) v2(66.77,123.35) v2(66.73,105.46) v2(67.01,118.37) v2(67.07,116.23) v2(67.18,101.51) v2(67.28,123.54) v2(67.28,114.09) v2(67.37,125.68) v2(67.34,124.23) v2(67.3,121.63) v2(67.35,111.77) v2(67.39,108.9) v2(67.41,110.33) v2(67.4,107.55) v2(68.16,109.73) v2(68.11,95.67) v2(68.27,118.21) v2(68.2,103.52) v2(68.52,111.99) v2(68.67,114.43) v2(68.69,106.02) v2(68.74,118.64) v2(68.73,116.07) v2(68.75,110.28) v2(68.71,107.7) v2(68.79,103.31) v2(68.83,108.88) v2(69.48,103.99) v2(69.56,118.04) v2(69.55,112.28) v2(69.5,110.95) v2(70.09,108.01) v2(70.09,106.02) v2(70.17,125.71) v2(70.11,124.46) v2(70.14,118.6) v2(70.19,112.41) v2(70.13,101.78) v2(70.24,122.89) v2(70.25,120.09) v2(70.21,117.28) v2(70.2,108.96) v2(70.2,103.34) v2(70.25,94.2) v2(70.93,123.61) v2(70.9,119.38) v2(70.95,118.06) v2(70.9,105.34) v2(71.03,124.92) v2(71.07,103.43) v2(71.54,122.84) v2(71.57,118.62) v2(71.6,101.95) v2(71.6,100.45) v2(72.35,123.6) v2(72.32,118.06) v2(72.31,99.12) v2(72.46,120.46) v2(72.99,117.25) v2(72.94,101.65) v2(73.05,125.12) v2(73.06,98.34) v2(73.19,121.38) v2(73.16,104.25) v2(73.2,128.94) v2(73.47,99.88) v2(73.58,123.91) v2(73.69,119.45) v2(73.63,117.95) v2(73.71,122.18) v2(73.91,102.95) v2(74.06,125.08) v2(74,99.41) v2(74.2,101.7) v2(74.34,104.14) v2(74.69,100.39) v2(97.43,128.92) v2(97.67,129.78) v2(259.46,54.02) v2(259.51,47.51) v2(260.09,54.68) v2(260.72,54.68) v2(260.77,52.05) v2(293.07,44.96) v2(293.07,39.36) v3(9.77,153.76) v3(9.77,153) v3(10.56,153.76) v3(10.53,153) v3(12.01,150.84) v3(13,150.87) v3(18.7,157.88) v3(18.7,157.12) v3(18.7,156.36) v3(24.28,60.87) v3(24.71,61.56) v3(25.04,60.87) v3(26.51,68.67) v3(27.3,68.67) v3(28.06,68.67) v3(28.82,68.67) v3(29.58,68.67) v3(31.08,68.67) v3(31.87,68.67) v3(32.63,68.67) v3(33.39,68.67) v3(33.93,60.87) v3(34.16,68.67) v3(34.69,60.87) v3(36.16,68.67) v3(36.95,68.67) v3(37.58,169.72) v3(37.58,168.96) v3(37.71,68.67) v3(38.34,169.72) v3(38.34,168.96) v3(38.47,68.67) v3(39.1,169.72) v3(39.1,168.96) v3(39.24,68.67) v3(39.86,169.72) v3(39.86,168.96) v3(39.98,174.06) v3(39.98,173.17) v3(40.61,173.59) v3(41.24,68.67) v3(42.03,68.67) v3(42.79,68.67) v3(43.55,68.67) v3(43.58,60.87) v3(44.32,68.67) v3(44.34,60.87) v3(45.81,68.67) v3(46.6,68.67) v3(47.36,68.67) v3(48.13,68.67) v3(48.89,68.67) v3(50.89,68.67) v3(51.68,68.67) v3(52.44,68.67) v3(53.21,68.67) v3(53.23,60.87) v3(53.97,68.67) v3(53.99,60.87) v3(55.59,68.67) v3(56.38,68.67) v3(57.14,68.67) v3(57.91,68.67) v3(58.67,68.67) v3(59.33,47.82) v3(59.33,47.03) v3(59.99,47.44) v3(59.96,46.63) v3(60.17,68.67) v3(60.95,68.67) v3(61.72,68.67) v3(61.74,52.59) v3(62.48,68.67) v3(62.5,52.59) v3(62.88,60.87) v3(63.24,68.67) v3(63.65,60.87) v3(65.12,68.67) v3(65.91,68.67) v3(66.67,68.67) v3(66.95,52.82) v3(66.95,52.06) v3(67.43,68.67) v3(68.19,68.67) v3(69.36,53) v3(69.36,52.11) v3(70.12,68.75) v3(71.01,68.75) v3(71.77,68.75) v3(72.54,68.75) v3(72.54,60.87) v3(73.3,60.87) v3(73.42,68.75) v3(74.77,68.8) v3(75.56,68.8) v3(76.32,68.8) v3(77.08,68.8) v3(77.84,68.8) v3(79.47,51.41) v3(79.41,50.6) v3(79.6,68.67) v3(80.38,68.67) v3(80.41,49.01) v3(80.54,51.73) v3(81.02,51.12) v3(81.15,68.67) v3(81.17,48.97) v3(81.4,50.44) v3(81.55,51.73) v3(81.91,68.67) v3(81.91,48.68) v3(82.19,60.87) v3(82.57,51.73) v3(82.67,68.67) v3(82.65,48.94) v3(82.62,48.19) v3(82.95,60.87) v3(83.23,51.26) v3(83.22,50.45) v3(83.36,48.69) v3(83.92,51.72) v3(84.04,68.67) v3(84.08,48.96) v3(84.83,68.67) v3(85.59,68.67) v3(86.35,68.67) v3(87.12,68.67) v3(96.95,62.3) v3(99.74,157.55) v3(99.74,156.79) v3(99.74,149.92) v3(99.72,149.15) v3(99.82,158.31) v3(106.24,29.62) v3(106.56,30.32) v3(106.99,29.63) v3(107.36,30.31) v3(107.81,29.64) v3(108.15,30.31) v3(108.6,29.62) v3(108.95,30.31) v3(113.27,9.56) v3(113.69,10.2) v3(114.06,9.55) v3(114.55,10.2) v3(114.89,9.54) v3(115.32,10.16) v3(115.8,9.55) v3(116.25,10.15) v3(116.73,9.57) v3(117.56,9.57) v3(117.85,144.95) v3(117.94,146.89) v3(117.94,146.13) v3(118.47,145.49) v3(118.43,9.55) v3(118.81,10.31) v3(119.09,144.87) v3(119.28,145.71) v3(119.25,11.02) v3(119.36,9.53) v3(119.68,10.29) v3(119.71,11.74) v3(120.13,11) v3(120.17,9.55) v3(120.59,10.32) v3(120.6,11.74) v3(121.07,11.04) v3(121.09,9.55) v3(121.55,11.76) v3(121.53,10.32) v3(122.01,11.06) v3(122.03,9.55) v3(122.49,10.32) v3(122.51,11.77) v3(122.97,11.04) v3(122.96,9.59) v3(123.39,11.79) v3(123.43,10.3) v3(123.89,11.11) v3(123.85,9.58) v3(124.24,10.29) v3(124.69,9.57) v3(124.81,26.81) v3(125.1,10.29) v3(125.56,26.79) v3(125.59,9.58) v3(125.96,10.28) v3(126.33,26.79) v3(126.42,9.58) v3(126.56,146.8) v3(126.56,146.04) v3(126.56,145.28) v3(126.56,144.52) v3(126.71,166.67) v3(126.71,165.9) v3(126.86,10.29) v3(127.09,26.79) v3(127.47,166.24) v3(127.88,157.06) v3(127.92,166.96) v3(128.52,160.19) v3(128.52,159.43) v3(128.52,158.66) v3(128.64,157.06) v3(128.94,166.79) v3(129.28,160.19) v3(129.28,159.43) v3(129.28,158.66) v3(129.41,157.06) v3(129.78,166.78) v3(130.04,160.19) v3(130.04,159.43) v3(130.04,158.66) v3(130.45,141.65) v3(130.45,140.88) v3(130.45,140.12) v3(130.45,139.36) v3(138.85,27.37) v3(138.92,165.22) v3(138.96,160.21) v3(138.96,159.45) v3(138.96,158.69) v3(138.96,157.47) v3(139.62,27.34) v3(139.72,160.21) v3(139.72,159.45) v3(139.72,158.69) v3(139.72,157.47) v3(140.38,27.34) v3(140.41,166.44) v3(140.48,160.21) v3(140.48,159.45) v3(140.48,158.69) v3(140.48,157.47) v3(141.14,27.34) v3(142.74,173.57) v3(142.74,172.81) v3(143.5,173.57) v3(143.5,172.81) v3(144.27,173.57) v3(144.27,172.81) v3(144.49,141.75) v3(144.49,140.99) v3(144.49,140.22) v3(147.28,21.02) v3(147.27,20.26) v3(147.29,19.43) v3(147.3,18.66) v3(148.05,21.01) v3(148.05,20.21) v3(148.08,19.44) v3(148.08,18.68) v3(148.94,160.16) v3(148.94,159.4) v3(148.94,158.64) v3(149.4,166.51) v3(149.55,156.63) v3(149.7,160.16) v3(149.7,159.4) v3(149.7,158.64) v3(150.16,166.51) v3(150.31,156.63) v3(150.46,160.16) v3(150.46,159.4) v3(150.46,158.64) v3(150.64,17.57) v3(151.07,156.63) v3(151.4,142.99) v3(151.4,142.23) v3(151.4,141.47) v3(151.4,140.71) v3(151.43,18.33) v3(151.4,17.57) v3(152.19,18.33) v3(152.16,17.57) v3(152.93,17.57) v3(153,18.36) v3(153.71,17.87) v3(157.66,10.17) v3(157.66,9.41) v3(158.43,10.17) v3(158.43,9.41) v3(158.78,15.06) v3(159.19,10.17) v3(159.19,9.41) v3(159.68,160.11) v3(159.68,159.35) v3(159.68,158.59) v3(159.99,166.36) v3(159.95,10.17) v3(159.95,9.41) v3(160.09,139.74) v3(160.17,142.79) v3(160.17,141.9) v3(160.17,141.01) v3(160.47,160.12) v3(160.45,159.35) v3(160.45,158.59) v3(160.42,21.63) v3(160.42,20.87) v3(160.55,156.58) v3(160.5,23.77) v3(160.75,166.36) v3(160.71,10.17) v3(160.71,9.41) v3(161.26,160.12) v3(161.21,159.35) v3(161.21,158.59) v3(161.31,156.58) v3(161.31,21.63) v3(161.31,20.87) v3(161.47,10.17) v3(161.47,9.41) v3(162.07,156.58) v3(173.46,13.11) v3(173.46,12.32) v3(174.26,13.08) v3(174.26,12.29) v3(175.02,13.08) v3(175.02,12.29) v3(175.78,13.08) v3(175.78,12.29) v3(176.54,13.08) v3(176.54,12.29) v3(236.16,60.14) v3(236.92,60.14) v3(237.69,60.14) v3(237.69,59.38) v3(238.45,60.14) v3(238.45,59.38) v3(239.21,60.14) v3(239.21,59.38)
