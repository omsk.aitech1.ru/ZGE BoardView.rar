# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
WTB-GS12201-1011-7H-20P-L-SMT
  round 0.965 hole 0.965 unplated: (-5.8,0) (5.8,0)
  rect 0.254x1.143 smd: 1(-4.75,2.325) 2(-4.25,2.325) 3(-3.75,2.325) 4(-3.25,2.325) 5(-2.75,2.325) 6(-2.25,2.325) 7(-1.75,2.325) 8(-1.25,2.325) 9(-0.75,2.325) 10(-0.25,2.325) 11(0.25,2.325) 12(0.75,2.325) 13(1.25,2.325) 14(1.75,2.325) 15(2.25,2.325) 16(2.75,2.325) 17(3.25,2.325) 18(3.75,2.325) 19(4.25,2.325) 20(4.75,2.325)
  rect 1.295x1.397 smd: 21(-5.8,2.2) 22(5.8,2.2) 23(-5.8,-1.8) 24(5.8,-1.8)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-2X1_6-1_35X1_05
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6-0_9H
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)

## Nets
1V8_ANX: C238.1 C312.2 C414.1 C484.2 C823.1 C831.2 C926.2 C935.1 L33.2 L36.2 Q47.2 Q47.5 R255.1 R394.2 R524.1 R525.2 R529.1 R564.1 R573.1 R583.1 R601.1 R839.1 R898.1 R937.1 R984.2 R986.1 R987.2 R1005.1 R1012.1 R1061.2 R1132.1 R1133.1 R1134.1 R1138.2 R1146.2 U15.3 U15.6 U15.16 U15.25 U15.33 U24.22 U24.32 U24.48 U24.60 U27.5(VCC)
1V8_AON_EN: PR143.1 PR578.1 Q80.2 R1169.1 UG10.4(Y)
1V8_MAIN_EN: PQ45.2 PR477.2 PR478.1 UG5.4
1V8_MAIN_EN_U: DG5.1(CATHODE) RG179.2 RG180.1 UG5.2 UG6.4(Y)
1V8_MAIN_PG: DG5.2 RG183.2 UG8.1
1V8_MAIN_S: PC113.1 PC118.1 PR131.2 PU11.13 PU11.14(VOUT1#2)
3V3_SYS: C827.2 C828.2 C923.2 C924.2 L11.2 R254.1 R521.1 R528.2 R624.1 R840.1 R915.1 R957.2 R1115.1 R1139.2 R1141.1 R1147.2 U15.40 U24.54
3V_LDO: PC247.1 PR116.1 PR342.1 PR381.1 PR390.1 PU28.3
5V_VCONN: C470.1 R1043.2 R1077.1 U28.5 U28.6(OUT#2)
51211V_DRVH: PQ35.1 PU29.9
51211V_DRVL: PQ35.8 PU29.6
51211V_EN: PC449.1 PR385.2 PU29.3
51211V_FB: PR382.1 PR399.1 PU29.4
51211V_SW: PC278.2 PL24.1 PQ35.9 PR424.1 PU29.8
51211V_TRIP: PR384.2 PU29.2
51211V_TST: PR408.2 PU29.5
51211V_VBST: PR421.1 PU29.10
+1.2V: C3.2 C4.2 C5.2 C8.2 C11.2 C13.2 C15.2 C16.2 C17.2 C20.1 C21.2 C22.2 PQ46.1(S) PR469.1 U34.6 U34.11 U34.15(VDDTX12#2) U34.18 U34.30 U34.43 U34.46
+1.2V_U3: C930.1 C932.1 C933.1 C936.1 C937.1 C938.1 C942.1 L40.2 U30.4 U30.10 U30.19 U30.22 U30.23 U30.24 U30.28(VDDM#3) U30.34
+1.2VSUS: C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 C106.1 C107.1 C108.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C116.1 C117.1 C118.1 C119.1 C122.1 C123.1 C124.1 C125.1 C126.1 C127.1 C128.1 C129.1 C130.1 C131.2 C132.1 C133.1 C134.1 C135.1 C136.1 C137.1 C138.1 C139.1 C140.1 C141.1 C142.1 C199.1 C200.1 C291.1 C292.1 C293.1 C294.1 C295.1 C296.1 C297.1 C298.1 C299.1 C300.1 C301.1 C302.1 C303.1 C304.1 C305.1 C306.1 C307.1 C308.1 C309.1 C310.1 C311.1 C313.1 C314.1 C315.1 C316.1 C317.1 C318.1 C651.1 C654.1 C655.1 C657.1 C658.1 C662.1 C663.1 C666.1 C667.1 C668.1 C689.1 C690.1 C691.1 C759.1 CN14.8 JDIM1.12 JDIM1.33 JDIM1.54 JDIM1.75 JDIM1.96 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM1.129 JDIM1.130 JDIM1.135 JDIM1.136 JDIM1.141 JDIM1.142 JDIM1.147 JDIM1.148 JDIM1.153 JDIM1.154 JDIM1.159 JDIM1.160 JDIM1.163 JDIM1.178 JDIM1.199 JDIM1.220 JDIM1.241 JDIM2.12 JDIM2.33 JDIM2.54 JDIM2.75 JDIM2.96 JDIM2.111 JDIM2.112 JDIM2.117 JDIM2.118 JDIM2.123 JDIM2.124 JDIM2.129 JDIM2.130 JDIM2.135 JDIM2.136 JDIM2.141 JDIM2.142 JDIM2.147 JDIM2.148 JDIM2.153 JDIM2.154 JDIM2.159 JDIM2.160 JDIM2.163 JDIM2.178 JDIM2.199 JDIM2.220 JDIM2.241 JDIM3.12 JDIM3.33 JDIM3.54 JDIM3.75 JDIM3.96 JDIM3.111 JDIM3.112 JDIM3.117 JDIM3.118 JDIM3.123 JDIM3.124 JDIM3.129 JDIM3.130 JDIM3.135 JDIM3.136 JDIM3.141 JDIM3.142 JDIM3.147 JDIM3.148 JDIM3.153 JDIM3.154 JDIM3.159 JDIM3.160 JDIM3.163 JDIM3.178 JDIM3.199 JDIM3.220 JDIM3.241 JDIM4.12 JDIM4.33 JDIM4.54 JDIM4.75 JDIM4.96 JDIM4.111 JDIM4.112 JDIM4.117 JDIM4.118 JDIM4.123 JDIM4.124 JDIM4.129 JDIM4.130 JDIM4.135 JDIM4.136 JDIM4.141 JDIM4.142 JDIM4.147 JDIM4.148 JDIM4.153 JDIM4.154 JDIM4.159 JDIM4.160 JDIM4.163 JDIM4.178 JDIM4.199 JDIM4.220 JDIM4.241 L37.1 L40.1 PC119.1 PC123.1 PC230.1 PC232.1 PC237.1 PC250.1 PC258.1 PC268.1 PC269.1 PL25.2 PQ17.5 PQ46.3 PR401.1 PU27.19 R110.1 R216.1 R331.1 R332.1 R336.2 R717.1 R720.1 R793.1 R808.1 U3.AA6 U3.AE12 U3.AF5 U3.AF6 U3.AG5 U3.AG9 U3.AJ12 U3.AL11 U3.AP6 U3.AP7 U3.AR6 U3.AR12 U3.AT12 U3.AW6 U3.AY6 U3.J5 U3.J6 U3.K6 U3.K12 U3.L6 U3.L12 U3.R6 U3.T6 U3.W6 U3.Y12
+1.8V: PQ10.1(S) PR109.1 R34.1 RG64.2 RG73.2 RG176.2 RG186.2 RG191.2 RG193.2 UG10.5
+1.8V_AON: CG14.1 CG15.1 CG16.1 CG18.1 CG19.1 CG30.1 CG84.1 CG98.1 CG100.1 CG104.1 CG109.1 CG110.1 CG111.1 CG112.1 CG113.1 CG273.1 CG275.1 CG277.1 CG279.1 CG280.1 CG282.1 CG286.1 CG288.1 CG301.1 CG313.1 CG331.1 CG336.1 CG340.1 CG348.1 CG353.1 CG415.1 CG421.2 CG458.1 CG516.1 CG521.1 CG555.1 CG584.1 CG586.1 CG690.2 CG691.1 CG727.1 CG737.2 CG738.2 CG739.1 CG744.2 CG745.1 CG753.2 CG756.2 CG757.1 CG771.1 CG778.1 CG779.2 CG790.2 CG791.2 CG792.1 CG813.1 CG814.1 CG834.1 PC120.1 PC336.1 PC337.1 PL9.2 PR6.1 PR137.2 PR144.1 PR311.2 PR312.2 PR480.1 PU11.1 PU11.2 Q63.2 Q63.5 Q65.2 Q65.5 QG3.2 QG5.2 QG14.2 QG14.5 QG15.2 QG20.2 QG20.5 R1167.1 RG7.1 RG8.1 RG11.2 RG12.1 RG13.1 RG17.1 RG18.1 RG19.1 RG21.1 RG24.1 RG27.1 RG28.1 RG29.1 RG30.1 RG35.2 RG39.1 RG40.1 RG45.1 RG46.2 RG48.1 RG49.1 RG58.1 RG59.1 RG63.2 RG67.1 RG70.2 RG72.1 RG75.2 RG76.1 RG77.1 RG78.1 RG79.1 RG128.1 RG130.1 RG131.1 RG132.1 RG133.2 RG135.1 RG138.1 RG140.1 RG143.2 RG145.2 RG153.2 RG159.2 RG162.2 RG171.2 RG173.2 RG175.2 RG181.2 RG187.2 RG190.2 RG192.2 RG194.2 UG1.AW9 UG1.AW10 UG1.AW11 UG1.BA10 UG1.BB14 UG1.BC14 UG2.8 UG4.1 UG4.2 UG4.9 VRAM1.A5 VRAM1.A10 VRAM1.V5 VRAM1.V10 VRAM2.A5 VRAM2.A10 VRAM2.V5 VRAM2.V10 VRAM3.A5 VRAM3.A10 VRAM3.V5 VRAM3.V10 VRAM4.A5 VRAM4.A10 VRAM4.V5 VRAM4.V10 VRAM5.A5 VRAM5.A10 VRAM5.V5 VRAM5.V10 VRAM6.A5 VRAM6.A10 VRAM6.V5 VRAM6.V10 VRAM7.A5 VRAM7.A10 VRAM7.V5 VRAM7.V10 VRAM8.A5 VRAM8.A10 VRAM8.V5 VRAM8.V10
+1.8V_DEEP_SUS: C838.2 C851.2 C852.2 R225.2 R243.2 R366.1 R383.1 R393.1 R416.1 R468.2 R473.2 R894.1 R922.2 R932.1 U14.AG19 U14.AG20 U14.AN15 U14.AR15 U14.BB11
+1.8V_MAIN: CG36.2 CG37.2 CG39.2 CG40.1 CG41.2 CG42.2 CG780.2 CG782.2 CG784.2 CG786.2 CG788.2 CG832.1 CG846.2 CG848.2 CG850.2 CG851.2 CG855.2 LG1.2 LG2.1 PR131.1 PR474.1 Q62.2 Q62.5 R676.2 R679.1 RG69.1 RG141.2 RG183.1 UG1.BB26 UG1.BB27 UG1.BB29 UG1.BB32 UG1.BC26 UG1.BC27 UG1.BC29 UG1.BC30 UG1.BC32 UG1.BD27 UG1.BD30
+1.8V_S5: PC241.1 PC243.1 PL21.2 PQ10.3 PR383.2 R932.2 R1138.1 R1146.1
+1V_GFX: CG46.1 CG47.1 CG48.2 CG49.2 CG50.2 CG51.1 CG52.2 CG53.2 CG54.2 CG55.1 CG56.1 CG57.1 CG58.1 CG59.1 CG60.1 CG61.2 CG62.1 CG63.1 CG64.2 CG65.2 CG785.2 CG787.1 CG789.2 CG793.1 CG794.1 CG795.1 CG796.1 CG797.2 CG798.1 CG799.1 CG800.2 CG801.1 CG802.1 CG803.1 CG804.1 CG807.1 CG809.2 CG810.1 CG815.1 CG824.2 CG825.2 CG826.2 CG827.2 CG828.2 CG829.2 CG830.2 CG831.2 CG836.2 CG839.1 CG841.2 CG844.2 CG849.1 PC115.1 PC116.1 PC117.1 PQ17.1 PQ17.2 PQ17.3(S3) PR132.1 PR134.1 UG1.AR10 UG1.AT11 UG1.BB15 UG1.BB17 UG1.BB18 UG1.BB20 UG1.BB21 UG1.BB23 UG1.BB33 UG1.BB35 UG1.BB36 UG1.BC15 UG1.BC17 UG1.BC18 UG1.BC20 UG1.BC21 UG1.BC23 UG1.BC33 UG1.BC35 UG1.BC36 UG1.BD33 UG1.BD36
+1V_GFX_EN: PR138.2 UG3.4(Y)
+1V_GFX_PG: PR136.2 PR137.1 RG190.1 UG9.2
+1V_S5: C789.1 C790.1 C791.1 C802.1 C808.2 C810.1 C811.2 C817.1 C819.2 C820.2 C821.2 PC279.1 PC283.1 PL24.2 PQ20.3 PQ24.5 PR420.1 R159.1 R172.1 R177.1 R189.1 R192.2 R531.2 R833.1 R838.1 R855.2 R868.1 R872.1 U14.AA22 U14.AA23 U14.AB20 U14.AB22 U14.AB23 U14.AB27 U14.AB28 U14.AB30 U14.AD20 U14.AD23 U14.AD27 U14.AD28 U14.AD30 U14.AD31 U14.AE17 U14.AF23 U14.AF27 U14.AF30 U14.AF31 U14.AG31 U14.U26 U14.U29 U14.V25 U14.V27 U14.V28 U14.V30 U14.V31
+1V_SUS: PQ20.1(S) PR172.1 R685.1 R688.2 R690.1
+2.5VSUS: C102.1 C103.1 C104.1 C105.1 C229.1 C235.1 C244.1 C255.1 C273.1 C274.1 C747.1 C761.1 C765.1 C766.1 C770.1 C785.1 JDIM1.257 JDIM1.259 JDIM2.257 JDIM2.259 JDIM3.257 JDIM3.259 JDIM4.257 JDIM4.259 PC133.1 PC134.1 PC136.1 PL10.2 PR164.2
+3.3V_AON: PR576.2 RG195.1
+3.3V_AON_S: PC445.1 PR576.1 PU11.8 PU11.9
+3V: C120.2 C121.2 C143.2 C147.1 C149.1 C225.2 C330.2 C335.2 C345.1 C354.1 C523.1 C524.1 C674.2 C692.2 C693.2 C767.1 C768.1 CN8.12 CN14.7 JDIM1.255 JDIM2.255 JDIM3.255 JDIM4.255 L2.1 L3.1 L27.1 L31.1 PR41.2 PR80.1 PR142.2 PR292.2 PR355.2 PR356.2 PR366.1 PR386.1 PR416.1 PR429.1 Q19.2 Q19.5 Q24.2 Q33.2 Q33.5 Q61.2 Q61.5 Q66.2 Q66.5 Q68.2 Q69.2 Q70.2 Q70.5 R14.1 R21.1 R37.1 R40.1 R83.2 R85.2 R86.2 R118.1 R146.2 R156.1 R174.1 R186.1 R199.2 R230.2 R241.1 R242.1 R256.2 R279.2 R281.2 R305.2 R307.2 R312.2 R314.1 R322.2 R323.1 R325.1 R328.1 R330.1 R338.2 R343.2 R357.1 R362.2 R368.2 R391.2 R441.2 R446.2 R474.1 R490.2 R511.2 R512.1 R513.1 R514.1 R515.1 R546.1 R576.2 R604.1 R633.1 R641.1 R642.1 R646.1 R666.1 R669.1 R673.1 R694.1 R700.2 R701.2 R722.1 R723.1 R724.1 R726.1 R733.1 R735.1 R743.1 R747.1 R750.2 R776.2 R781.2 R790.2 R798.2 R805.1 R825.2 R831.2 R832.2 R835.2 R846.2 R861.1 R862.2 R864.2 R874.2 R875.2 R878.1 R880.2 R881.2 R888.2 R893.2 R895.2 R896.1 R900.1 R902.2 R909.2 R911.2 R927.1 R928.1 R929.1 R930.1 R1047.1 R1062.1 R1065.1 R1089.2 R1096.1 R1098.2 R1119.2 R1120.2 R1121.2 R1122.2 R1123.1 R1126.1 R1129.2 R1163.1 R1165.2 RG60.1 RG61.1 RG188.1 U38.1(VCC) U40.5
+3V3PD: C346.1 R379.1 R1148.1 U13.5
+3V3PD-1: C157.1 R141.1 R142.1 R163.2 U5.13(VCC)
+3V_AR: C708.2 C710.2 C715.2 C716.2 C717.2 C726.2 L28.2 R740.2 R741.2 R750.1 R762.2 R764.1 R777.2 U7.A2 U7.A3 U7.B3 U7.H9
+3V_DEEP_SUS: C492.2 C798.2 C814.2 C818.2 C832.2 C836.2 C845.2 C846.2 C870.2 C881.1 CN5.1 Q27.2 Q55.2 Q55.5 R95.1 R96.1 R101.2 R222.1 R258.1 R270.2 R288.1 R289.1 R303.1 R319.1 R351.2 R377.2 R382.2 R436.2 R438.2 R451.2 R460.2 R477.1 R478.1 R481.2 R483.2 R484.1 R495.2 R498.2 R508.2 R534.2 R535.1 R537.1 R542.2 R544.2 R549.2 R554.2 R575.1 R577.1 R579.2 R580.2 R581.2 R603.1 R606.1 R615.2 R616.2 R617.2 R779.2 R828.1 R830.1 R836.2 R844.1 R849.1 R856.2 R873.1 R879.1 R882.1 R885.1 R891.1 R905.1 R906.2 R907.1 R908.2 R910.1 R919.2 R931.2 R935.2 R977.1 R991.2 R1008.1 R1011.2 R1025.2 R1026.2 R1048.1 R1057.2 R1059.1 R1088.1 R1090.2 R1091.2 R1097.2 R1099.2 R1100.2 R1101.2 R1102.2 R1103.2 R1105.1 R1106.2 R1110.1 R1125.2 RG196.2 U6.5(VCC) U14.AC35 U14.AC36 U14.AE35 U14.AE36 U14.AN21 U14.AN24 U14.AN26 U14.AP26 U14.AT44 U14.AW9 U14.AY8 U14.BB7 U14.V23 U31.5(VCC) U42.5(VCC)
+3V_DP: C18.1 C19.1 C32.1 C33.1 C34.1 C35.1 C526.1 C527.1 CN2.20 R7.2 R25.1 R27.1 R29.1 R649.2 R650.1 R651.2 R662.1 R663.2 R668.1 R671.1 R672.1 U39.1 U39.6 U39.20 U39.28(VCC#4)
+3V_DVDD: C261.2 C272.2 L3.2 R296.2 R439.2 R1149.1
+3V_DVDD_IO: C265.2 C267.2 L2.2 R280.1
+3V_EC: C329.1 R339.2 R357.2 U18.11
+3V_EDP: C675.1 C676.1 C677.1 C678.1 C679.1 C688.1 L27.2 R111.1 R113.1 R115.1 R705.2 R706.1 R707.1 R711.1 R713.1 R715.1 U41.1 U41.6 U41.20 U41.28(VCC#4)
+3V_HDMI: C1.2 C2.2 C12.1 C515.2 C516.1 R1.1 R13.2 R15.2 R654.1 R657.1 R658.1 R659.1 R660.1 R681.2 R684.2 U2.1(OUT) U34.1 U34.24
+3V_LDO_EC: D44.1(CATHODE) PR390.2 PR400.2 R236.1 R237.2 R238.2 R240.2 R261.2 R273.2 R287.2 R356.1 R901.2
+3V_RTC: C431.2 C432.2 C433.2 C438.2 C488.1 D58.3(COMMON ANODE) R260.2 R262.2 R618.1 R619.1 R967.1 U14.BC49 U14.BD49
+3V_RTC_0: CN6.1 R566.1
+3V_RTC_1: D58.1 R566.2
+3V_S5: C266.1 C446.1 C513.1 C520.1 CG729.1 CN8.11 L30.1 PR148.1 PR149.1 PR348.2 PR411.1 PR412.1 PR581.1 Q31.1(S) Q39.2 Q71.1(S) Q74.2 Q74.5 Q79.1(S) R19.1 R142.2 R221.1 R245.2 R246.2 R265.2 R282.1 R339.1 R375.1 R502.1 R510.2 R829.1 R843.2 R942.2 R964.2 R1016.1 R1025.1 R1026.1 R1063.1 R1064.1 R1139.1 R1140.1 R1147.1 R1148.2 RG139.1 UG4.3
+3V_SSD1: C148.2 C150.1 C161.1 C165.1 C170.1 C180.1 C269.2 C283.2 CN15.2 CN15.4 CN15.12 CN15.14 CN15.16 CN15.18 CN15.70 CN15.72 CN15.74 R146.1 R859.1
+3V_SSD2: C376.2 C403.1 C410.1 C411.1 C412.1 C413.1 C485.2 C491.2 CN18.2 CN18.4 CN18.12 CN18.14 CN18.16 CN18.18 CN18.70 CN18.72 CN18.74 R391.1
+3V_SUS: C212.1 C213.1 CN14.4 L21.1 L35.1 L39.1 PQ56.1(S) PR579.1
+3V_TYPEC_DP1: C153.1 C154.1 C155.1 C156.1 C211.1 C214.1 C782.1 L29.2 L30.2 L31.2 R213.1 R788.1 R795.1 R800.1 R815.1 R818.2 R823.1 R826.1 U10.1 U10.6 U10.20 U10.28(VCC#4)
+3V_U3: C929.1 L39.2 R631.1 R1127.1 R1128.1 R1130.2 R1131.2 R1137.1 R1143.2 R1144.2 U30.1 U30.18
+3V_VCCSPI: R908.1 U14.AN44
+3VPCU: C496.1 C497.1 C895.1 C905.1 C927.2 CN5.3 CN5.7 CN8.1 CN14.5 CN19.22 D58.2 EC12.2 L29.1 PC130.1 PC131.1 PC231.1 PC233.1 PC235.1 PC240.1 PC259.1 PC262.1 PL22.1 PQ52.1(S) PQ53.1(S) PQ56.3 PR147.1 PR181.2 PR182.1 PR194.2 PR196.1 PR368.1 PR396.1 PR400.1 PR402.2 PR503.2 PR507.2 PR529.1 PR575.1 PU12.9 PU12.10(VIN#2) PU26.1 PU26.2 PU26.6 PU26.7 PU30.9 PU30.10(VIN#2) R80.1 R82.2 R141.2 R267.2 R286.2 R379.2 R532.2 R538.2 R623.2 R780.2
+3VPCU_EC: C251.1 C252.1 C258.1 C332.1 C333.1 C415.1 C890.1 L4.2 L14.1 R356.2 U18.26 U18.50 U18.92 U18.114 U18.121
+3VPCU_ECPLL: C262.1 L4.1 U18.127
+3VS5_HDMI: C14.2 R13.1 R14.2 R16.1 R19.2 U2.4 U2.5
+5V: C268.2 C278.2 C362.1 C363.1 C400.1 C402.1 C459.1 C460.1 D43.1 L7.1 PR341.2 PR496.1 PR561.2 PR565.2 R125.2 R459.1 R728.1 R734.1 R952.1 R968.1 R982.1 R999.1 R1038.1 R1039.1 U20.3 U20.4(PVDD2) U22.3 U22.4(PVDD2) U25.3 U25.4(PVDD2) U35.3
+5V_HDD: C457.2 C458.2 C464.1 C467.1 C468.1 C469.1 CN20.3 CN20.4 CN20.5 CN20.6 R459.2
+5V_HDMIC: C502.1 CN1.18 R10.1 R11.1 RV2.1 U35.1(OUT)
+5V_KB_M: C898.1 C906.1 C907.1 CN19.24 CN19.25 D111.1 Q75.3 R509.2 R1014.2
+5V_MCU: C100.2 C101.2 C447.2 C451.2 C877.1 D15.1(CATHODE) Q23.1(S) Q36.1(S) Q45.1 Q45.4(S) Q50.1 Q50.4(S) Q76.1(S) R122.2 R123.2 R125.1 R145.1 R152.2 R462.1 R472.2 R519.1 R582.1 R588.1 R596.1 R989.1 U4.8
+5V_S5: C909.1 PC114.1 PC371.1 PC372.1 PC373.1 PC374.1 PC375.1 PC376.1 PC377.1 PC378.1 PR2.1 PR11.1 PR36.2 PR37.2 PR38.2 PR39.2 PR56.2 PR61.2 PR86.2 PR139.1 PR177.1 PR186.1 PR187.1 PR188.1 PR189.1 PR190.1 PR191.1 PR192.1 PR256.2 PR264.1 PR268.1 PR301.1 PR331.1 PR375.1 PR394.1 PR427.1 PR458.2 PR483.1 PR519.1 PR522.1 PR524.1 PR526.1 PR528.1 PR533.1 PR537.1 PR539.1 PR560.1 PR562.1 PU10.1(VCC) PU14.4 PU15.4 PU16.4 PU17.4 PU18.4 PU19.4 PU20.4 PU21.4 Q75.1(S) R1014.1 R1159.1
+5V_S5_TYPEC: C257.1 C349.1 C462.2 C472.1 PC431.1 PC432.1 PU32.8 PU32.9 PU32.13 PU32.14(VOUT1#2) R569.2 U13.11 U13.25 U28.2
+5VA: C338.2 C343.2 C352.1 C360.1 L7.2 U17.26
+5VPCU: C189.1 C226.1 C517.1 C518.1 C917.1 CN8.3 PC244.1 PC275.1 PC276.1 PC433.1 PC434.1 PC435.1 PC436.1 PL23.2 PR395.2 PR479.2 PR563.1 PR564.1 PR566.2 PR568.2 PU29.7(VCC) PU31.1 PU31.2 PU31.6 PU31.7 PU32.1 PU32.2 PU32.6 PU32.7 R165.1 R166.1 R182.1 R183.1 R1084.2 R1085.2 U8.1 U11.1 U26.1
+12V_FAN: PC155.1 PC442.1 PD3.1(CATHODE) PR176.1 PR199.2 R729.2 R761.2
+12V_FAN1: C711.2 CN12.1 R761.1
+12V_FAN2: C698.2 CN11.1 R729.1
+A3VPCU: C392.1 L14.2 U18.74
+V3.3DX_ADO: C867.1 R977.2 U14.BB14
+VCC3P3_LC: C718.2 R753.1 R754.1 R755.1 R756.1 U7.R6
+VCC3P3_S0: C703.1 C704.1 C739.2 L28.1 R134.2 R138.2 R149.1 R744.2 R745.1 U7.R13
+VCC3P3_SX: C720.2 Q22.2 R132.1 R133.1 R135.2 R136.2 R137.2 R140.1 R732.2 R736.2 R742.2 R760.2 R764.2 R767.2 R779.1 R780.1 R803.1 U7.F8
+VCC_CORE: C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.1 C556.2 C557.1 C558.1 C560.2 C561.2 C563.2 C564.1 C565.2 C566.2 C567.1 C568.1 C569.1 C570.2 C571.2 C572.2 C573.1 C576.1 C577.2 C578.1 C579.2 C580.1 C581.1 C583.1 C585.1 C586.1 C587.1 C588.1 C590.1 C592.1 C593.1 C595.1 C596.1 C597.1 C599.1 C600.1 C602.1 C603.1 C604.1 C607.1 C609.1 C612.1 C613.1 C614.1 C615.1 C617.1 C621.1 C622.1 C623.1 C624.1 C627.1 C629.1 C632.1 C633.1 C634.1 C636.1 C637.1 C642.1 C644.1 C645.1 C646.1 C647.1 C652.1 C653.2 C656.2 C661.1 C664.2 C665.2 PC98.1 PC99.1 PC100.1 PC101.1 PC102.1 PC103.1 PC104.1 PC105.1 PC107.1 PC108.1 PC109.1 PC110.1 PC322.1 PC323.1 PC332.1 PC333.1 PL4.2 PL5.2 PL6.2 PL7.2 PR110.2 PR111.2 PR112.2 PR113.2 PR123.1 R32.2 U3.AA13 U3.AA31 U3.AA32 U3.AA33 U3.AA34 U3.AA35 U3.AA36 U3.AA37 U3.AA38 U3.AB29 U3.AB30 U3.AB31 U3.AB32 U3.AB35 U3.AB36 U3.AB37 U3.AB38 U3.AC13 U3.AC14 U3.AC29 U3.AC30 U3.AC31 U3.AC32 U3.AC33 U3.AC34 U3.AC35 U3.AC36 U3.AD13 U3.AD14 U3.AD31 U3.AD32 U3.AD33 U3.AD34 U3.AD35 U3.AD36 U3.AD37 U3.AD38 U3.AE13 U3.AE14 U3.AE30 U3.AE31 U3.AE32 U3.AE35 U3.AE36 U3.AE37 U3.AE38 U3.AF29 U3.AF30 U3.AF31 U3.AF32 U3.AF33 U3.AF34 U3.AF35 U3.AF36 U3.AF37 U3.AF38 U3.AG14 U3.AG31 U3.AG32 U3.AG33 U3.AG34 U3.AG35 U3.AG36 U3.AH13 U3.AH14 U3.AH29 U3.AH30 U3.AH31 U3.AH32 U3.AJ14 U3.AJ29 U3.AJ30 U3.AJ31 U3.AJ32 U3.AJ33 U3.AJ34 U3.AJ35 U3.AJ36 U3.AK31 U3.AK32 U3.AK33 U3.AK34 U3.AK35 U3.AK36 U3.AK37 U3.AK38 U3.AL13 U3.AL29 U3.AL30 U3.AL31 U3.AL32 U3.AL35 U3.AL36 U3.AL37 U3.AL38 U3.AM13 U3.AM14 U3.AM29 U3.AM30 U3.AM31 U3.AM32 U3.AM33 U3.AM34 U3.AM35 U3.AM36 U3.AN13 U3.AN14 U3.AN31 U3.AN32 U3.AN33 U3.AN34 U3.AN35 U3.AN36 U3.AN37 U3.AN38 U3.AP13 U3.AP30 U3.AP31 U3.AP32 U3.AP35 U3.AP36 U3.AP37 U3.AP38 U3.K13 U3.K14 U3.L13 U3.L14 U3.N13 U3.N14 U3.N30 U3.N31 U3.N32 U3.N35 U3.N36 U3.N37 U3.N38 U3.P13 U3.P14 U3.P29 U3.P30 U3.P31 U3.P32 U3.P33 U3.P34 U3.P35 U3.P36 U3.R13 U3.R31 U3.R32 U3.R33 U3.R34 U3.R35 U3.R36 U3.R37 U3.R38 U3.T29 U3.T30 U3.T31 U3.T32 U3.T35 U3.T36 U3.T37 U3.T38 U3.U29 U3.U30 U3.U31 U3.U32 U3.U33 U3.U34 U3.U35 U3.U36 U3.V13 U3.V14 U3.V31 U3.V32 U3.V33 U3.V34 U3.V35 U3.V36 U3.V37 U3.V38 U3.W13 U3.W14 U3.W29 U3.W30 U3.W31 U3.W32 U3.W35 U3.W36 U3.W37 U3.W38 U3.Y29 U3.Y30 U3.Y31 U3.Y32 U3.Y33 U3.Y34 U3.Y35 U3.Y36
+VCC_GT: R686.2 U3.AT14 U3.AT31 U3.AT32 U3.AT33 U3.AT34 U3.AT35 U3.AT36 U3.AT37 U3.AT38 U3.AU14 U3.AU29 U3.AU30 U3.AU31 U3.AU32 U3.AU35 U3.AU36 U3.AU37 U3.AU38 U3.AV29 U3.AV30 U3.AV31 U3.AV32 U3.AV33 U3.AV34 U3.AV35 U3.AV36 U3.AW14 U3.AW31 U3.AW32 U3.AW33 U3.AW34 U3.AW35 U3.AW36 U3.AW37 U3.AW38 U3.AY29 U3.AY30 U3.AY31 U3.AY32 U3.AY35 U3.AY36 U3.AY37 U3.AY38 U3.BA13 U3.BA14 U3.BA29 U3.BA30 U3.BA31 U3.BA32 U3.BA33 U3.BA34 U3.BA35 U3.BA36 U3.BB13 U3.BB14 U3.BB31 U3.BB32 U3.BB33 U3.BB34 U3.BB35 U3.BB36 U3.BB37 U3.BB38 U3.BC29 U3.BC30 U3.BC31 U3.BC32 U3.BC35 U3.BC36 U3.BC37 U3.BC38 U3.BD13 U3.BD14 U3.BD29 U3.BD30 U3.BD31 U3.BD32 U3.BD33 U3.BD34 U3.BD35 U3.BD36 U3.BE31 U3.BE32 U3.BE33 U3.BE34 U3.BE35 U3.BE36 U3.BE37 U3.BE38 U3.BF13 U3.BF14 U3.BF29 U3.BF30 U3.BF31 U3.BF32 U3.BF35 U3.BF36 U3.BF37 U3.BF38 U3.BG29 U3.BG30 U3.BG31 U3.BG32 U3.BG33 U3.BG34 U3.BG35 U3.BG36 U3.BH33 U3.BH34 U3.BH35 U3.BH36 U3.BH37 U3.BH38 U3.BJ16 U3.BJ17 U3.BJ19 U3.BJ20 U3.BJ21 U3.BJ23 U3.BJ24 U3.BJ26 U3.BJ27 U3.BJ37 U3.BJ38 U3.BK16 U3.BK17 U3.BK19 U3.BK20 U3.BK21 U3.BK23 U3.BK24 U3.BK26 U3.BK27 U3.BL15 U3.BL16 U3.BL17 U3.BL23 U3.BL24 U3.BL25 U3.BL26 U3.BL27 U3.BL28 U3.BL36 U3.BL37 U3.BM15 U3.BM16 U3.BM17 U3.BM36 U3.BM37 U3.BN15 U3.BN16 U3.BN17 U3.BN36 U3.BN37 U3.BN38 U3.BP15 U3.BP16 U3.BP17 U3.BP37 U3.BP38 U3.BR15 U3.BR16 U3.BR17 U3.BR37 U3.BT15 U3.BT16 U3.BT17 U3.BT37
+VCC_SA: C547.1 C562.1 C574.1 C575.2 C584.1 C591.1 C598.1 C605.1 C611.1 C620.1 C631.1 C643.1 PC89.1 PC90.1 PC96.1 PC97.1 PC328.1 PL3.2 PR108.2 PR120.2 U3.J30 U3.K29 U3.K30 U3.K31 U3.K32 U3.K33 U3.K34 U3.K35 U3.L31 U3.L32 U3.L35 U3.L36 U3.L37 U3.L38 U3.M29 U3.M30 U3.M31 U3.M32 U3.M33 U3.M34 U3.M35 U3.M36
+VCCA_BCLK: C787.2 R838.2 U14.V19
+VCCA_XTAL: C786.2 C793.2 R833.2 U14.P2 U14.P3 U14.W19 U14.W20
+VCCAMPHYPLL: C192.1 C195.1 C196.2 C206.2 R192.1 U14.C49 U14.D49 U14.E49
+VCCAPLL_1: C163.2 C166.2 EC3.2 R172.2 U14.C1 U14.C2
+VCCAPLL_2: C158.2 C162.2 EC4.2 R159.2 U14.B1 U14.B2 U14.B3
+VCCDPHY: C826.2 R808.2 U14.AJ22 U14.AJ23 U14.AK22 U14.AK23
+VCCDSW_1.05V: C452.1 R531.1 U14.BG45 U14.BG46
+VCCDUSB: EC9.2 R872.2 U14.W22 U14.W23
+VCCIO: C608.1 C618.1 C625.2 C630.2 C638.1 C641.2 PQ24.1 PQ24.2 PQ24.3(S3) PR22.1 PR91.1 R102.1 R103.1 R687.1 R689.2 U3.AG12 U3.G15 U3.G17 U3.G19 U3.G21 U3.H15 U3.H16 U3.H17 U3.H19 U3.H20 U3.H21 U3.H26 U3.H27 U3.J15 U3.J16 U3.J17 U3.J19 U3.J20 U3.J21 U3.J26 U3.J27
+VCCPGPPA: C833.1 R906.1 R922.1 U14.AN32
+VCCPLL: C559.2 C589.2 C594.1 R690.2 U3.H28 U3.J28
+VCCPLL_OC: C93.2 C648.1 C649.2 C659.2 R110.2 U3.BH13 U3.BJ13 U3.G11
+VCCPRIM_MPHY: C797.2 C801.2 R868.2 U14.W31
+VCCST: C537.2 C555.2 PR433.2 Q6.3 R36.2 R39.1 R42.1 R46.2 R71.1 R72.1 R73.1 R76.1 R78.1 R98.2 R108.2 R685.2 U3.H30
+VCCSTG: C582.2 R67.1 R688.1 R689.1 U3.G30 U3.H29
+VDD12: C841.2 C842.1 C843.2 C847.1 C853.2 C855.2 C860.1 C861.1 C865.2 C868.2 C871.1 C872.1 C875.2 C878.2 C884.1 C888.1 C892.2 C893.2 C894.1 C897.2 L37.2 U21.1 U21.4 U21.10 U21.13 U21.19 U21.24 U21.31 U21.32 U21.33 U21.37 U21.40 U21.41 U21.42 U21.46(VDDM#46) U21.52
+VDD33: C324.1 C325.1 C326.1 C427.1 C440.1 C449.1 L21.2 Q46.2 Q46.5 R306.2 R308.1 R309.1 R310.1 R363.1 R499.2 R516.2 R562.1 R567.1 R923.1 R979.1 R995.1 R1009.1 U21.28 U21.54
+VDD_DCI: C934.1 R1137.2 U30.5
+VDDIO: C859.1 L35.2 U21.14
+VDDQ: PC246.1 PR393.1
+VIN: PC13.1 PC44.1 PC45.1 PC46.1 PC47.1 PC55.1 PC56.1 PC57.1 PC59.1 PC70.1 PC74.1 PC75.1 PC88.1 PC94.1 PC211.1 PC214.2 PC216.1 PC218.1 PC219.1 PC222.1 PC224.1 PC236.1 PC248.1 PC274.1 PC280.1 PC281.1 PC282.1 PC284.1 PC285.1 PC286.1 PC287.1 PC288.1 PC289.1 PC290.1 PC302.1 PC303.1 PC304.1 PC305.1 PC308.1 PC309.1 PC310.1 PC311.1 PC326.1 PC327.1 PQ30.5 PQ32.5 PQ34.2 PQ35.2 PQ36.2 PQ37.2 PR67.2 PR69.1 PR178.1 PR195.1 PR272.2 PR295.1 PR372.1 PR419.2 PR457.2 PR466.1 PR467.1 PR475.1 PR487.1 PR509.1 PR580.1 PU3.8 PU3.9 PU4.8 PU4.9 PU5.8 PU5.9 PU6.8 PU6.9 PU7.1 PU8.8 PU8.9 R680.2 R1166.1
+VIN_GPU_TOTAL: PC16.1 PC24.1 PC28.1 PC49.1 PC51.1 PC52.1 PC53.1 PC69.1 PC294.1 PC312.1 PQ2.3 PQ2.4 PQ2.9 PQ3.3 PQ3.4 PQ3.9 PQ6.3 PQ6.4 PQ6.9 PQ7.3 PQ7.4 PQ7.9 PR32.1 PR271.2 PR272.1 PR294.1 PR299.2
+VIN_PANEL_R: C536.1 C538.1 C539.2 CN10.39 CN10.40 R680.1
+VIN_VGACORE: PC147.1 PC148.1 PC149.1 PC150.1 PC151.1 PC152.1 PC153.1 PC154.1 PC157.2 PC160.1 PC161.2 PC162.2 PC163.2 PC164.2 PC165.2 PC166.2 PC167.2 PC171.1 PC172.1 PC173.1 PC174.1 PC175.1 PC176.1 PC177.1 PC178.1 PC179.1 PC185.1 PC201.1 PC353.1 PC354.1 PC357.1 PC358.1 PC359.1 PC360.1 PC361.1 PC362.1 PC363.1 PC364.1 PC365.1 PC366.1 PC367.1 PC368.1 PC369.1 PC370.1 PC388.1 PC389.1 PC390.1 PC391.1 PC392.1 PC393.1 PC394.1 PC395.1 PC396.1 PC397.1 PC398.1 PC399.1 PC400.1 PC401.1 PR266.2 PR271.1 PR298.2 PU14.25 PU14.30 PU15.25 PU15.30 PU16.25 PU16.30 PU17.25 PU17.30 PU18.25 PU18.30 PU19.25 PU19.30 PU20.25 PU20.30 PU21.25 PU21.30
AVDD09: C340.1 C341.2 C829.1 L8.1 U15.1 U15.36
