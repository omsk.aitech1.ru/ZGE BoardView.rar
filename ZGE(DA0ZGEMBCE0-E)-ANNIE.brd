# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8V_DEEP_SUS: length 203.6
  TOP w0.254: U14.AG20 v1(212.69,32.56) ; U14.AG19 v1(211.93,32.58)
  TOP w0.381: U14.AR15 210.48,29.53 v1(210.53,29.58) 210.48,29.64 U14.AN15 ; U14.BB11 208.53,25.98 v1(208.31,26.21)
  TOP w0.508: R416.1 196.18,25.19 v1(195.9,25.47) ; R225.2 49.44,40.17 49.66,39.95 R243.2 ; R468.2 190.98,20.16 190.93,20.12 R473.2 190.04,20.6 190.04,26.71 188.57,28.18 v1(188.57,28.6) ; R393.1 196.61,27.25 R383.1 196.45,28.08 v1(195.94,28.08) ; v1(195.32,30.5) 195.84,30.5 R366.1
  IN1 w0.508: v1(102.8,23.63) 105.51,26.34 111.31,26.34 113.6,28.62 147.46,28.62 148.7,27.39 164.03,27.39 164.69,28.06 167.28,28.06 167.63,27.7 173.73,27.7 174.45,28.42 176.86,28.42 178.3,29.86 179.09,29.86 179.67,29.28 179.67,28.67 180.84,27.5 185.24,27.5 185.92,28.19 v1(186.05,28.19) ; v1(195.32,30.5) 194.33,30.5 193.77,29.94 191.89,29.94 190.55,28.6 v1(188.57,28.6)
  IN3 w0.508: v1(186.05,28.19) 186.46,28.6 v1(188.57,28.6)
  IN4 w0.508: v1(102.8,23.63) 100.94,21.77 100.94,19.64 99.3,18 98.01,18 97.3,18.71 95.32,18.71 93.92,20.11 92.02,20.11 91.38,19.47 90.72,19.47 89.93,18.69 89.93,18.53 89.07,17.67 88.66,17.67 88.39,17.39 87.9,17.39 86.33,15.82 86.33,15.13 85.01,13.81 84.09,13.81 83.7,14.21 80.7,14.21 79.93,14.98 79.93,15.84 79.64,16.13 77.43,16.13 76.63,16.93 68.01,16.93 67.43,16.35 65.72,16.35 64.8,17.28 63.9,17.28 63.45,17.72 62.72,17.72 62.27,18.17 61.72,18.17 60.29,19.6 58.99,19.6 58.99,19.61 55.4,19.61 54.84,20.17 53.78,20.17 53.19,20.76 53.19,25.13 52.5,25.82 51.83,25.82 50.86,26.79 v1(50.86,29.47)
  BOTTOM w0.381: C851.2 208.18,27.35 208.01,27.18 208.01,26.65 208.31,26.34 v1(208.31,26.21)
  BOTTOM w0.508: v1(52.91,39.81) 52.91,39 54.46,37.46 54.46,36.27 53.57,35.38 53.57,31.68 52.46,30.57 51.96,30.57 v1(50.86,29.47) ; R922.2 217.5,28.65 217.35,28.5 v1(217.01,28.16)
  vias: v1(201.09,28.64) v1(201.72,29.26)
+1.8V_MAIN: length 91.8
  TOP w0.508: v1(33.67,80.56) RG69.1
  IN2 w0.508: v1(17.61,102.62) 15.47,102.62 14.16,103.93 9.91,103.93 8.15,105.69 8.15,108.25 7.51,108.89 7.51,131.04 7.83,131.36 7.83,136.26 8.79,137.22 10.34,137.22 11,137.88 11,139.44 v1(10.28,140.15) ; v1(8.15,140.12) 8.17,140.14 10.28,140.14 v1(10.28,140.15) ; v1(10.28,140.15) 11.37,141.24 v1(11.37,141.39)
  IN4 w0.508: v1(33.67,80.56) 33.09,81.14 33.09,81.79 32.18,82.71 32.18,83.3 31.67,83.81 28.75,83.81 28.31,84.24 28.31,85 27.93,85.39 27.78,85.39 27.35,85.82 25.8,85.82 25.29,86.33 25.29,87.21 26.91,88.84 28.24,88.84 29.26,89.86 29.26,93.06 30.69,94.49 30.69,95.53 29.92,96.31 27.07,96.31 25.9,97.48 25.42,97.48 24.63,98.26 24.28,98.26 23.74,98.8 v1(23.74,98.94)
  BOTTOM w0.254: Q62.2 7.56,141.39 7.23,141.06 7.23,139.78 R679.1 ; Q62.5 v1(11.37,141.39)
  BOTTOM w0.381: v1(23.74,98.94) 23.48,98.67 PR474.1 ; R679.1 7.88,140.12 v1(8.15,140.12)
  BOTTOM w0.508: R676.2 v1(10.28,140.15)
  vias: v1(17.53,100.6) v1(17.98,99.91) v1(18.21,100.52) v1(25.52,103.09) v1(25.81,102.48) v1(26.18,103.06) v1(26.59,102.55) v2(54.11,100.5) v2(54.8,100.48) v2(55.59,100.52) v2(55.52,99.05) v2(56.13,100.48) v2(56.25,99.8)
+1.8V_S5: length 167.3
  TOP w0.178: PR383.2 176.12,26.57 PC243.1
  TOP w0.203: PC243.1 176.3,27.03 176.65,27.03 v1(176.8,27.17)
  TOP w0.508: v1(175.34,152.56) 176.62,152.56 PQ10.3 ; v1(182.26,42.64) 181.78,42.16 181.78,37.71 177.11,33.04 177.11,31.87
  IN3 w0.508: v1(175.34,152.56) 175.01,152.56 173.46,151 173.46,147.07 170.48,144.09 170.48,141.8 170.07,141.39 170.07,138.58 170.35,138.3 170.35,136.64 169.79,136.07 169.79,132.57 168.83,131.61 168.01,131.61 166.9,130.5 166.9,128.13 165.91,127.14 165.91,124.4 166.9,123.41 166.9,122.62 166.21,121.94 166.21,118.02 167.28,116.96 167.28,110.91 168.1,110.09 169.56,110.09 170.28,109.36 170.28,107.3 170.95,106.63 170.95,95.15 168.07,92.27 168.07,83.99 169.18,82.88 169.18,80.46 169.98,79.66 169.98,66.49 171.83,64.64 171.83,61.58 174.54,58.87 174.54,58.26 176.62,56.17 176.62,54.04 177.62,53.05 177.62,48.76 176.27,47.41 176.27,43.6 177.44,42.43 182.06,42.43 v1(182.26,42.64)
  IN4 w0.203: v1(165.36,27.07) 173.42,27.07 173.82,27.46 176.51,27.46 v1(176.8,27.17)
  BOTTOM w0.508: v1(155.07,27.09) 155.98,27.99 162.8,27.99 v3(163.65,28.84)
  vias: v1(191.28,17.44) v1(191.66,16.88) v1(192.04,17.42) v1(192.5,16.93) v1(210.08,27.34) v1(210.11,27.97) v1(228.62,10.61) v1(228.62,9.95) v1(229.38,10.61) v1(229.38,9.95)
+1V_GFX: length 12.6
  TOP w0.2: v2(52.7,100.5) UG1.BB23
  TOP w0.254: 44.42,103.88 UG1.AT11 UG1.AR10
  TOP w0.381: UG1.BB15 46.75,100.45 46.12,101.08 44.9,101.08 44.42,101.57 44.42,103.88
  TOP w0.508: PR134.1 96.47,96.14 97.11,95.5 v1(97.91,95.5) 98.55,95.5 98.99,95.05 100.73,95.05
  vias: v1(76.14,96.05) v1(76.19,95.39) v1(76.83,96.08) v1(76.84,95.38) v1(77.41,95.72) v1(85.98,94.47) v1(86.67,94.46) v1(87.39,94.45) v1(88.07,94.44) v1(88.72,94.45) v1(95.6,96.93) v1(96.27,96.93) v1(96.93,96.93) v1(97.59,96.93) v1(98.26,96.93) v2(47.63,100.47) v2(48.47,99.08) v2(48.5,100.48) v2(49.19,99.08) v2(49.88,100.45) v2(50.59,100.47) v2(51.45,100.46) v2(52.75,99.8) v2(58.97,99.1) v2(59.05,99.79) v2(60.4,99.77) v2(61.1,99.76) v2(61.78,99.79)
+1V_GFX_EN: length 88
  TOP w0.14: PR138.2 93.38,92.22 93.33,92.27 v1(92.94,92.27) 92.94,91.7 v1(93.06,91.59) ; UG3.4 v1(31.29,77.66)
  IN2 w0.089: v1(31.29,77.66) 31.68,77.28 34.38,77.28 35.2,78.1 38.37,78.1 38.47,77.99 38.47,77.66 38.65,77.49 39.05,77.49 39.28,77.73 39.28,78.05 39.66,78.43 41.06,78.43 41.61,78.98 42.59,78.98 42.91,78.67 42.91,78.33 43.28,77.95 45.7,77.95 46.03,77.63 49.13,77.63 49.2,77.69 54.12,77.69 54.42,77.99 87.77,77.99 89.12,76.64 90.37,76.64 v1(91.59,75.42)
  IN3 w0.089: v1(91.59,75.42) 91.59,75.62 90.74,76.47 89.94,76.47 86.02,80.39 86.02,84.78 91.48,90.24 91.71,90.24 v1(93.06,91.59)
+1V_GFX_PG: length 76.6
  TOP w0.203: PR136.2 90.95,92.52 PR137.1 91.59,92.49 92.38,91.71 v1(92.38,91.58)
  IN2 w0.089: v1(42.44,78.53) 43.2,77.76 45.62,77.76 45.95,77.44 49.21,77.44 49.28,77.5 54.33,77.5 54.62,77.8 87.69,77.8 89.04,76.45 89.96,76.45 v1(90.94,75.47)
  IN3 w0.089: v1(90.94,75.47) 90.68,75.47 85.83,80.31 85.83,85.03 v1(92.38,91.58)
  BOTTOM w0.14: RG190.1 42.44,78.34 v1(42.44,78.53) 42.92,79.01 42.92,79.47 42.56,79.82 UG9.2
+1V_S5: length 64
  TOP w0.203: PR420.1 172.84,18.1
  TOP w0.508: v1(228.87,16.37) 228.87,16.55 229.14,16.82 R531.2
  IN2 w0.508: v3(179.04,24.38) 180.84,24.38 181.26,23.96 186.24,23.96 188.26,21.94 192.37,21.94 193.52,20.79 195.01,20.79 196.41,19.4 196.41,17.39 199.27,14.53 203.89,14.53 205.1,13.32 v1(205.1,13.02)
  IN4 w0.508: v1(228.87,16.37) 229.02,16.23 229.02,15.17 228.24,14.39 226.84,14.39 226.4,13.95 226.4,13.57 224.82,12 222.92,12 221.48,10.56 219.57,10.56 218.13,12 215.51,12 213.4,14.11 211.41,14.11 211.15,13.86 209.34,13.86 209.28,13.92 207.45,13.92 207.41,13.88 205.96,13.88 v1(205.1,13.02)
  BOTTOM w0.508: v1(198.75,37) 198.78,37 199.39,37.61 R855.2
  vias: v1(195.19,48.07) v1(195.88,48.1) v1(212.65,34.88) v1(214.24,34.89) v1(215.01,34.11) v1(215.79,37.21) v1(215.79,34.84) v1(215.79,34.11) v1(216.56,37.21) v1(216.55,34.84) v1(216.56,34.11) v1(217.29,34.1) v1(217.34,37.21) v1(217.34,34.87) v1(218.11,37.21) v1(218.17,34.88) v1(218.16,34.1) v1(218.84,34.1) v1(233.65,44.49) v1(234.97,43.73) v3(177.56,26.33) v3(177.56,25.57) v3(177.56,24.81) v3(177.56,24.04) v3(177.95,27.02) v3(178.33,26.33) v3(178.33,25.57) v3(178.33,24.81) v3(178.33,24.04) v3(179.04,26.03) v3(179.04,25.21) v3(191.65,53.05) v3(191.65,52.29) v3(192.4,53.1) v3(192.4,52.34) v3(193.16,53.1) v3(193.16,52.34)
+1V_SUS: length 190.5
  TOP w0.508: v1(187.9,54.97) 187.42,55.45 PQ20.1 ; PR172.1 180.94,62.22 v1(180.94,62.07)
  IN2 w0.508: v1(187.9,54.97) 187.63,54.7 186.67,54.7 185.04,56.33 184.15,56.33 182.67,57.81 182.67,58.82 181.11,60.38 181.11,60.62 180.53,61.2 180.53,61.65 v1(180.94,62.07)
  IN3 w0.508: v1(109.02,66.52) 115.75,66.52 117.61,68.38 117.61,92.56 122.26,97.22 122.26,100.84 120.04,103.06 115,103.06 113.83,101.89 109.8,101.89 108.43,103.26 108.43,107.79 107.74,108.48 107.74,125.29 106.93,126.1 106.93,127.85 107.29,128.21 107.84,128.21 v1(108.12,127.93)
  BOTTOM w0.508: v1(180.94,62.07) 180.38,62.63 179.42,62.63 178.83,63.21 178.83,63.59 178.25,64.18 177.77,64.18 176.4,65.55 176.4,67.12 173.63,69.89 170.19,69.89 166.44,66.13 136.87,66.13 134.82,64.09 115.07,64.09 113.94,65.22 110.32,65.22 109.02,66.51 v1(109.02,66.52) ; v1(108.12,127.93) 108.12,128.06 109.02,128.96 R690.1 v1(107.67,129.07) 107.29,129.07 106.78,129.58 106.78,131.1 107.8,132.12 R688.2 109.02,132.89 109.02,132.89 R685.1
+2.5VSUS: length 11.6
  TOP w0.254: JDIM2.259 106.57,44.5 106.42,44.34 106.42,42.72 v1(106.69,42.45) 106.69,42.54 106.91,42.77 106.91,44.17 107.07,44.34 JDIM2.257
  BOTTOM w0.508: 101.54,42.33 101.85,42.64 106.5,42.64 v1(106.69,42.45)
  vias: v1(97.55,69.26) v1(100.86,40.4) v1(100.89,41.07) v1(101.49,48.58) v1(104.54,53.03) v1(104.54,52.37) v1(104.81,38.92) v1(106.27,57.06) v1(106.27,56.4)
+3.3V_AON: length 0.9
  BOTTOM w0.254: RG195.1 22.08,100.91 21.63,100.45 v1(21.63,100.41)
  vias: v1(22.62,99.86)
+3.3V_AON_S:
  vias: v1(21.48,97.32)
+3V: length 822.9
  TOP w0.203: v1(91.61,22.37) 91.61,22.27 91.08,21.73 R446.2 ; R312.2 86.8,34.26 87.01,34.46 v1(87.01,34.72) ; L3.1 33.52,39.11 33.36,39.28 33.36,40.51 33.17,40.71 33.17,41.67 32.35,42.49 32.35,43.54 31.75,44.14 PR292.2 ; R1165.2 69.39,40.15 R230.2 69.9,39.99 70.01,39.88 v1(70.01,39.57) ; 9.99,19.22 10.21,19 R511.2 ; v1(165.83,26.54) 165.71,26.42 PR386.1 ; R362.2 50.92,30.25 51.07,30.1 R368.2 ; R86.2 180.71,116.5 v3(180.64,116.58) ; PR41.2 v1(15.54,164.66) ; PR416.1 173.25,19.51 173.53,19.24 173.53,18.69 v1(173.65,18.56) ; R604.1 7.16,13.15 v1(6.8,13.5) ; R307.2 84.65,34.56 v1(84.35,34.25) ; v1(152.98,28.85) 153.38,28.85 PR366.1
  TOP w0.254: JDIM2.255 107.57,44.25 107.26,43.94 107.26,42.66 108.12,41.8 v1(108.47,41.8) ; v1(90.8,91.41) 91.21,90.99 PR142.2 ; v1(11.12,68.11) 10.99,68.11 10.74,67.86 Q19.5
  TOP w0.305: Q19.2 v1(8.4,67.86) 8.4,68.36 7.82,68.94 7.82,69.42 8.16,69.76 8.64,69.76 8.9,69.5 R118.1
  TOP w0.381: R314.1 107.51,33.68 107.49,33.66 R322.2 106.74,33.44 v1(106.74,31.75) ; v1(108.52,31.75) 108.52,32.03 109.43,32.93 110.23,32.93 R323.1 111,33.61 R325.1
  TOP w0.508: v1(130.8,31.61) 130.8,31.72 129.09,33.43 R330.1 ; v1(168.75,115.82) R83.2 168.08,116.57 167.76,116.25 R85.2 ; v1(198.32,22.27) 198.34,22.27 198.47,22.14 R441.2 ; v1(21.96,78.53) v1(21.27,77.84) 15.53,77.84 14.55,76.85 14.55,71.72 15.1,71.17 15.1,70.33 14.59,69.82 v1(14.32,69.82) ; v1(98.24,161.66) 98.43,161.66 99.15,162.38 v1(99.15,165.75) ; RG60.1 29.23,80.76 29.1,80.64 v1(29.1,80.6) ; v1(43.2,18.93) 43.2,17.99 43.76,17.43 R512.1 R513.1 45.62,17.43 45.65,17.41 R515.1 47.57,17.41 R514.1 ; R279.2 232.03,36.68 v1(232.01,36.71) 231.95,36.71 231.8,36.56 R281.2 ; v1(219.03,18.33) 219.12,18.43 219.12,18.92 R490.2 ; R474.1 v1(223.31,18.54) ; R357.1 63.3,31.53 v1(63.01,31.82) ; R40.1 180.09,133.18 179.97,133.3 R37.1 180.23,134.21 180.23,134.23 v1(180.65,134.65) ; 9.99,19.22 9.8,19.4 8.29,19.4 7.29,18.4 7.29,13.99 v1(6.8,13.5) ; v1(177.26,158.74) 177.05,158.53 PR80.1 ; v1(49.28,30.13) 49.4,30.25 R362.2 ; R174.1 9.7,49.43 v1(9.7,50.67) 10.37,51.34 Q24.2 ; R546.1 211.27,16.12 v1(211.27,15.43) ; v1(215.64,13.17) 215.84,13.37 R576.2 ; v1(33.85,81.3) 33.68,81.47 33.26,81.47 RG61.1 ; v1(8.12,53.33) 8.18,53.39 R156.1
  IN1 w0.254: v1(91.61,22.37) 91.61,21.63 94.07,19.17 97.1,19.17 97.81,18.46 99.49,18.46 v1(100.27,17.67)
  IN1 w0.508: v1(102.86,151.66) 102.34,152.18 102.34,158.03 100.25,160.11 100.25,160.11 98.7,161.66 v1(98.24,161.66) 98.24,162.86 97.01,164.09 91.58,164.09 90.66,163.17 86.82,163.17 86.28,163.72 80.56,163.72 79.92,163.08 79.19,163.08 77.26,165.02 75.41,165.02 74.75,164.36 v1(74.75,162.19) 72.43,162.19 72.06,161.82 70.95,161.82 70.38,161.26 69.67,161.26 69.26,161.66 68.29,161.66 68.17,161.54 61.49,161.54 60.29,162.74 57.98,162.74 56.53,161.29 48.93,161.29 48.71,161.07 47.76,161.07 46.56,159.87 42.89,159.87 42.53,159.5 37.95,159.5 37.37,160.09 36.26,160.09 v1(35.48,159.3) ; v1(21.96,78.53) 22.12,78.68 23.18,78.68 24.61,80.1 28.61,80.1 v1(29.1,80.6) 29.24,80.74 31.68,80.74 31.74,80.67 32.78,80.67 33.4,81.3 v1(33.85,81.3) ; v1(21.8,157.34) 19.95,157.34 v1(19.5,156.89) ; v1(63.14,16.45) 63,16.45 62.5,15.94 ; v1(106.46,40.98) 106.49,41.01 106.49,41.77 105.93,42.34 105.93,44.45 105.3,45.07 105.3,46.47 104.32,47.45 104.32,48.43 105.25,49.36 105.25,52.52 105.76,53.03 v1(105.91,53.03) ; v1(8.4,67.86) 8.65,68.11 v1(11.12,68.11) ; v1(67.52,12.73) 65.52,12.73 64.87,13.38 64.87,13.89 64.51,14.24 63.48,14.24 62.5,15.23 62.5,15.94 ; 62.5,15.94 61.33,15.94 60.27,17.01 60.27,18.28 59.28,19.26 59.28,27.12 59.86,27.7 60.34,27.7 60.88,28.24 61.16,28.24 v1(61.68,28.75) ; v1(168.75,115.82) 170.32,115.82 171.5,114.64 177.66,114.64 179.6,116.58 v3(180.64,116.58) 180.64,117.75 180.16,118.23 180.16,119.8 179.37,120.59 179.37,124.08 180.16,124.87 180.16,132.45 180.65,132.94 v1(180.65,134.65) 179.87,133.87 177.84,133.87 177.02,134.7 175.86,134.7 174.4,136.16 174.37,136.16 173.15,137.38 173.15,147.62 174.59,149.06 177.13,149.06 177.95,149.88 177.95,152.29 176.52,153.71 176.52,158 v1(177.26,158.74) ; v1(26.42,34.22) 27.25,33.39 31.36,33.39 32.45,34.48 32.91,34.48 34.03,35.61 35.25,35.61 35.76,35.1 35.76,34.66 37.1,33.31 37.1,31.84 38.78,30.17 40.23,30.17 v1(40.96,29.43) 41.98,30.45 44.21,30.45 45.31,29.35 v1(46.32,29.35) 48.85,29.35 49.28,29.78 v1(49.28,30.13)
  IN1 w0.762: 180.03,105.45 180.03,110.25 180.4,110.62 180.4,112.62 179.49,113.54 179.49,114.63 180.64,115.78 v3(180.64,116.58)
  IN2 w0.508: v3(94.18,66.23) 94.62,66.23 95.13,66.73 95.13,68.74 97.05,70.66 97.05,71.19 100.47,74.61 100.47,76.08 100.95,76.55 100.95,78.03 104.43,81.52 104.43,83.41 104.18,83.66 104.18,85.51 103.06,86.63 102.56,86.63 100.08,89.11 100.08,98.08 v1(100.1,98.11) 100.08,98.13 100.08,99.31 102.82,102.06 102.82,125.1 101.75,126.18 101.75,129.61 95.88,135.47 v1(95.88,137.2) ; v1(21.39,153.98) 21.08,154.3 21.08,155.34 21.8,156.07 v1(21.8,157.34) ; v1(97.03,50.34) 97.37,50.34 99.45,48.26 99.45,47.98 100.61,46.81 100.61,45.42 ; v1(67.52,12.73) 70.16,12.73 70.81,13.38 85.46,13.38 85.91,12.93 88.6,12.93 90.72,15.05 91.54,15.05 92.86,16.37 93.64,16.37 94.46,17.19 99.79,17.19 v1(100.27,17.67)
  IN3 w0.508: v1(6.8,13.5) 6.8,18.61 8.13,19.93 8.76,19.93 9.09,20.26 9.09,25.87 7.53,27.43 7.53,34.71 9.69,36.86 9.69,39.38 10.51,40.2 10.51,41.06 v1(9.73,41.84) ; v1(178.42,171.71) 178.82,171.71 179.3,171.23 179.3,170.22 178.89,169.8 178.89,161.64 178.45,161.2 177.74,161.2 177.18,160.65 177.18,160.19 177.46,159.91 177.46,158.94 v1(177.26,158.74) ; v1(90.8,91.41) 90.8,92.04 91.51,92.75 91.51,95.16 91.37,95.3 91.37,96.36 91.88,96.87 93.75,96.87 95.08,95.54 99.02,95.54 100.1,96.62 v1(100.1,98.11) ; v3(192.35,54.63) 192.35,57.88 192.96,58.49 v1(192.96,58.54)
  IN4 w0.254: v1(60.93,36.87) 62.19,35.61 62.19,33.98 62.55,33.62 62.55,33.17 63.01,32.71 v1(63.01,31.82)
  IN4 w0.508: v1(21.39,153.98) v1(21.39,151.75) ; v1(46.32,29.35) 45.64,28.67 45.64,26.42 46.44,25.62 46.44,24.65 43.2,21.41 v1(43.2,18.93) 43.55,18.93 44.49,19.88 45.89,19.88 46.97,18.8 47.78,18.8 48.67,17.91 49.7,17.91 49.96,18.17 52.09,18.17 52.52,17.74 53.64,17.74 54.7,16.68 57.07,16.68 57.35,16.96 57.35,18.41 57.93,19 58.73,19 58.74,19 60.04,19 60.66,18.37 60.66,17.47 62,16.13 62.72,16.13 63.04,16.45 v1(63.14,16.45) ; v1(9.7,50.67) 9.7,45.05 9.14,44.49 9.14,42.43 v1(9.73,41.84) ; v1(15.54,164.66) 16.07,164.13 18.69,164.13 20.97,161.84 20.97,158.17 v1(21.8,157.34) 22.41,157.94 22.41,159.08 24.66,161.33 28.85,161.33 29.28,160.9 33.88,160.9 v1(35.48,159.3) ; v1(14.17,47.11) 14.17,47.46 14.91,48.21 14.91,49.15 16.48,50.71 19.25,50.71 20.65,49.31 20.65,47.77 22.25,46.18 25.63,46.18 28.44,43.37 29.21,43.37 31.64,40.95 31.64,38.94 v1(32.08,38.5) ; v1(61.68,28.75) 62.42,29.5 62.42,29.88 63.25,30.7 63.25,31.58 v1(63.01,31.82)
  BOTTOM w0.203: v1(178.42,171.71) 178.14,171.99 178.14,172.87 PR429.1 ; R1122.2 218.5,14.68 R1126.1
  BOTTOM w0.254: R666.1 19.78,157.17 v1(19.5,156.89) ; v1(219.03,18.33) 218.94,18.42 R1062.1 218.51,19.01 R1065.1 ; C524.1 34.69,158.84 34.94,159.1 34.94,159.86 34.35,160.45 CN8.12 ; v1(60.93,36.87) 61.64,36.87 62.89,38.12 62.89,38.8 63.17,39.08 63.18,39.08 64.4,40.3 67.63,40.3 68.12,39.82 68.62,39.82 68.91,40.1 69.74,40.1 70,39.85 70,39.58 v1(70.01,39.57) ; R805.1 103.82,47.76 104.87,48.81 105.35,48.81 105.67,49.13 JDIM3.255 105.67,51.58 105.64,51.61 105.55,51.7 105.4,51.85 105.4,52.54 105.89,53.03 v1(105.91,53.03) ; JDIM4.255 105.67,38.84 v1(105.45,39.07)
  BOTTOM w0.305: R747.1 195.53,57.78 194.68,57.78 194.22,58.24 194.22,58.59 194.03,58.79 193.24,58.79 192.98,58.54 v1(192.96,58.54) ; Q61.5 22.88,150.28 ; 22.88,150.28 22.88,151.07 22.67,151.28 22.17,151.28 21.7,151.75 v1(21.39,151.75) ; 22.88,150.28 Q61.2
  BOTTOM w0.381: Q70.5 202.51,50.84 v1(202.3,50.64) ; R895.2 222.75,32.25 v1(222.75,31.89) ; U38.1 22.09,157.05 v1(21.8,157.34) ; v1(21.39,153.98) 21.19,153.77 R669.1 ; v1(202.3,50.64) 202.1,50.84 Q70.2 ; v1(202.3,50.64) 202.34,50.6 R798.2 ; v1(202.3,50.64) 202.3,51.71 202.46,51.86 R781.2 ; v1(233.6,33.8) 233.83,34.03 234.05,34.03 234.4,34.37 R881.2 234.4,34.88 233.68,35.6 R875.2
  BOTTOM w0.508: 223.41,12.99 223.41,13.15 223.07,13.49 R1129.2 ; 223.41,12.99 v1(223.41,12.97) ; 223.41,12.99 R1123.1 ; R835.2 228.93,40.72 228.93,39.96 228.94,39.96 v1(228.94,39.88) ; R862.2 R874.2 R880.2 R888.2 199.43,33.61 R893.2 199.43,31.63 R902.2 v1(198.1,31.6) ; v1(217.7,13.05) 217.7,13.88 R1126.1 ; v1(32.08,38.5) 31.8,38.5 30.96,37.67 30.96,35.63 30.32,34.98 29.58,34.98 29.23,35.34 28.77,35.34 28.34,34.92 28.34,34.31 27.83,33.8 26.84,33.8 v1(26.42,34.22) ; Q68.2 191.47,57.84 R743.1 ; Q68.2 191.75,58.8 191.38,59.17 R733.1 ; Q68.2 192.22,58.12 192.64,58.54 v1(192.96,58.54) ; R735.1 8.12,52.79 v1(8.12,53.33) ; v1(232.07,39.56) 232.07,39.27 R846.2 ; v1(100.27,17.67) 101.07,18.47 101.07,20.97 104.7,24.6 107.56,24.6 109.9,26.94 109.9,30.38 108.56,31.72 108.55,31.72 v1(108.52,31.75) ; v1(234.28,30.26) 233.62,30.26 R909.2 ; v1(14.32,69.82) 14.24,69.89 10.69,69.89 10.1,69.3 10.1,68.9 10.89,68.11 v1(11.12,68.11) ; R896.1 235.41,32.45 234.71,31.74 v1(234.36,31.74) 233.6,31.74 R900.1 ; v1(40.96,29.43) 40.93,29.4 R911.2 ; C524.1 C523.1 35.83,158.56 35.48,158.92 v1(35.48,159.3) ; v1(211.27,15.43) 211.78,14.93 R1120.2 R1119.2 214.02,14.93 R1121.2 214.04,15.11 214.37,15.44 R1098.2 ; v1(99.15,165.75) 99.73,165.18 R633.1 ; v1(95.88,137.2) 96.87,138.19 96.87,140.57 99.08,142.78 101.54,142.78 102.27,143.5 102.27,146.26 102.77,146.77 R673.1 103.56,147.48 102.86,148.18 v1(102.86,151.66) ; v3(179.47,104.18) 179.47,104.84 R701.2 ; R700.2 181.22,104.61 v1(181.22,104.12) ; R878.1 235.52,34.42 v1(235.35,34.26) ; R832.2 231.71,41.09 232.85,41.09 R831.2 233.06,40.64 233.46,40.24 v1(233.61,40.24) ; v1(234.51,36.85) 234.66,36.99 R861.1 ; R1096.1 217.34,16.34 217.34,15.28 215.86,13.81 215.86,13.45 215.61,13.2 215.61,13.17 v1(215.64,13.17) ; v1(226.89,18.38) 226.89,18.98 R1047.1 ; v1(251.15,49.16) 252.03,49.16 252.74,49.87 Q69.2 ; v1(205.78,15.6) 205.78,16.29 R1089.2 ; v1(175.07,21.94) 174.59,21.47 174.2,21.47 173.55,20.82 173.55,18.66 v1(173.65,18.56) ; R864.2 231.43,36.71 v1(232.01,36.71) ; v1(29.1,80.6) 28.87,80.37 RG188.1 ; v1(98.24,161.66) 97.96,161.38 97.96,161.37 97.45,160.86 R646.1 ; v1(233.52,43.6) 233.52,42.81 R825.2
  vias: v1(14.4,46.5) v1(100.81,43.14) v1(100.85,42.49) v1(100.87,41.82) v1(101.36,45.33) v1(101.42,44.62) v1(104.31,39.44) v1(104.97,39.56) v1(175.88,105.18) v1(181.22,103.46) v1(192.12,29.28) v1(192.12,28.63) v1(192.83,29.28) v1(192.83,28.63) v1(193.49,29.3) v1(193.49,28.63) v1(232.25,49.72) v1(232.73,49.24) v1(238.88,51.65) v1(239.6,51.65) v1(274.61,59.19) v1(275,58.56) v1(275.25,59.2) v1(275.66,58.59) v1(276.02,59.2) v3(91.25,32.39) v3(92.01,32.39) v3(92.77,32.39) v3(93.52,32.42) v3(94.18,65.43) v3(94.18,64.68) v3(94.27,32.41) v3(95.03,32.4) v3(180.39,101.7) v3(181.15,64.44) v3(181.62,63.82) v3(181.73,53.88) v3(182.39,54.27) v3(192.35,53.86) v3(193.13,54.63) v3(193.13,53.86)
+3V3PD:
  vias: v1(247.67,30.56)
+3V3PD-1:
  vias: v1(277.01,51.35) v1(279.52,51.8) v1(279.52,51.16) v1(281.7,55.92) v1(282.59,55.92)
+3V_AR: length 4.7
  TOP w0.203: v2(265.31,52.72) U7.H9
  BOTTOM w0.203: C726.2 265.49,52.54 v2(265.31,52.72)
  BOTTOM w0.508: R740.2 R741.2 258.76,59.49 v1(259.48,60.21) ; v1(255.62,53.97) 255.57,53.92 255.53,53.92 255.16,53.54 R777.2 ; v1(256.13,55.9) 255.66,55.43 R762.2
  vias: v1(268.7,55.26) v1(269.28,54.96) v1(269.84,55.29)
+3V_DEEP_SUS: length 328.1
  TOP w0.203: v1(235.32,40.28) 235.38,40.33 R222.1
  TOP w0.254: C492.2 206.33,10.34 206.94,9.73 U31.5 ; U14.BB7 206.81,26.55 U14.AY8 207.01,26.6 207.39,26.22 v1(207.61,26.22) 207.61,26.88 U14.AW9 ; v1(224.28,15.71) 224.28,15.64 224.11,15.48 CN5.1 ; U14.V23 v1(214.24,37.21) ; U14.AT44 224.64,28.84 223.81,29.67 v1(223.81,29.81) ; v1(215.92,10.96) 215.68,10.73 Q55.2
  TOP w0.305: U14.AN21 213.94,29.66 v1(214.17,29.66) 214.28,29.66 U14.AN24 ; U14.AN26 215.77,30.2 215.39,29.81 v1(215.39,29.66) 215.61,29.44 U14.AP26 ; Q55.5 213.11,10.73 212.96,10.88 v1(212.59,10.88) ; U6.5 209.97,50.45 210.54,49.87 v1(210.9,49.87)
  TOP w0.381: R258.1 231.43,38.54 v1(231.92,38.04) 232,38.04 232.38,37.65 R270.2 ; v1(231.96,34.48) R303.1 ; R436.2 230.49,22.32 v1(230.06,22.75) ; R289.1 232.64,35.47 v1(232.02,35.47) 231.42,35.47 R288.1 ; v1(235.1,42.84) 235.17,42.84 235.38,43.05 235.79,43.05 Q27.2 ; v1(225.98,18.46) 225.98,18.61 226.31,18.94 R481.2
  TOP w0.508: v1(228.01,16.4) 227.99,16.42 R534.2 ; v1(218.33,9.92) 218.51,9.92 218.83,10.24 R615.2 ; v1(169.49,109.29) 168.54,108.34 R96.1 ; R580.2 218.94,13.82 R581.2 218.96,13.62 219.07,13.51 v1(219.07,13.12) ; v1(204.47,15.68) 204.47,15.71 204.11,16.07 R544.2 ; C492.2 206.28,10.46 207,10.46 v1(207.13,10.33) ; R991.2 207.49,14.91 206.8,15.6 v1(206.52,15.6) ; R616.2 219.8,10.82 R615.2 ; R478.1 R477.1 215.67,18.58 v1(215.58,18.49) ; R617.2 218.01,10.82 218.01,10.82 R615.2 ; R101.2 110.04,105.23 110.98,104.29 111.49,104.29 112.42,103.37 112.42,101.56 113.55,100.43 113.55,96.48 116.56,93.47 166.63,93.47 169.81,96.65 169.81,101.44 167.91,103.34 R96.1 ; R438.2 R451.2 196.5,21.27 R460.2 ; v1(206.52,15.6) 206.52,15.85 R554.2 ; v1(206.52,15.6) R549.2 ; R542.2 v1(224.28,15.71) ; R535.1 213.68,16.08 v1(213.68,15.69) 214.35,16.36 R537.1 ; R606.1 215.32,12.55 216.13,12.55 v1(216.73,13.15) 216.73,13.59 R579.2 ; R484.1 210.99,18.47 v1(210.91,18.39) ; R351.2 189.46,32.56 v1(188.57,33.45) 188.06,33.45 186.66,34.85 186.66,40.54 ; R483.2 v1(212.95,18.46) ; R498.2 R460.2 ; R460.2 196.8,20.06 199.21,20.06 199.94,20.79 v1(199.94,21.28) ; R96.1 167.53,108.34 167.02,108.85 167.02,109.15 R95.1 ; R495.2 217.91,18.32 v1(217.91,18.32) ; R382.2 v1(234.21,28.33) ; v1(232.53,17.87) 232.33,17.67 231.69,17.67 R508.2 ; R377.2 v1(234.21,29.34)
  IN2 w0.381: v1(220.11,34.49) 220.11,34.94 220.24,35.07 220.24,38.17 218.27,40.14 217.23,40.14 216.63,40.73 215.14,40.73 213.53,42.34 213.53,44.65 212.87,45.31 212.87,47.54 210.9,49.52 v1(210.9,49.87)
  IN2 w0.508: v1(223.81,29.81) 222.78,30.84 221.61,30.84 219.62,32.83 219.62,33.37 220.11,33.86 v1(220.11,34.49)
  IN3 w0.508: v1(236.16,31.79) 236.39,31.56 237.34,31.56 238.15,32.37 238.15,33.98 238.22,34.05 v1(238.22,34.84) ; v1(220.11,34.49) 220.11,34.84 219.6,35.35 218.69,35.35 218.53,35.51 215.39,35.51 215.03,35.86 215.03,36.7 214.52,37.21 v1(214.24,37.21) ; v1(187.68,41.85) 186.1,41.85 185.87,41.62 183.27,41.62 183.07,41.82 177.18,41.82 175.66,43.35 175.66,47.67 177.01,49.01 177.01,52.8 176.02,53.79 176.02,55.92 173.93,58 173.93,58.61 171.07,61.48 171.07,64.22 168.57,66.72 168.57,82.62 167.46,83.73 167.46,93.09 170.08,95.72 170.08,106.64 169.49,107.23 v1(169.49,109.29)
  IN4 w0.508: v1(207.13,10.33) 209.69,10.33 210.51,11.15 212.32,11.15 v1(212.59,10.88) ; v1(202.89,27.37) 203.37,27.37 204.11,28.11 204.11,29 203.35,29.76 202.71,29.76 201.44,31.03 200.42,31.03 198.9,32.55 196.11,32.55 195.75,32.19 194.05,32.19 193.36,32.88 189.14,32.88 v1(188.57,33.45) ; v1(218.33,9.92) 218.33,10.28 217.65,10.96 v1(215.92,10.96)
  BOTTOM w0.203: R1097.2 215.73,16.49 215.95,16.27 R1110.1
  BOTTOM w0.381: R1057.2 212.27,19.13 v1(212.95,18.46) ; v1(212.13,21.65) 212.29,21.5 R1008.1
  BOTTOM w0.508: v1(202.89,27.37) 202.63,27.63 R935.2 ; R1125.2 219.75,13.7 219.17,13.12 v1(219.07,13.12) ; v1(215.58,18.49) 215.24,18.84 R1059.1 215.18,19.17 R1048.1 ; R919.2 234.08,29.22 v1(234.21,29.34) ; v1(234.21,28.33) 234.11,28.23 R931.2 ; v1(216.08,15.24) 215.41,15.91 R1097.2 ; v1(224.28,15.71) 224.28,15.79 224.18,15.89 R1100.2 R1101.2 R1102.2 R1103.2 ; v1(236.16,31.79) 236.34,31.62 R905.1 R910.1 ; R1106.2 211.4,16.24 v1(211.96,15.69) 211.96,15.87 212.37,16.28 R1105.1 ; v1(235.1,42.84) 235.43,42.84 235.47,42.8 235.89,42.38 R828.1 235.89,41.23 R830.1 235.85,40.98 235.32,40.45 v1(235.32,40.28) ; R856.2 231.42,37.54 v1(231.92,38.04) 232.28,37.68 R849.1 232.73,37.69 R844.1 232.73,39.01 232.78,39.06 232.78,39.88 232.45,40.21 231.77,40.21 231.41,39.85 R836.2
  vias: v1(200.98,21.96) v1(201.64,21.96) v1(202.3,21.96) v1(202.96,21.96) v1(211.83,13.03) v1(220.77,34.51) v1(255.92,45.13) v1(256.69,45.13) v1(257.45,45.13) v1(275,51.2) v1(275.76,51.2) v1(276.21,51.77)
+3V_DP: length 55.2
  TOP w0.508: C19.1 80.92,161.43 80.14,162.21 80.14,163.43 v1(79.44,164.13) 78.01,164.13 76.8,165.34 R7.2 ; v1(90.37,146.15) v1(91.53,146.15) 92.86,147.48 R25.1 ; R27.1 v1(94.89,149.25) ; R29.1 96.92,148.81 96.97,148.86 v1(96.97,149.37) 96.97,150.05 96.82,150.2 96.82,151.7 v1(96.46,152.06)
  IN1 w0.508: v1(79.44,164.13) 79.71,164.39 91.01,164.39 91.52,164.9 91.52,166.08 CN2.20 ; v1(90.61,158.94) 90.22,159.33 88.96,159.33 88.07,158.44 83.13,158.44 v1(82.19,159.38)
  IN2 w0.508: v1(81.16,162.34) 82.19,161.31 v1(82.19,159.38)
  IN3 w0.508: v1(85.16,153.27) 85.34,153.27 86.82,154.75 v1(88.61,154.75) 88.61,158.15 89.41,158.94 v1(90.61,158.94)
  BOTTOM w0.508: R650.1 83.37,159.03 82.55,159.03 v1(82.19,159.38) ; R668.1 85.81,153.84 85.25,153.27 v1(85.16,153.27) ; v1(90.61,158.94) 89.56,158.94 R649.2
  vias: v1(82.19,162.22) v1(89.23,149.53) v2(96.14,155.17) v2(96.14,154.37)
+3V_DVDD: length 25.8
  TOP w0.508: R439.2 38.32,22.29 v1(38.7,21.9)
  IN1 w0.508: v1(38.7,21.9) 40.07,21.9 40.51,22.34 42.92,22.34 45.03,24.45 45.03,27.17 44.52,27.68 43.1,27.68 42.41,28.36 41.78,28.36 41.32,28.82 40.23,28.82 39.49,29.56 38.52,29.56 36.44,31.64 36.44,33.11 35.1,34.45 v1(35.1,34.89)
  BOTTOM w0.508: v1(35.1,34.89) 35.03,34.82 R1149.1
  vias: v1(35.71,38.85)
+3V_DVDD_IO:
  vias: v1(29.41,37.38)
+3V_EC: length 8.8
  TOP w0.203: U18.11 68.59,29.42 68.39,29.62 68.39,29.65
  TOP w0.254: 68.39,29.65 68.39,29.77 67.63,30.53 67.63,31.57 67.16,32.04 C329.1 67,32.26 66.72,32.54 65.75,32.54 v1(65.73,32.51) 65.3,32.51 R339.2 64.69,31.94 R357.2
+3V_EDP: length 40.1
  TOP w0.508: 176.32,85.61 R111.1 174.99,85.34 174.09,85.34 173,86.43 v1(173,86.61) ; 176.32,85.61 176.29,85.63 R113.1 ; 176.32,85.61 177.02,85.61 178.33,86.91 R115.1 ; v1(182.86,91.97) 181.54,93.28 181.54,96.65 v1(180.4,97.79)
  IN1 w0.508: v1(173,86.61) 171.58,88.03 170.86,88.03 v1(170.61,87.77) 170.61,90.42 v1(170.58,90.45) 170.58,90.79 v1(174.2,94.4)
  IN4 w0.508: v1(180.4,97.79) 178.23,95.62 175.41,95.62 v1(174.2,94.4)
  BOTTOM w0.508: v1(170.61,87.77) 170.61,87.79 R715.1 ; v1(170.58,90.45) R711.1 R713.1 ; v1(173,86.61) 172.69,86.91 172.69,88.28 173,88.59
  vias: v1(171.01,94.87)
+3V_HDMI: length 115.5
  TOP w0.508: v1(69.14,162.54) 69.14,163.1 68.99,163.25 C12.1 68.86,163.25 68.35,162.75 68.35,162.24 U2.1 63.34,161.85 ; 63.34,161.85 63.34,162.28 61.88,163.74 R1.1 ; 63.34,161.85 62.7,161.85 62.33,161.48 59.9,161.48 v1(58.42,160) ; R15.2 47.22,164.79 46.75,165.26 v1(46.75,166.28) ; v1(72.75,163.74) 73.62,163.74 73.92,163.44 R13.2
  IN1 w0.508: v1(9.21,142.54) 7.83,143.92 7.83,146.19 8.68,147.03 13.07,147.03 13.28,146.83 17.03,146.83 18.53,148.33 18.53,154.88 19.36,155.7 20.63,155.7 21.42,156.5 22.4,156.5 24.41,158.51 28.06,158.51 28.85,159.3 29.59,159.3 31.36,161.08 34.33,161.08 34.91,161.66 40.28,161.66 40.79,162.17 40.79,162.5 41.52,163.24 44.09,163.24 44.6,163.74 44.6,164.51 46.37,166.28 v1(46.75,166.28) 47.45,165.59 48.17,165.59 v1(49.45,166.87)
  IN3 w0.508: v1(72.75,163.74) 71.67,163.74 70.68,162.75 69.36,162.75 v1(69.14,162.54) ; v1(46.75,166.28) 46.9,166.14 46.9,160.73 48.89,158.74 55.49,158.74 56.75,160 v1(58.42,160)
  IN4 w0.508: 8.74,139.01 8.89,139.17 8.89,142.21 v1(9.21,142.54) ; 8.74,139.01 v1(8.17,138.45) ; 8.74,139.01 9.65,139.01 v1(10.31,138.35)
  BOTTOM w0.508: R659.1 51.64,156.5 49.5,156.5 49.18,156.82 49.18,157.32 R657.1 ; R684.2 7.77,138.04 v1(8.17,138.45) ; R681.2 v1(10.31,138.35)
+3V_LDO_EC: length 87.2
  TOP w0.381: v1(84.42,39.26) 84.85,38.83 R261.2 ; v1(66.95,33.01) 66.85,33.1 65.86,33.1 65.48,33.49 65.48,33.62 64.55,34.55 D44.1 64.09,34.67 63.09,35.67 R287.2 ; v1(82.98,38.94) v1(82.5,38.46) R273.2 ; 115.55,25.56 115.17,25.18 112.71,25.18 112.13,25.75 112.13,27.73 112.78,28.37 v1(112.78,31.61) ; 115.55,25.56 PR390.2 ; 115.55,25.56 PR400.2 ; v1(90.44,30.55) 90.44,30.62 89.87,31.19 R356.1
  IN2 w0.381: v1(90.44,30.55) 90.44,30.27 90.06,29.89 90.05,29.89 90.01,29.85 88.46,29.85 88.33,29.72 85.74,29.72 84.93,30.53 v1(83.45,30.53)
  IN3 w0.381: v1(84.42,39.26) 84.32,39.36 83.4,39.36 v1(82.98,38.94)
  IN4 w0.381: v1(82.98,38.94) 82.19,39.74 79.34,39.74 v1(79.32,39.77) 78.65,39.77 77.7,38.82 76.38,38.82 75.92,38.36 74.23,38.36 73.38,37.51 72.33,37.51 71.3,38.54 v1(71.3,38.56) ; v1(90.44,30.55) 91.03,29.96 95.74,29.96 96.12,29.57 97.11,29.57 97.18,29.51 100.52,29.51 100.9,29.89 100.9,30.73 100.93,30.75 101.61,31.44 102.79,31.44 103.02,31.2 111.13,31.2 111.38,31.45 112.48,31.45 112.64,31.61 v1(112.78,31.61)
  BOTTOM w0.381: v1(66.95,33.01) 66.95,36.36 67.93,37.34 69.43,37.34 70.02,37.93 70.68,37.93 v1(71.3,38.56) ; v1(82.98,38.94) 83.28,38.65 83.28,35.87 82.8,35.38 82.8,31.67 83.45,31.03 v1(83.45,30.53) ; R901.2 89.89,31.81 90.44,31.25 v1(90.44,30.55)
+3V_RTC: length 172.3
  TOP w0.508: R619.1 C488.1 R618.1 201.2,10.96 v1(201.19,10.96)
  IN2 w0.508: v1(234.63,16.02) 235.27,15.38 235.27,13.76 234.31,12.8 230.86,12.8 230.37,12.31 225.88,12.31 225.71,12.15 222.03,12.15 221.43,12.74 219.91,12.74 219.44,12.27 212,12.27 211.86,12.41 210.73,12.41 209.42,11.1 208.27,11.1 207.54,11.83 202.06,11.83 v1(201.19,10.96) 198.85,10.96 196.87,12.95 196.87,15.94 194.07,18.74 191.43,18.74 190.75,19.43 190.75,20.03 189.45,21.33 187.93,21.33 187.24,22.01 184.2,22.01 183.99,21.8 181.16,21.8 v1(180.49,22.47)
  IN4 w0.508: v1(180.49,22.47) 180.18,22.47 177.05,19.34 173.76,19.34 171.72,21.38 171.72,25.11 v1(171.34,25.49)
  BOTTOM w0.508: v1(228.57,24.2) 228.57,24.4 R967.1 ; v1(171.34,25.49) 170.9,25.49 168.47,27.92 168.45,27.92 163.67,27.92 163.1,27.35 156.52,27.35 v1(154.04,24.87) 152.67,23.5 150.93,23.5 150.44,23 149.14,23 148.6,23.55 141.3,23.55 140.57,24.27 136.2,24.27 134.45,26.03 134.45,27.41 132.5,29.36 113.69,29.36 109.49,33.57 101.21,33.57 99.06,35.72 97.46,35.72 95.08,38.1 v1(95.08,38.48)
+3V_RTC_0: length 3.3
  TOP w0.508: CN6.1 239.24,15.43 238.53,15.43 v1(238.42,15.54) 237.71,15.54 R566.1
+3V_RTC_1: length 2.3
  TOP w0.508: v1(237.56,16.5) 237.27,16.21 D58.1 236.42,16 R566.2
+3V_S5: length 719.1
  TOP w0.203: PR149.1 94.86,78.01 PR148.1 ; Q39.2 90.94,17.88 R510.2 ; R246.2 76.82,39.49 76.47,39.84 v1(76.47,39.92) 76.09,39.54 R245.2
  TOP w0.381: Q39.2 90.33,18.25 90.16,18.08 v1(90.16,17.8)
  TOP w0.508: v1(84.55,41.57) 84.17,41.19 R221.1 ; v1(74.64,160.14) 74.5,160 R19.1 ; v1(111.46,76.17) 111.46,73.8 110.37,72.71 109.26,72.71 108.42,73.55 108.42,76.78 107.81,77.39 105.12,77.39 103.77,78.74 101.95,78.74 99.54,81.14 97.5,81.14 96.5,80.14 96.5,79.24 96.23,78.97 95.2,78.97 95.15,78.92 94.75,78.52 PR148.1 ; R339.1 63.49,33.9 63.52,33.92 v1(63.52,33.92) ; v1(37.12,37.41) 37.12,37.41 37.12,36.15 37.64,35.63 37.64,35.35 38.4,34.59 PR348.2 ; v1(247.14,27.68) 246.07,27.68 246.06,27.69 245.75,27.69 245.43,28.01 245.43,28.01 245.26,28.18 R1148.2 ; v1(251.68,28.41) 251.68,28.46 252.11,28.9 R375.1
  IN1 w0.508: v1(74.64,160.14) 74.64,160.65 73.71,161.58 72.68,161.58 72.31,161.21 71.21,161.21 70.2,160.21 61.82,160.21 59.9,162.13 58.23,162.13 56.72,160.62 50.12,160.62 48.76,159.26 45.99,159.26 45.28,158.55 42.98,158.55 42.71,158.82 39.13,158.82 38.75,158.44 34.23,158.44 33.3,159.37 v1(32.74,159.37) ; v1(94.25,38.42) 94.12,38.42 93.91,38.62 92.47,38.62 91.79,37.94 91.01,37.94 90.27,38.68 86.8,38.68 85.22,40.25 81.88,40.25 81.09,41.05 75.89,41.05 75.1,41.83 71.44,41.83 v1(70.5,42.76) ; v1(60.15,50.82) 58.97,50.82 58.24,51.55 58.24,53.36 57.12,54.48 53.08,54.48 52.88,54.28 50.58,54.28 49.55,53.25 47.26,53.25 46.85,53.65 45.38,53.65 44.85,53.13 44.2,53.13 43.66,52.59 41.44,52.59 40.51,51.65 40.49,51.65 40.03,51.19 39.51,51.19 37.76,49.44 v1(36.9,49.44) ; v1(239.62,53.31) 240.25,53.94 241.5,53.94 242.94,52.49 247.8,52.49 250.46,55.16 251.55,55.16 252.65,56.25 252.65,57.47 v1(254.96,59.78) ; v1(84.55,41.57) 84.51,41.53 82.5,41.53 82.14,41.89 82.14,43.99 82.98,44.82 84.3,44.82 85.52,46.04 v1(86.05,46.04)
  IN2 w0.305: v1(84.55,41.57) 82.22,41.57 80.93,40.28 76.83,40.28 v1(76.47,39.92)
  IN2 w0.508: v1(282.97,58.97) v1(282.21,58.97) 282.21,57.75 281.56,57.09 273.94,57.09 273.72,57.3 267.46,57.3 266.37,58.4 259.88,58.4 258.49,59.78 v1(254.96,59.78) ; v1(70.5,42.76) 69.87,42.13 66.54,42.13 62.46,46.21 61.37,46.21 60.86,46.71 60.86,47.53 60.06,48.34 60.06,49.05 60.15,49.15 v1(60.15,50.82) ; v1(247.14,27.68) 247.14,27.07 247.93,26.27 247.93,25.3 v1(247.14,24.5) ; v1(240.41,34.72) 240.51,34.62 246.57,34.62 246.98,34.21 248.13,34.21 248.58,34.66 248.58,37.56 249.27,38.24 251.3,38.24 252.05,39 252.7,39 252.71,38.98 v1(252.72,38.98)
  IN3 w0.508: v1(86.05,46.04) 86.05,46.11 85.69,46.46 85.69,49.96 88.56,52.82 89.37,52.82 90.2,53.65 90.2,53.86 91.42,55.08 91.42,56.84 92.72,58.14 94.24,58.14 96.22,60.12 96.22,61.22 95.62,61.82 95.62,63.2 97.23,64.81 97.23,65.23 101.16,69.16 103.09,69.16 105.66,71.73 106.58,71.73 106.74,71.89 108.97,71.89 111.46,74.39 v1(111.46,76.17) 111.46,82.96 112.09,83.59 112.09,93.55 108.38,97.26 107.25,97.26 102.45,102.05 102.45,131.98 97.45,136.97 97.45,144.16 95.5,146.12 95.5,147.72 96.36,148.58 97.25,148.58 98.01,149.34 98.01,150.49 98.67,151.15 98.67,154.4 98.37,154.7 98.37,156 98.04,156.33 98.04,159.14 96.46,160.72 88.61,160.72 87.94,160.05 84.77,160.05 84.45,160.37 79.44,160.37 79.19,160.62 75.13,160.62 v1(74.64,160.14) ; v1(18.23,103.27) 18.23,103.06 18.41,102.88 18.41,101.55 19.46,100.5 19.46,99.69 17.85,98.07 17.85,96.31 18.46,95.7 18.46,93.03 17.99,92.56 17.99,89.83 16.8,88.65 16.8,88.61 14.95,86.76 14.71,86.76 12.85,84.9 12.85,83.66 13.28,83.22 13.96,83.22 14.32,82.87 14.32,78.68 13.83,78.19 13.83,77.49 14.45,76.87 14.45,71.58 14.95,71.08 14.95,66.39 15.45,65.89 15.45,62.19 16.12,61.51 16.12,60.18 17.67,58.64 17.67,56.69 19.72,54.63 19.72,52.74 21.1,51.36 21.1,48.24 22.44,46.9 25.98,46.9 26.16,46.72 26.17,46.72 26.22,46.67 v1(26.81,46.67) ; v1(178.71,16.55) 178.12,17.14 178.12,18.46 178.63,18.96 182.9,18.96 183.98,17.88 185.61,17.88 189.35,14.14 189.35,12.54 189.75,12.13 190.47,12.13 191.17,12.83 195.23,12.83 195.8,12.26 197.5,12.26 199.71,10.05 203.16,10.05 203.8,10.68 206.26,10.68 206.6,11.02 207.93,11.02 208.08,10.87 211.45,10.87 212.4,11.81 218.14,11.81 220.1,9.86 223.56,9.86 225.78,12.08 230.9,12.08 232.25,13.43 232.25,13.76 232.76,14.27 234.49,14.27 236.37,16.15 237.28,16.15 237.92,16.78 241.93,16.78 243.25,18.1 243.25,19.24 244.49,20.49 244.49,23.13 245.71,24.35 245.71,26.26 v1(247.14,27.68) 247.14,27.91 247.64,28.41 v1(251.68,28.41)
  IN4 w0.381: v3(92.56,18.77) 92.08,18.77 91.15,17.85 90.24,17.85 90.21,17.82 90.19,17.82 v1(90.16,17.8)
  IN4 w0.508: v1(247.14,24.5) 246.42,24.5 245.38,25.54 244.29,25.54 242.64,27.19 239.08,27.19 v1(238.83,26.94) ; v1(26.81,46.67) 26.81,46.61 26.8,46.59 26.8,45.88 27.51,45.17 28.32,45.17 28.52,45.36 28.99,45.36 29.35,45 29.35,44.09 32.52,40.93 v1(32.52,39.37)
  BOTTOM w0.254: C513.1 33.46,159.85 33.85,160.24 CN8.11
  BOTTOM w0.305: R942.2 246.53,27.1 246.09,26.66 Q74.5 ; UG4.3 19.16,105.81 CG729.1 ; v1(247.14,24.5) 247.01,24.38 246.27,24.38 246.09,24.55 Q74.2
  BOTTOM w0.508: R942.2 246.86,27.68 v1(247.14,27.68) ; v1(239.37,20.2) 239.79,19.77 R1063.1 ; C520.1 33.67,158.84 33.46,159.05 C513.1 32.77,159.4 v1(32.74,159.37) ; Q79.1 94.14,18.91 v3(93.57,18.91) ; v1(247.14,24.5) 247.38,24.75 R964.2 ; R843.2 252.54,39.17 v1(252.72,38.98) ; v1(84.27,36.49) 84.27,36.5 84.34,36.57 84.34,36.79 84.87,37.32 84.87,37.88 83.68,39.08 83.68,40.05 84.16,40.54 84.16,41.04 84.55,41.43 v1(84.55,41.57) ; v1(242.28,21.45) 242.6,21.77 R1016.1 ; v1(178.71,16.55) 176.43,14.27 PR581.1 175.14,14.27 169.69,19.73 166.26,19.73 165.29,18.75 160.76,18.75 159.15,20.36 150.77,20.36 148.23,22.9 141.03,22.9 140.3,23.63 135.93,23.63 133.8,25.76 133.8,27.14 132.23,28.71 113.43,28.71 109.22,32.92 100.94,32.92 98.8,35.06 97.14,35.06 94.25,37.95 v1(94.25,38.42) ; v1(237.25,18.85) 237.27,18.83 R1064.1 ; RG139.1 18.28,102.54 18.28,103.22 v1(18.23,103.27) 18.23,104.18 18.48,104.44 18.48,105.13 CG729.1
  vias: v1(32.7,38.75) v1(37.73,37.63) v1(52.7,36.89) v1(53.19,36.47) v1(202.36,13.47) v1(202.61,12.87) v1(203.02,13.47) v1(203.35,12.87) v1(203.68,13.43) v1(220.49,12.11) v1(220.49,11.45) v1(221.15,12.11) v1(221.15,11.45) v1(233.55,13.53) v1(234.03,12.82) v1(238.96,53.33) v3(92.96,19.42) v3(93.16,18.28)
+3V_SSD1: length 1.9
  BOTTOM w0.508: R859.1 187.61,37.41 188.11,37.92 v1(189.1,37.92)
  vias: v1(192.68,35.02) v1(192.68,34.33) v1(193.41,34.99) v1(193.41,34.31) v1(194.65,31.63) v1(195.18,49.95) v1(195.18,49.19) v1(195.94,49.95) v1(195.94,49.19) v1(196.08,53.92) v1(196.06,53.25)
+3V_SSD2:
  vias: v1(191.92,11.09) v1(191.94,10.43) v1(191.94,9.77) v1(192.53,10.76) v1(193.5,23.65) v1(194.56,24.17) v1(194.56,23.51) v1(194.74,27.07) v1(195.32,24.17) v1(195.32,23.51) v1(195.47,27.09)
+3V_SUS: length 130.6
  TOP w0.508: v1(61.84,17.16) 62.42,17.74 L21.1
  IN1 w0.508: 194.3,10.67 195.78,10.67 197.16,9.29 203.65,9.29 204.29,9.92 205.83,9.92 206.47,9.29 234.02,9.29 235.16,10.43 243.71,10.43 245.05,11.78 v1(245.99,11.78) ; v1(61.84,17.16) 60.88,18.13 60.88,18.71 60.09,19.5 60.09,24.5 60.7,25.11 61.32,25.11 v1(61.59,25.39)
  IN3 w0.508: v1(245.99,11.78) 245.99,10.13 244.52,8.65 198.01,8.65 196.06,10.61 194.23,10.61
  IN4 w0.508: v1(61.59,25.39) 61.59,25.37 61.45,25.23 60.84,25.23 60.41,25.66 60.41,28.35 61.81,29.76 61.81,30.42 v1(62.53,31.13)
  BOTTOM w0.508: CN14.4 11.71,44 11.29,43.58 v1(11.29,43.09) ; v1(62.53,31.13) 62.32,30.92 L35.1
  vias: v1(10.43,41.7) v1(59.3,16.22) v1(193.13,9.57) v1(193.24,10.23) v1(246.64,11.75) v1(270.43,10.81) v1(271.1,10.98)
+3V_TYPEC_DP1: length 4.5
  TOP w0.508: R213.1 v1(244.24,41.47)
  IN1 w0.508: v1(244.24,41.47) 245.38,42.61 v1(245.38,44.19)
  BOTTOM w0.508: v1(244.24,41.47) 244.24,42.13 244.23,42.14
  vias: v1(240.1,44.59) v1(241.78,52.16) v1(241.75,51.5) v1(242.33,53.51) v1(242.36,51.76) v1(244.9,51.55) v1(245.66,51.63) v1(245.66,50.87)
+3V_U3: length 8.1
  TOP w0.178: v1(272.87,14.52) 273.24,14.52 273.81,13.95 U30.1
  TOP w0.381: v1(281.02,8.88) 281.45,8.45 R631.1
  BOTTOM w0.381: R1127.1 R1128.1 278.08,16.05 v1(278.53,16.5) ; v1(281.02,8.88) 281.02,8.87 R1144.2 281.57,8.1 282.39,7.28 283.11,7.28 R1143.2
  vias: v1(271.11,12.39) v1(278.17,9.59)
+3V_VCCSPI: length 1.8
  TOP w0.203: U14.AN44 224.7,29.84 v1(224.51,29.66)
  BOTTOM w0.305: v1(224.51,29.66) 224.64,29.66 225.1,30.13 R908.1
+3VPCU: length 577.1
  TOP w0.203: PR194.2 98.55,57.19 98.57,57.17 PR196.1 98.24,56.86 98.19,56.81 97.88,56.81 v1(97.71,56.63) ; v1(97.32,57.88) 97.5,58.07 97.5,58.48 97.71,58.69 PR182.1 ; v1(69.35,39.58) 69.49,39.44 69.49,38.42 R267.2 ; PR402.2 116.33,23.74 115.69,23.74 115.49,23.55 115.37,23.55
  TOP w0.254: CN5.7 227.11,13.6 v1(227.07,13.55) ; v1(225.19,13.53) 225.19,13.55 225.11,13.63 CN5.3
  TOP w0.381: v1(92.22,52.17) 92.04,52.17 91.15,51.28 89.53,51.28 v1(89.2,50.95)
  TOP w0.508: v1(93.22,58.75) 93.22,58.31 PR181.2 ; v1(188.72,64.3) 188.72,65.75 188.19,66.28 186.28,66.28 179.21,73.35 179.21,80.24 179.79,80.82 179.79,81.45 181.04,82.71 181.04,88.73 179.93,89.85 179.93,94.92 178.46,96.38 177.44,96.38 176.93,96.89 176.93,97.61 176.61,97.93 176.61,106.4 175.55,107.47 175.55,111.2 175.18,111.58 175.18,117.46 ; v1(87.99,40.37) 88.23,40.13 88.93,40.13 89.66,39.4 89.66,38.19 90.37,37.48 91.38,37.48 92.59,36.26 R286.2 92.59,35.59 93.05,35.13 93.93,35.13 94.1,35.29 v1(95.01,35.29) ; v1(88.29,53.77) 88.29,53.49 86.96,52.16 86.45,52.16 85.53,51.24 85.53,47.87 86.93,46.47 87.65,46.47 v1(88.17,46.99) 88.36,47.18 88.36,47.32 88.86,47.82 88.86,49.69 89.2,50.03 v1(89.2,50.95) ; R538.2 219.02,16.18 v1(219.02,15.71) ; R379.2 245.19,31.19 v1(245.54,31.54) ; v1(229.63,16.37) 230.03,16.77 230.03,16.79 R532.2 ; v1(233.19,15.03) 233.77,14.44 234.77,14.44 235.33,15.01 D58.2 ; v1(98.18,31.96) 98.18,29.37 97.55,28.74 97.02,28.74 96.51,28.24 v3(96.51,28.03) ; v1(113.4,22.27) 113.4,23.89 113.91,24.4 PR400.1 114.35,23.84 114.65,23.55 115.37,23.55 ; R623.2 v1(7.03,11.73)
  TOP w0.762: v1(9.95,30.98) 9.3,31.63 v1(9.3,31.69)
  TOP w1.016: v1(9.3,31.69) 9.3,35.73 10.16,36.59 PQ56.3
  IN1 w0.508: v1(238.14,54.27) 238.14,53 238.68,52.47 240,52.47 240.53,51.93 240.53,51.53 241.47,50.59 244.16,50.59 245.18,49.57 245.18,45.94 243.93,44.7 243.93,42.49 243.58,42.13 243.58,38.09 243.93,37.74 243.93,35.97 243.9,35.94 243.9,35.21 244.49,34.62 245.44,34.62 245.95,34.11 245.95,31.95 v1(245.54,31.54) ; v1(93.22,58.75) 93.25,58.73 95.23,58.73 95.23,58.73 95.67,58.73 96.52,57.88 v1(97.32,57.88) ; v1(78.92,21.39) 79.18,21.39 80.87,19.7 80.87,17.95 80.92,17.9 80.92,16.4 v1(82.49,14.82) ; v1(11.57,45.01) 12.31,45.75 16.27,45.75 16.69,46.17 19.5,46.17 20.39,45.28 20.51,45.28 v1(20.78,45.01)
  IN2 w0.508: 113.4,20.29 v1(113.4,22.27)
  IN3 w0.508: 10.48,44.2 10.48,42.21 11.37,41.32 11.74,41.32 12.17,40.9 12.17,40.62 11.1,39.55 11.1,37.42 9.3,35.61 v1(9.3,31.69) 9.3,31.49 9.81,30.98 v1(9.95,30.98) 9.95,30.47 8.65,29.17 8.65,27.23 9.7,26.18 9.7,20.01 9.01,19.32 8.38,19.32 7.41,18.36 7.41,13.1 7.03,12.72 v1(7.03,11.73) ; v1(42.38,168.55) 43.38,168.55 46.3,165.63 46.3,160.48 48.64,158.13 57.13,158.13 57.94,158.94 62.11,158.94 62.7,158.36 69.9,158.36 71.34,159.81 74.11,159.81 75.24,158.68 87.43,158.68 88.86,160.11 96.2,160.11 97.43,158.88 97.43,156.08 97.76,155.75 97.76,154.45 98.06,154.15 98.06,151.4 94.89,148.23 94.89,145.86 96.84,143.91 96.84,136.72 101.84,131.72 101.84,101.8 105.5,98.14 105.5,97.48 107.05,95.93 108.85,95.93 110.48,94.3 110.48,88.48 107.66,85.66 107.66,76.95 108.45,76.16 108.45,73.57 107.38,72.5 106.49,72.5 106.32,72.33 105.37,72.33 105,72.71 101.29,72.71 98.6,70.02 98.6,67.45 96.62,65.48 96.62,65.06 95.01,63.45 95.01,62.41 94.79,62.19 94.79,59.67 93.88,58.75 v1(93.22,58.75)
  IN4 w0.305: v1(83.2,42.7) 82.73,42.23 82.73,41.97 81.04,40.28 78.53,40.28 77.51,39.26 76.19,39.26 75.74,38.8 73.49,38.8 73.09,39.21 70.91,39.21 70.66,38.96 69.65,38.96 69.35,39.27 v1(69.35,39.58)
  IN4 w0.508: v1(20.78,45.01) 21.26,45.01 21.82,45.57 25.38,45.57 28.03,42.92 28.03,42.26 28.53,41.75 29.97,41.75 31.03,40.7 31.03,37.64 31.53,37.13 34.92,37.13 36.89,39.1 43.23,39.1 45.1,40.98 47.62,40.98 48.28,41.64 48.83,41.64 49.32,42.13 49.32,44.14 48.68,44.77 47.91,44.77 47.6,45.08 47.6,48.21 48.2,48.81 48.2,49.32 47.85,49.67 47.47,49.67 47.16,49.99 47.16,50.97 47.9,51.71 49.98,51.71 51.17,50.52 53.03,50.52 54.1,51.6 55.16,51.6 55.78,52.21 57.09,52.21 58.82,53.94 59.66,53.94 60.24,53.36 66.52,53.36 67,53.84 69.46,53.84 70.99,52.32 73.66,52.32 v1(74.35,53) 74.35,53.48 75.75,54.88 79.8,54.88 80.3,54.38 84.27,54.38 84.68,54.78 86.73,54.78 87.74,53.77 v1(88.29,53.77) 88.29,53.96 88.8,54.47 90.18,54.47 90.83,55.11 90.83,57.44 91.7,58.31 92.47,58.31 92.68,58.51 92.98,58.51 v1(93.22,58.75) ; v1(42.38,168.55) 41.01,168.55 38.82,166.36 38.82,162.34 38.17,161.69 29.84,161.69 v1(28.85,162.68)
  BOTTOM w0.203: v1(92.22,52.17) 92.61,52.17 92.75,52.03 PR507.2 92.75,51.07 ; v1(74.35,53) 74.31,52.96 74.31,52.71 PR503.2 ; PR529.1 28.14,45.25 27.68,45.25
  BOTTOM w0.254: C905.1 78.75,20.45 78.15,19.85 CN19.22
  BOTTOM w0.305: CN8.1 v1(28.85,162.68)
  BOTTOM w0.381: 92.75,51.07 93.14,50.68 93.17,50.68 93.23,50.62 93.71,50.62 93.77,50.68 95.24,50.68 95.94,51.38 PQ53.1
  BOTTOM w0.508: C905.1 78.9,20.89 78.9,21.16 78.92,21.18 v1(78.92,21.39) 79.03,21.5 79.03,21.62 79.18,21.78 C895.1 ; C496.1 25.55,168.52 25.2,168.17 C497.1 25.95,167.11 26.67,167.11 28.85,164.94 v1(28.85,162.68) ; v1(89.2,50.95) 89.2,51.19 89.62,51.61 PQ52.1 ; v1(95.01,35.29) 95.01,35.17 97.06,33.12 97.82,33.12 98.18,32.77 v1(98.18,31.96) ; v1(227.07,13.55) 227.34,13.83 EC12.2 ; 27.68,45.25 27.04,45.25 26.31,45.99 25.11,45.99 24.88,46.22 22.31,46.22 21.49,45.41 21.18,45.41 v1(20.78,45.01) ; v1(225.19,13.53) 225.55,13.89 C927.2
  vias: v1(9.61,79.59) v1(10.93,45.08) v1(13.51,81.07) v1(13.51,80.41) v1(13.51,79.75) v1(13.51,79.09) v1(83.18,14.85) v1(84.25,15.31) v1(84.8,14.95) v1(106.53,23.9) v1(171.22,29.76) v1(174.55,26.69) v1(174.57,26.04) v1(175.22,26.7) v1(175.24,26.04) v1(187.31,65.15) v1(187.99,65.25) v1(188.03,64.58) v1(190.16,13.4) v1(190.16,12.74) v1(237.76,54.91) v1(238.52,54.91) v1(273.22,51.2) v1(273.93,51.2) v1(280.56,58.97) v1(281.32,58.97) v3(94.28,28.43) v3(95.04,28.43) v3(95.68,27.35) v3(95.75,28.11) v3(96.11,22.5) v3(96.13,21.75) v3(96.13,21) v3(96.13,20.23) v3(96.37,23.2) v3(96.49,27.27) v3(96.86,22.5) v3(96.89,21) v3(96.89,20.23) v3(96.91,21.76) v3(97.14,23.2) v3(97.61,22.53) v3(97.66,21.78) v3(97.67,21) v3(97.66,20.23) v3(98.36,22.53) v3(98.42,21.78) v3(98.42,21) v3(98.42,20.23)
+3VPCU_EC: length 79.9
  TOP w0.203: U18.50 77.83,20.58 78.2,20.95 78.2,21.38 v1(78.25,21.43) ; U18.114 76.63,35.96 77.09,36.41 v1(77.09,36.66) 77.11,36.68 C258.1 ; U18.26 68.54,23.42 68.34,23.22 68.34,23.21 ; 86.66,31.87 86.18,31.87 86.13,31.82 U18.92
  TOP w0.305: C415.1 67.02,22.17 v1(67.3,22.45) 67.73,22.45 68.34,23.07 68.34,23.21 ; v1(69.92,36.59) 70.06,36.73 70.06,37.35 L4.2 ; R356.2 88.52,31.76 C333.1 88.03,31.99 v1(87.76,32.26) C332.1 86.89,31.76 86.79,31.87 86.66,31.87 ; v1(89.1,25.44) 89.08,25.46 88.72,25.46 L14.1
  IN1 w0.305: v1(67.3,22.45) 67.48,22.28 71.51,22.28 74.11,19.68 76.78,19.68 78.2,21.1 78.2,21.38 v1(78.25,21.43)
  IN4 w0.305: v1(89.1,25.44) 89.09,25.44 89.02,25.37 88.89,25.37 88.13,24.6 86.89,24.6 84.4,22.11 82.7,22.11 82.06,22.75 80.59,22.75 79.62,21.78 79.62,21.07 79.19,20.64 78.76,20.64 78.25,21.15 v1(78.25,21.43)
  BOTTOM w0.305: v1(87.76,32.26) 87.76,29.71 88.32,29.15 88.64,29.15 88.95,28.84 88.95,28.31 89.11,28.15 89.11,25.46 89.1,25.45 v1(89.1,25.44) ; v1(78.25,21.43) 78.25,22.03 C890.1 ; v1(69.92,36.59) 69.92,36.26 70.27,35.91 73.25,35.91 v1(73.83,36.5) 74.7,37.36 76.49,37.36 77.09,36.77 v1(77.09,36.66) 77.09,36.5 74.84,34.26 70.95,34.26 69.91,33.22 69.91,25.1 68.94,24.13 68.64,24.13 68.05,23.54 67.68,23.54 67.38,23.23 67.38,22.53 v1(67.3,22.45)
+3VS5_HDMI: length 12.9
  TOP w0.508: R16.1 63.06,160.1 62.37,160.1 62.07,160.4 v1(62.07,160.82)
  IN3 w0.508: v1(71.77,162.7) 69.18,160.1 62.58,160.1 62.07,160.61 v1(62.07,160.82)
+5V: length 353.2
  TOP w0.203: v1(39.41,36.97) 39.69,37.25 PR341.2
  TOP w0.762: R459.1 41.25,22.21 42.39,22.21 43.63,23.45 v3(43.63,24.04)
  TOP w1.016: v1(188.99,69.45) 188.99,69.14 189.29,68.83 189.29,67.41 192.7,64 193.39,64 193.98,63.41 194.87,63.41 ; v1(210.58,62.37) 210.42,62.21 208.34,62.21 206.77,63.77 202.49,63.77 202.13,63.41 197.36,63.41
  IN2 w0.508: v1(88.33,45.91) 86.67,44.25 84.92,44.25 84.48,44.7 83.4,44.7 80.07,41.37 74.77,41.37 73.86,42.28 v1(73.86,43.07)
  IN3 w0.508: v1(73.27,160.7) 74.09,161.51 78.81,161.51 80.41,163.11 81.6,163.11 83.28,161.43 84.96,161.43 85.48,160.91 87.03,160.91 87.46,161.33 87.85,161.33 88.16,161.63 88.16,162.22 88.66,162.73 94.51,162.73 96.25,164.48 99.59,164.48 103.4,160.67 105.28,160.67 105.71,160.24 105.71,156.86 104.62,155.77 104.62,152.31 105.91,151.02 105.91,148.15 106.56,147.51 106.56,144.25 107.03,143.78 107.03,141.93 107.82,141.14 107.82,138.84 107.09,138.11 107.09,136.27 104.78,133.95 104.78,125.23 105.58,124.43 105.58,109.2 105.3,108.92 105.3,103.53 108.98,99.86 109.6,99.86 115.41,94.04 115.41,74.26 112.41,71.26 v1(112.41,70.27) 111.8,69.66 107.67,69.66 104.21,66.2 103.41,66.2 101.23,64.03 101.23,63.04 99.26,61.06 99.26,59.63 98.19,58.56 96.79,58.56 96.18,57.95 96.18,57.57 95.68,57.06 94.82,57.06 92.86,55.11 92.31,55.11 91.1,53.89 91.1,53.69 89.62,52.21 88.81,52.21 86.35,49.75 86.35,46.73 87.17,45.91 v1(88.33,45.91)
  IN4 w0.508: v1(71.8,31.93) 71.64,31.77 69.6,31.77 67.2,34.18 67.2,36.64 67.81,37.25 67.81,38.73 67.35,39.18 67.35,40.61 68.6,41.85 73.09,41.85 73.86,42.61 v1(73.86,43.07)
  BOTTOM w0.508: v1(195.9,62.81) 195.93,62.78 R728.1 ; v1(210.58,62.37) 210.58,60.97 213.83,57.73 v1(213.83,55.89) 214.81,54.91 PR496.1 ; v1(10.71,49.85) 12.21,49.85 12.6,50.24 R734.1 ; R1039.1 22.29,19.31 R1038.1 21.13,19.13 21.13,17.83 21.43,17.52 23.26,17.52 23.53,17.25 v1(23.53,16.09) ; v1(13.78,22.1) 13.73,22.16 R999.1 R982.1 ; U35.3 72.43,161.54 v1(73.27,160.7) ; PR561.2 72.11,29.61 71.31,30.41 71.31,31.44 v1(71.8,31.93)
  BOTTOM w1.016: v1(112.41,70.27) 164.47,70.27 168.38,74.18 179.17,74.18 183.9,69.45 185.24,69.45 185.44,69.26 188.15,69.26 188.34,69.45 v1(188.99,69.45)
  vias: v1(10.36,24.22) v1(10.36,23.56) v1(14.22,61.92) v1(14.24,61.26) v1(15.72,40.94) v1(23.53,15.45) v1(24.3,35.88) v1(24.66,36.44) v1(24.96,35.81) v1(25.34,36.41) v1(30.26,16.13) v1(49.93,25.29) v1(50.59,25.29) v3(71.19,27.45) v3(71.22,28.2) v3(71.21,26.71) v3(71.22,25.96) v3(71.98,26.89)
+5V_HDD:
  vias: v1(32.67,16.24) v1(33.29,16.48) v1(33.82,16.08) v1(34.36,16.49) v1(38.64,18.87) v1(39.33,18.89) v1(39.98,18.86)
+5V_HDMIC: length 25.3
  TOP w0.508: v1(62.19,162.48) 61.84,162.13 v1(59.92,162.13) R11.1 R10.1 ; CN1.18 68.11,168.6 69.15,167.56 71.17,167.56 v1(71.6,167.13) v1(72.07,166.67)
  IN3 w0.508: v1(62.19,162.48) 63.74,162.48 64.59,161.63 68.14,161.63 68.44,161.93 69.85,161.93 v1(69.86,161.95)
  BOTTOM w0.508: v1(69.86,161.95) 70.05,162.13 U35.1 71.26,163.87 C502.1 71.26,164.39 72.07,165.21 RV2.1 v1(72.07,166.67)
+5V_KB_M:
  vias: v1(75.19,21.35) v1(75.84,21.35) v1(85.97,20.13) v1(86.33,17.72) v1(86.44,20.58) v1(86.48,17.06) v1(87.96,21.59)
+5V_MCU: length 126.1
  TOP w0.508: v1(64.26,13.63) 64.52,13.38 R596.1 64.91,13.96 64.77,14.1 Q45.1 ; Q23.1 8.69,55.38 8.69,56.06 9.25,56.61 v1(9.5,56.61) ; Q50.1 70.68,13.23 70.81,13.37 R588.1 v1(71.27,12.72)
  IN1 w0.508: v1(64.26,13.63) 63.23,13.63 62.5,14.37 59.48,14.37 59.35,14.24 54.96,14.24 53.28,15.92 51.94,15.92 51.56,16.3 ; v1(65.7,18.1) 65.2,17.59 65.2,14.57 v1(66.41,13.35) 68.12,13.35 68.75,12.72 v1(71.27,12.72)
  IN2 w0.508: v1(9.5,56.61) 9.85,56.61 11.45,55.01 12.12,55.01 12.73,54.4 15.02,54.4 16.25,53.17 16.25,45.28 16,45.03 16,42.61 20.7,37.91 20.7,37.33 24.78,33.24 25.06,33.24 25.74,32.56 28.09,32.56 28.59,32.05 28.59,31.52 29.1,31.01 35.23,31.01 35.59,30.66 36.13,30.66 36.5,31.03 37.3,31.03 38.37,29.96 39.21,29.96 40.35,28.82 41.22,28.82 41.6,28.44 42.41,28.44 43.27,27.58 44.54,27.58 45.05,27.07 45.05,24.15 42.18,21.28 v1(42.11,21.28)
  IN4 w0.508: v1(9.5,56.61) 9.93,56.61 10.64,57.31 10.64,66.01 v1(11.58,66.95) ; v1(51.06,17.43) 50.33,16.7 49.02,16.7 47.53,18.19 42.93,18.19 42.11,19.02 v1(42.11,21.28)
  BOTTOM w0.508: v1(65.7,18.1) 65.7,18.38 66.59,19.27 66.59,19.8 68.47,21.68 69.36,21.68 69.9,22.23 Q76.1 ; v1(66.41,13.35) 64.54,13.35 v1(64.26,13.63)
  vias: v1(11.45,64.84)
