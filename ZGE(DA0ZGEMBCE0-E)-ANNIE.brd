# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_VREF_CTL: length 196.2
  TOP w0.102: 35.99,98.62 36.22,98.39 37.99,98.39 38.35,98.75 UG1.BD3
  TOP w0.381: QG2.2 93.57,134.41 93.19,134.79 86.03,134.79 85.63,135.19 v1(84.85,135.19) QG1.2 ; RG20.2 v1(33.2,99.39) 33.74,98.84 35.77,98.84 35.99,98.62
  IN2 w0.381: v1(84.85,135.19) 84.61,135.19 83.97,135.83 83.97,137.3 85.69,139.03 85.69,148.5 85,149.19 85,150.54 85.82,151.35 85.82,154.98 84.54,156.26 80.84,156.26 79.44,157.66 77.5,157.66 76.79,158.38 70.44,158.38 68.74,156.67 64.56,156.67 64.02,157.2 61.65,157.2 61.16,157.7 60.62,157.7 60.45,157.53 58.5,157.53 58.05,157.98 55.49,157.98 55.35,157.84 49.64,157.84 48.59,156.79 45.4,156.79 44.08,158.11 42.17,158.11 41.77,158.5 39.2,158.5 38.82,158.12 36.65,158.12 35.73,157.21 31.27,157.21 30.95,156.89 28.2,156.89 27.95,156.63 26.16,156.63 25.77,156.25 23.77,156.25 22.95,155.43 22.95,154.29 20.5,151.84 20.5,150.07 21.08,149.48 v1(21.27,149.48) 20.12,148.32 20.12,148.03 17.54,145.46 14.75,145.46 12.72,143.42 12.72,139.37 11.55,138.2 11.55,137.65 10.62,136.73 10.62,136.2 9.98,135.55 9.14,135.55 8.48,134.89 8.48,131.18 8.82,130.84 8.82,129.29 9.14,128.97 9.14,113.15 8.83,112.84 8.83,108.55 8.96,108.42 8.96,106.16 10.13,104.99 v1(11.52,104.99) 11.65,104.87 13.99,104.87 14.73,104.14 18.63,104.14 18.92,103.85 23.36,103.85 25.41,101.81 29.5,101.81 29.86,101.45 31.76,101.45 33.2,100.02 v1(33.2,99.39)
  BOTTOM w0.381: QG19.2 13.47,104.29 12.77,104.99 v1(11.52,104.99) ; QG17.2 21.21,149.42 v1(21.27,149.48)
MEM_VREF_CTL_QA: length 2.3
  TOP w0.381: RG3.1 91.27,133.2 92.49,131.98 QG2.3
MEM_VREF_CTL_QB: length 2
  TOP w0.381: RG4.1 84.22,132.25 v1(83.91,132.55) 83.58,132.89 QG1.3
MEM_VREF_CTL_QC: length 3.1
  BOTTOM w0.254: RG96.1 23.76,147.75 v4(23.51,148) 23.45,147.93 22.9,147.93 QG17.3
MEM_VREF_CTL_QD: length 1.3
  BOTTOM w0.254: RG126.1 15.83,105.23 QG19.3
MIC1-L: length 24.5
  TOP w0.203: U17.31 29.21,25.36 v1(29.38,25.19)
  IN2 w0.254: v1(12.7,16.2) 13.56,16.2 17.74,20.39 22.04,20.39 23.04,21.39 28.77,21.39 29.56,22.17 29.56,25.01 v1(29.38,25.19)
  BOTTOM w0.254: v1(12.7,16.2) 12.61,16.2 12.4,16 CN17.5
MIC1-R: length 23.3
  TOP w0.203: v1(28.64,25.01) 28.81,25.17 U17.30
  IN2 w0.254: v1(12.8,16.87) 13.14,16.87 17.43,21.15 21.72,21.15 22.72,22.15 28.46,22.15 28.8,22.49 28.8,24.86 v1(28.64,25.01)
  BOTTOM w0.254: v1(12.8,16.87) 12.55,16.87 12.19,16.5 CN17.6
MIC1-VREFO-L: length 28.2
  TOP w0.203: U17.18 26.71,31.16 26.59,31.28 25.82,31.28 v1(25.72,31.19)
  IN1 w0.254: v1(13.3,17.8) 14.7,17.8 18.05,21.15 18.05,22.72 21.28,25.96 26.07,25.96 27.73,27.62 27.73,30.06 26.49,31.31 25.85,31.31 v1(25.72,31.19)
  BOTTOM w0.254: CN17.7 12.13,17 12.5,17.37 13,17.37 13.3,17.67 v1(13.3,17.8)
MIC1-VREFO-R: length 24.9
  TOP w0.203: v1(26.28,30.83) 26.35,30.76 U17.19
  IN1 w0.254: v1(26.28,30.83) 26.28,30.42 26.97,29.73 26.97,27.93 25.75,26.72 20.97,26.72 17.29,23.04 17.29,21.47 14.38,18.56 13.07,18.56 12.63,18.11 v1(12.63,17.86)
  BOTTOM w0.254: v1(12.63,17.86) 12.62,17.86 12.45,17.86 12.09,17.5 CN17.8
MIC-JD: length 30.9
  TOP w0.254: v1(37.08,28.64) 37.24,28.8 R373.2
  IN2 w0.254: v1(37.08,28.64) 36.7,28.26 36.7,27.68 35.72,26.7 34.12,26.7 33.55,26.13 27.91,26.13 24.69,22.91 22.2,22.91 21.86,22.57 17.77,22.57 14.24,19.04 v1(13.89,19.04)
  BOTTOM w0.254: v1(13.89,19.04) 13.12,19.04 12.08,18 CN17.9
MIC_VCC: length 11.8
  TOP w0.203: v1(176.14,131.36) 175.79,131.72 C52.2 175.52,131.99 175.17,131.63 C51.2
  TOP w0.508: v1(178.58,132.6) 178.68,132.71 R40.2
  IN1 w0.508: v1(176.14,131.36) 175.85,131.65 v1(171.86,131.65)
  BOTTOM w0.508: v1(176.14,131.36) 177.54,131.36 178.58,132.4 v1(178.58,132.6) ; 173.04,130.34 171.86,131.52 v1(171.86,131.65)
MKB_INT#: length 12.9
  TOP w0.14: v1(86.34,25.23) 86.15,25.42 U18.76 ; Q39.1 89.84,18.99 90.8,18.99 v1(91,18.79) 91.36,18.43 R510.1
  IN1 w0.086: v1(91,18.79) 89.93,18.79 88.06,20.67 88.06,23.51 v1(86.34,25.23)
MKB_INT#_R: length 15.6
  TOP w0.14: R509.1 88.07,17.5 D57.1 88.94,17.31 v1(89.2,17.06) 89.79,17.06 Q39.3
  BOTTOM w0.14: v1(89.2,17.06) 89.3,17.06 89.68,16.68 89.68,15.41 88.87,14.6 86.23,14.6 83.76,17.06 83.31,17.06 81.65,18.72 CN19.15
MKB_PWR_EN: length 42
  TOP w0.14: R367.1 65.46,29.87 v1(65.82,29.51)
  IN1 w0.086: v1(92.07,29) 91.56,29 90.99,28.43 88.8,28.43 88.58,28.21 86.6,28.21 86.45,28.05 85.13,28.05 83.52,29.66 82.4,29.66 82.05,30.01 78.07,30.01 76.36,28.3 73.75,28.3 72.47,27.01 72.47,25.89 71.33,24.76 66.59,24.76 65.88,25.47 65.88,26.71 67.02,27.85 67.02,28.47 65.98,29.51 v1(65.82,29.51)
  BOTTOM w0.14: Q77.2 95.92,26.24 R1158.2 94.42,27.74 93.33,27.74 v1(92.07,29)
MODE: length 1.2
  TOP w0.14: R559.2 277.22,14.92 277.27,14.87 U30.30
MODEM_CLKREQ: length 155.8
  TOP w0.14: Q35.6 192.93,20.24 192.85,20.16 R468.1 192.31,19.77 191.9,19.35 v1(191.69,19.35)
  IN3 w0.089: v1(51.85,37.06) 52.09,37.29 53.34,37.29 54.01,36.63 57.05,36.63 58.98,34.7 62.67,34.7 62.96,34.99 64.93,34.99 65.28,34.64 67.63,34.64 67.69,34.57 68.37,34.57 68.39,34.56 68.4,34.56 68.68,34.27 71.18,34.27 71.71,33.75 74.41,33.75 74.61,33.55 75.47,33.55 76.77,32.25 77.59,32.25 78.64,31.2 79.9,31.2 80.52,30.58 82.62,30.58 83.07,30.12 84.31,30.12 85.2,29.24 91.65,29.24 92.21,29.8 95.59,29.8 95.82,29.57 100.2,29.57 100.78,30.16 100.78,30.73 101.4,31.35 110.16,31.35 111.04,30.47 148.91,30.47 149.22,30.16 167.08,30.16 167.58,29.65 175.53,29.65 177.2,27.99 178.52,27.99 180.38,26.12 182.8,26.12 183.21,25.71 186.52,25.71 187.95,24.28 187.95,24.02 188.76,23.22 188.76,21.9 191,19.65 191.43,19.65 191.69,19.4 v1(191.69,19.35)
  BOTTOM w0.14: v1(51.85,37.06) 51.85,36.41 51.45,36 CN16.14
MODEM_CLKREQ_C: length 43.2
  TOP w0.14: v1(212.41,26.12) 211.8,26.12 U14.BA17 ; Q35.5 193,20.74 192.86,20.88 192.86,21.08 R447.1 192.31,20.91 v1(192.39,20.83)
  IN1 w0.086: v1(192.39,20.83) 189.83,18.28 189.83,16.68 191.93,14.59 202.27,14.59 204.42,16.74 206.62,16.74 207.25,16.11 207.25,15.46 207.58,15.13 209.16,15.13 209.44,15.41 209.44,19.98 212.31,22.85 212.31,23.12 212.7,23.51 212.7,25.86 212.43,26.12 v1(212.41,26.12)
MPHY_EXT_PWR_GATE: length 15.2
  TOP w0.14: U14.AP29 216.62,28.64 v1(216.55,28.64)
  BOTTOM w0.102: 214.42,24.09 214.19,24.32 214.19,24.68 214.53,25.02 214.53,26.1 214.94,26.51 214.94,27.1 216.48,28.64 v1(216.55,28.64)
  BOTTOM w0.14: 214.42,24.09 215.09,23.43 TP111.1 215.29,23.03 215.03,22.78 215.03,21.22 215.96,20.29 215.96,19.15 216.31,18.8 216.31,18.09 215.49,17.27 R1097.1
NB_FGC6: length 47.1
  TOP w0.102: v2(39.41,97.65) 39.41,97.71 39.5,97.8 UG1.BE5
  IN1 w0.086: v1(35.63,86.1) 35.96,85.77 35.96,84.68 36.89,83.76 40.07,83.76 41.75,82.08 47.55,82.08 48.51,81.11 48.51,80.5 45.48,77.47 40.42,77.47 40.16,77.73 40.16,77.92 39.89,78.19 39.17,78.19 v1(38.88,77.89)
  IN4 w0.086: v1(35.63,86.1) 35.63,86.27 36.61,87.25 36.61,89.17 34.73,91.05 34.73,92.61 34.04,93.3 34.04,93.79 37.9,97.65 v2(39.41,97.65)
  BOTTOM w0.14: v2(39.41,97.65) 39.36,97.7 RG151.2 ; v1(38.88,77.89) 38.75,78.02 38.75,78.91 38.88,79.04 39.16,79.32 UG11.2
NBSWON#: length 426.4
  TOP w0.14: v1(81.17,21.64) 80.72,21.64 80.2,22.16 80.2,23.65 78.99,24.86 78.99,27 78.89,27.09 78.89,29.06 79.25,29.42 79.25,30.95 79.59,31.28 79.59,33.66 79.43,33.81 U18.107 79.43,35.82 79.69,36.07 79.69,37.51 79.88,37.7 79.88,38.32 80.25,38.7 80.25,38.94 v1(80.27,38.95) 80.27,38.99 79.98,39.28 R240.1 ; SW1.1 85.18,37.17 C254.2 85.18,37.82 84.85,38.14 R261.1 85.38,38.3 SW1.2 86.27,39.19 v1(86.27,40.07) ; v1(229.11,13.2) CN5.11
  IN2 w0.089: v1(86.27,40.07) 86.47,40.28 87.48,40.28 87.83,39.93 88.18,39.93 88.85,40.6 88.85,44.76 89.57,45.49 89.57,46.11 91.67,48.21 95.33,48.21 95.94,47.59 96.31,47.59 97.47,46.44 98.19,46.44 98.68,46.93 98.68,47.77 97.16,49.29 96.57,49.29 96.13,49.73 96.13,51.43 97.08,52.39 97.42,52.39 97.76,52.73 97.76,55.85 98.42,56.52 98.42,57.51 99.23,58.31 99.23,66.79 100.17,67.73 100.17,71.39 102.27,73.49 102.27,73.89 103.4,75.03 103.4,75.55 104.29,76.44 104.29,77.47 107.35,80.52 107.35,83.13 107.96,83.73 107.96,86.7 108.38,87.12 108.38,88.77 107.32,89.83 105.9,89.83 105.58,90.15 105.58,92.68 105.7,92.8 105.7,97.18 107,98.48 107,110.06 107.98,111.04 107.98,124.98 109.06,126.06 109.06,131.21 108.4,131.88 108.4,144.99 106.28,147.11 106.28,150.15 104.55,151.87 104.55,155.89 106.28,157.62 106.28,160.02 105.28,161.02 99.24,161.02 98.99,161.27 98.38,161.27 98.19,161.08 97.6,161.08 97.4,161.27 93.5,161.27 92.71,162.06 92.71,162.41 91.99,163.13 88.71,163.13 88.13,163.71 78.21,163.71 77.39,164.52 71.47,164.52 69.95,163.01 68.81,163.01 68.49,162.69 68.49,162.41 67.44,161.36 64.14,161.36 62.03,163.47 60.62,163.47 59.91,162.76 55.4,162.76 54.49,161.84 49.67,161.84 48.66,162.86 41.14,162.86 40.63,162.35 v1(39.64,162.35)
  IN3 w0.089: v1(229.11,13.2) 228.48,12.56 225.42,12.56 224.28,11.42 222.22,11.42 221.45,10.65 219.87,10.65 218.31,12.21 210.38,12.21 209.44,11.27 208.25,11.27 208.1,11.42 206.43,11.42 206.09,11.08 203.63,11.08 203,10.45 199.87,10.45 197.66,12.66 195.97,12.66 195.39,13.23 191.03,13.23 190.11,14.16 189.9,14.16 185.15,18.91 183.52,18.91 183.04,19.39 178.41,19.39 177.48,18.46 175.81,18.46 174.82,19.45 171.67,19.45 171.47,19.26 166.11,19.26 165.44,18.58 160.04,18.58 158.8,19.82 151.4,19.82 148.79,22.42 144.45,22.42 144.09,22.06 134,22.06 131.48,19.55 118.11,19.55 115.97,21.69 115.97,22.3 114.69,23.59 111.51,23.59 111.01,24.09 104.64,24.09 101,20.45 101,19.37 99.3,17.67 96.01,17.67 93.8,19.88 92.08,19.88 91.44,19.24 89.11,19.24 88.73,18.86 84.58,18.86 83.6,19.84 82.07,19.84 81.17,20.74 v1(81.17,21.64) ; v1(86.27,40.07) 86.02,40.33 81.78,40.33 80.4,38.95 v1(80.27,38.95)
  BOTTOM w0.14: R645.1 42.38,159.57 41.99,159.18 41.99,158.99 42.28,158.69 D87.1 42.67,158.91 43.19,159.43 C514.1 43.19,160.47 42.42,161.25 41,161.25 39.9,162.35 v1(39.64,162.35)
NGFF1_DET1: length 68
  TOP w0.14: v1(224.8,32.65) 224.78,32.63 224.78,32.5 224.38,32.1 U14.AJ43
  IN3 w0.089: v1(224.8,32.65) 224.76,32.65 224.45,32.33 221.3,32.33 220.94,31.98 219.4,31.98 218.72,32.66 214.24,32.66 213.09,33.81 211.78,33.81 211.44,33.47 210.15,33.47 209.9,33.72 204.91,33.72 204.54,33.35 203.14,33.35 202.7,32.9 199.82,32.9 195.37,37.35 193.24,37.35 190.85,39.74 189.76,40.83 188.36,40.83 187.99,40.47 187.99,40.33 187.9,40.24 v1(183.89,40.24)
  BOTTOM w0.14: v1(224.8,32.65) 224.92,32.53 225.93,32.53 226.46,33.06 226.46,33.64 v1(227.02,34.21) 227.2,34.38 227.2,35.26 R877.2 228.04,35.79 228.43,36.18 229.77,36.18 230.22,35.73 231.6,35.73 231.83,35.96 232.32,35.96 R875.1 ; v1(183.89,40.24) 182.81,39.16 182.26,39.16 182.01,38.9 182.01,38.85 182.01,38.85 182.01,38.47 182.01,38.46 182.01,37.25 183.03,36.24 184.65,36.24 R860.1 185.59,36.31 185.71,36.19 Q72.3
NGFF1_PEDET1: length 7.5
  BOTTOM w0.14: R848.2 186.83,38.38 R859.2 R860.2 186.04,36.77 186.74,36.08 Q72.2 187.09,35.83 187.76,35.17 188.16,35.17 188.43,35.44 188.43,35.82 188.62,36 CN15.69
NGFF1_RST#: length 4.9
  TOP w0.14: v1(194.79,42.71) 194.79,42.96 194.19,43.56 R201.1
  BOTTOM w0.14: CN15.50 195.98,40.75 194.79,41.94 v1(194.79,42.71)
NGFF2_DET2: length 18.8
  TOP w0.102: 230.96,31.33 230.29,31.33 230.19,31.43 227.28,31.43 226.57,30.72 226.15,30.72 225.92,30.48 U14.AM46
  TOP w0.14: R256.1 233.52,38.5 234.38,38.5 234.64,38.24 234.64,37.78 234.05,37.19 234.05,36.02 234.97,35.09 235.44,35.09 v1(235.91,34.62) 235.91,33.89 R334.2 235.64,33.47 234.49,32.33 234.25,32.33 233.94,32.02 232.58,32.02 231.9,31.33 230.96,31.33
NGFF2_RST#: length 11.8
  TOP w0.14: R609.1 206.06,11.94 205.69,12.31 v1(205.69,12.74)
  IN3 w0.089: v1(200.75,12.67) 200.96,12.46 205.4,12.46 v1(205.69,12.74)
  BOTTOM w0.14: CN18.50 198.61,15.7 v1(200.32,13.99) 200.75,13.56 v1(200.75,12.67)
NV_USB2_D_N: length 98.9
  TOP w0.102: U14.H3 204.43,42.57 203.47,42.57 203.36,42.46 202.28,42.46 202.08,42.26 201.53,42.26 201.42,42.37 201.42,42.51 v1(201.63,42.71)
  TOP w0.14: U16.11 271.83,31.64 271.69,31.51 271.49,31.51 271.19,31.21 271.19,31 270.86,30.67 270.73,30.67 270.56,30.85 v1(270.56,30.87)
  IN3 w0.089: v1(270.56,30.87) 270.31,30.62 269.85,30.62 269.14,29.91 264.74,29.91 264.02,30.63 260.02,30.63 259.58,30.19 258.77,30.19 256.74,32.22 256.74,36.19 253.33,39.59 252.11,39.59 250.4,37.88 247.64,37.88 246.6,36.83 243.31,36.83 242.79,36.31 241.22,36.31 240.68,36.85 239.93,36.85 239.55,36.47 238.5,36.47 237.58,37.39 235.83,37.39 234.7,36.26 226.43,36.26 225.52,35.35 221.91,35.35 219.45,37.81 219.12,37.81 218.71,38.22 215.28,38.22 214.76,38.74 212.46,38.74 211.79,38.08 207.79,38.08 207.2,38.66 205.54,38.66 204.38,37.5 204.38,37.11 203.49,36.23 203.49,35.73 203.24,35.48 201.4,35.48 199.93,36.95 199.93,38.54 199.69,38.78 199.69,41.24 199.92,41.47 201.16,41.47 201.4,41.71 201.4,42.34 201.4,42.47 v1(201.63,42.71)
NV_USB2_D_P: length 98.9
  TOP w0.102: U14.H2 204.13,42.36 203.55,42.36 203.45,42.26 202.36,42.26 202.16,42.05 201.45,42.05 201.21,42.29 201.21,42.44 v1(200.96,42.69)
  TOP w0.14: v1(270.55,30.19) 270.77,30.41 270.97,30.41 271.46,30.89 271.46,31.1 271.6,31.24 U16.12
  IN3 w0.089: v1(200.96,42.69) 201.21,42.46 201.21,42.34 201.21,41.79 201.08,41.66 199.84,41.66 199.5,41.32 199.5,38.7 199.74,38.46 199.74,36.87 201.32,35.29 203.32,35.29 203.68,35.65 203.68,36.15 204.57,37.03 204.57,37.42 205.62,38.47 207.12,38.47 207.71,37.88 211.87,37.88 212.54,38.55 214.68,38.55 215.2,38.03 218.63,38.03 219.04,37.62 219.37,37.62 221.83,35.16 225.6,35.16 226.51,36.07 234.78,36.07 235.9,37.2 237.51,37.2 238.42,36.28 239.63,36.28 240.01,36.66 240.6,36.66 241.14,36.12 242.87,36.12 243.39,36.64 246.68,36.64 247.72,37.68 250.48,37.68 252.19,39.4 253.25,39.4 256.55,36.11 256.55,32.14 258.69,30 259.66,30 260.1,30.44 263.94,30.44 264.66,29.72 269.22,29.72 269.93,30.43 270.31,30.43 v1(270.55,30.19)
NVVDD: length 51.3
  IN3 w0.305: v1(34.79,52.62) 34.84,52.67 34.84,53.49 34.46,53.86 31.67,53.86 29.36,56.18 26.89,56.18 25.98,55.26 24.21,55.26 22.95,54 22.95,53.98 v1(22.91,53.94)
  IN3 w0.508: 20.03,77.79 22.48,80.23 22.48,83.6 ; v1(22.91,53.94) 22.75,53.79 21.85,53.79 21.35,54.3 21.35,55.42 20.64,56.12 20.64,56.91 21.02,57.29 21.02,59.52 22.61,61.12 22.61,71.76
  BOTTOM w0.203: CG720.2 v2(59.7,106.8) CG693.2 ; v1(34.79,52.62) 35.07,52.62 35.44,52.25 PR506.2
  BOTTOM w0.254: v2(50.6,101.9) 50.5,102 CG765.2 50.5,102.38 CG761.2
  BOTTOM w0.508: v1(22.91,53.94) 22.91,53.38 21.99,52.47 21.81,52.47 21.1,51.76 21.1,49.36 PR521.1
  vias: v1(24.14,83.13) v1(39.75,91.08) v1(41.52,91.12) v1(45.64,90.72) v1(45.64,88.56) v1(47.44,90.52) v1(48.46,90.82) v1(48.61,88.64) v1(50.87,86.43) v2(44.84,106.76) v2(45.02,104.67) v2(45.69,119.4) v2(45.67,116.63) v2(45.67,115.91) v2(45.68,115.2) v2(45.69,109.58) v2(45.68,106.8) v2(45.69,103.32) v2(45.71,117.99) v2(45.73,117.31) v2(45.7,104.66) v2(45.7,102.65) v2(46.38,111.03) v2(46.39,108.23) v2(46.4,119.35) v2(46.4,117.34) v2(46.41,104.66) v2(47.05,119.4) v2(47.09,112.37) v2(47.1,117.33) v2(47.1,108.25) v2(47.1,103.3) v2(47.79,117.33) v2(47.79,115.17) v2(47.79,113.78) v2(47.79,111.04) v2(47.78,109.57) v2(47.79,106.78) v2(47.8,118.74) v2(47.82,113.12) v2(47.8,101.9) v2(48.49,115.17) v2(48.48,114.52) v2(48.48,113.79) v2(48.49,103.26) v2(48.52,118.73) v2(48.5,117.35) v2(48.5,115.93) v2(48.5,113.12) v2(48.5,111) v2(48.51,108.23) v2(48.5,106.8) v2(49.17,118.71) v2(49.18,113.13) v2(49.19,101.92) v2(49.23,117.31) v2(49.21,112.37) v2(49.2,109.62) v2(49.2,108.22) v2(49.2,105.4) v2(49.22,103.99) v2(49.91,120.12) v2(49.9,117.3) v2(49.9,114.5) v2(49.92,112.4) v2(49.9,109.6) v2(49.9,106.8) v2(49.9,103.25) v2(50.58,110.99) v2(50.6,118.7) v2(50.6,115.9) v2(50.6,113.1) v2(50.6,108.2) v2(51.29,109.57) v2(51.29,104.69) v2(51.31,120.14) v2(51.31,117.98) v2(51.32,115.2) v2(51.3,114.54) v2(51.3,112.4) v2(51.3,106.8) v2(51.3,104.03) v2(51.99,115.17) v2(52,118.7) v2(52,116.58) v2(52,111) v2(52,108.2) v2(52,105.36) v2(52,104.67) v2(52.04,104) v2(52,103.25) v2(52.68,117.98) v2(52.69,115.16) v2(52.69,106.76) v2(52.7,120.06) v2(52.7,116.59) v2(52.71,113.76) v2(52.7,112.37) v2(52.7,109.57) v2(52.74,104.01) v2(52.7,101.87) v2(53.38,104) v2(53.4,118.7) v2(53.41,115.18) v2(53.4,113.75) v2(53.4,111) v2(53.41,108.21) v2(53.4,105.36) v2(53.41,103.26) v2(54.08,118.72) v2(54.09,113.76) v2(54.09,108.24) v2(54.1,111) v2(54.1,106.76) v2(54.1,104.72) v2(54.79,112.4) v2(54.77,109.58) v2(54.79,106.84) v2(54.78,105.4) v2(54.78,103.27) v2(54.8,120.1) v2(54.8,106.06) v2(54.81,104.03) v2(54.8,102.65) v2(55.49,107.47) v2(55.49,105.4) v2(55.47,104) v2(55.49,102.64) v2(55.5,118.7) v2(55.5,113.14) v2(55.5,111) v2(55.5,108.2) v2(56.18,114.47) v2(56.18,105.38) v2(56.19,101.92) v2(56.2,120.1) v2(56.2,117.3) v2(56.2,112.4) v2(56.2,109.55) v2(56.2,106.75) v2(56.88,114.47) v2(56.89,105.38) v2(56.9,118.7) v2(56.91,115.9) v2(56.9,112.4) v2(56.91,103.3) v2(57.59,114.47) v2(57.55,113.1) v2(57.63,120.1) v2(57.6,117.3) v2(57.6,115.9) v2(57.61,110.97) v2(57.6,108.2) v2(57.6,106.75) v2(57.6,105.38) v2(58.28,118.7) v2(58.3,115.85) v2(58.32,109.58) v2(58.35,107.5) v2(58.32,106.81) v2(58.34,103.3) v2(58.33,102.6) v2(59,118.7) v2(59,110.95) v2(59,108.21) v2(59,105.4) v2(59.69,117.31) v2(59.68,102.63) v2(59.7,120.1) v2(59.7,114.5) v2(59.7,109.6) v2(59.7,101.9) v2(60.39,110.96) v2(60.36,105.4) v2(60.36,104.01) v2(60.37,102.61) v2(60.43,118.71) v2(60.4,115.9) v2(60.4,113.85) v2(60.4,108.2) v2(61.1,120.1) v2(61.1,117.3) v2(61.12,113.79) v2(61.1,110.95) v2(61.1,108.2) v2(61.1,101.9) v2(61.75,118.7) v2(61.8,115.9) v2(61.8,114.5) v2(61.8,112.4) v2(61.8,108.2) v2(61.8,107.48) v2(61.8,106.1) v2(61.81,105.42) v2(61.81,103.26) v2(62.48,119.4) v2(62.49,109.6) v2(62.5,117.3) v2(62.5,115.88) v2(62.5,112.4) v2(63.19,115.91) v2(63.2,113.8) v2(63.2,111.02) v2(63.2,108.2) v2(63.25,104) v2(63.89,119.41) v2(63.89,104) v2(63.95,110.3) v2(63.9,104.67) v2(63.91,102.64) v2(63.99,101.17) v2(64.1,99.89) v2(64.33,100.77) v2(64.48,100.22) v2(64.56,113.09) v2(64.56,110.29) v2(64.71,101.3) v2(64.88,104.17) v2(64.86,100.58) v2(65.19,102.91) v2(65.27,101.67) v2(65.32,100.24) v2(65.4,100.78) v2(65.43,98.8) v2(65.78,99.91) v2(66.01,100.42) v2(66.16,97.48) v2(66.29,99.28) v2(66.35,99.85) v2(66.55,97.12) v2(66.67,98.9) v2(66.74,101.21) v2(67.05,98.41) v2(67.4,96.33) v2(67.6,98) v2(68.09,96.33) v2(68.12,97.02) v2(68.65,97.15) v2(68.8,99.05) v2(69.51,97.68) v2(70.2,98.45) v2(70.86,96.99) v2(70.88,94.91) v2(70.88,94.23) v2(71.52,97.63) v2(71.62,95.57) v2(71.6,94.91) v2(71.6,94.25) v2(72.28,96.31) v2(72.31,95.57) v2(72.31,94.94) v2(73.07,94.26) v2(73.17,95.67) v2(73.17,95.04) v2(73.93,95.16) v2(73.94,94.09) v2(74.72,94.78) v2(75.35,95.42) v3(16.12,77.03) v3(16.12,76.27) v3(16.12,75.51) v3(16.12,74.62) v3(16.12,73.85) v3(16.12,73.09) v3(16.12,72.33) v3(20.85,77) v3(20.85,76.24) v3(20.85,75.48) v3(20.85,74.59) v3(20.85,73.83) v3(20.85,73.07) v3(20.85,72.3) v3(24.66,75.35) v3(25.55,75.35) v3(25.55,74.59) v3(25.55,73.83) v3(25.55,73.07) v3(25.55,72.3) v3(30.5,75.35) v3(30.5,74.59) v3(30.5,73.83) v3(30.5,73.07) v3(30.5,72.3) v3(31.39,75.35) v3(32.28,75.35) v3(33.17,75.35) v3(35.2,77) v3(35.2,76.24) v3(35.2,75.48) v3(35.2,74.59) v3(35.2,73.83) v3(35.2,73.07) v3(35.2,72.3) v3(40.15,77) v3(40.15,76.24) v3(40.15,75.48) v3(40.15,74.59) v3(40.15,73.83) v3(40.15,73.07) v3(40.15,72.3) v3(44.82,76.93) v3(44.82,76.17) v3(44.82,75.4) v3(44.82,74.51) v3(44.82,73.75) v3(44.82,72.99) v3(44.82,72.23) v3(49.93,77) v3(49.93,76.24) v3(49.93,75.48) v3(49.93,74.59) v3(49.93,73.83) v3(49.93,73.07) v3(49.93,72.3) v3(54.5,77) v3(54.5,76.24) v3(54.5,75.48) v3(54.5,74.59) v3(54.5,73.83) v3(54.5,73.07) v3(54.5,72.3) v3(59.45,77) v3(59.45,76.24) v3(59.45,75.48) v3(59.45,74.59) v3(59.45,73.83) v3(59.45,73.07) v3(59.45,72.3) v3(64.15,77) v3(64.15,76.24) v3(64.15,75.48) v3(64.15,74.59) v3(64.15,73.83) v3(64.15,73.07) v3(64.15,72.3) v3(69.11,77) v3(69.11,76.24) v3(69.11,75.48) v3(69.11,74.59) v3(69.11,73.83) v3(69.11,73.07) v3(69.11,72.3) v3(73.81,77) v3(73.81,76.24) v3(73.81,75.48) v3(73.81,74.59) v3(73.81,73.83) v3(73.81,73.07) v3(73.81,72.3) v3(78.76,77) v3(78.76,76.24) v3(78.76,75.48) v3(78.76,74.59) v3(78.76,73.83) v3(78.76,73.07) v3(78.76,72.3) v3(83.46,77) v3(83.46,76.24) v3(83.46,75.48) v3(83.46,74.59) v3(83.46,73.83) v3(83.46,73.07) v3(83.46,72.3) v3(88.31,75.62) v3(88.31,74.86) v3(88.31,74.1) v3(88.31,73.33) v3(88.31,72.57) v3(88.31,71.81) v3(89.15,75.12)
NVVDD_CORE1: length 34.4
  TOP w0.14: RG80.1 26.24,78.4 26.23,78.39 DG3.1 v1(25.42,77.71)
  IN1 w0.086: v1(31.46,78.86) 30.93,78.32 26.03,78.32 v1(25.42,77.71)
  BOTTOM w0.14: v1(31.46,78.86) 32.03,78.29 DG7.2 32.74,78.29 33.19,78.75 RG189.1 34.17,79.37 34.17,79.74 34.42,80 34.87,80 35.78,79.08 UG8.4 36,78.36 36.11,78.25 38.22,78.25 38.47,78.5 38.47,79.02 38.84,79.39 38.84,80.19 38.96,80.31 40.73,80.31 40.77,80.36 40.86,80.36 41.34,80.84 42.42,80.84 42.68,81.1 DG6.2 42.68,82.33 42.76,82.4 42.76,82.68 42.21,83.23 42.21,84.32 41.6,84.93 41.6,85.87 41.32,86.14 39.77,86.14 39.29,85.67 39.29,85.06 39.01,84.78 38.71,84.78 38.24,84.3 RG180.2
NVVDD_CORE1_EN: length 83.2
  TOP w0.14: PR320.2 29.51,39.98 PD7.1 30.17,39.97 v1(30.37,40.17)
  IN2 w0.089: v1(30.37,40.17) 30.37,42.14 24.99,47.52 22.16,47.52 21.71,47.97 21.71,52.18 20.47,53.43 20.47,53.52 20.4,53.59 20.4,54.66 19.23,55.83 17.73,55.83 16.25,57.31 16.25,57.98 13.92,60.31 13.92,61.01 13.65,61.29 13.65,71.2 13.08,71.77 13.08,73.42 12.91,73.59 12.91,75.63 11.99,76.55 11.99,81.81 13.94,83.76 13.94,84.03 16.46,86.55 20.59,86.55 23.64,83.51 23.64,82.49 24.5,81.63 v1(31.18,81.63)
  BOTTOM w0.14: v1(31.18,81.63) 31.53,81.98 RG184.1 32.62,81.98 32.63,81.99 CG899.1 32.84,81.76 32.84,81.15 DG7.1 33.34,79.53 RG189.2
NVVDD_PG_LOOP_OVT: length 7.2
  BOTTOM w0.14: QG21.2 45.81,83.45 45.81,82.66 RG185.2 46.95,81.52 46.95,80.96 46.44,80.45 QG23.6 46.69,80.17 47.24,79.62 47.24,79.42 47.79,78.87 QG23.3
NVVDD_PSI: length 109.1
  TOP w0.102: 35.9,99.92 36.74,99.08 37.14,99.08 37.47,98.75 UG1.BD2
  TOP w0.14: 35.9,99.92 34.51,99.92 v1(34.02,100.41) 33.42,101.01 RG18.2
  IN1 w0.086: v1(21.25,90.47) 19.4,90.47 18.9,90.97 18.9,92.4 19.58,93.09 22.1,93.09 22.94,93.92 24.92,93.92 25.38,94.39 26.8,94.39 27.26,93.92 31.29,93.92 34.02,96.65 v1(34.02,100.41)
  IN2 w0.089: v1(21.25,90.47) 21.25,89.78 22.23,88.8 22.23,87.64 21.53,86.94 16.3,86.94 15.91,86.55 14.59,86.55 12.54,84.5 12.54,83.5 11.61,82.56 11.61,76.39 12.51,75.48 12.51,73.44 12.7,73.26 12.7,71.61 13.26,71.05 13.26,61.13 13.54,60.86 13.54,60.15 15.83,57.86 15.83,57.19 17.57,55.45 19.07,55.45 20.01,54.5 20.01,53.34 21.33,52.02 21.33,47.81 22.81,46.33 25.64,46.33 29.78,42.19 29.78,39.87 30.09,39.56 30.6,39.56 30.99,39.95 30.99,40.93 31.45,41.4 31.94,41.4 32.92,42.39 v1(34.25,42.39)
  BOTTOM w0.14: PR532.1 34.72,42.86 v1(34.25,42.39)
NVVDD_PWM_GPU: length 100.1
  TOP w0.102: v2(40.11,98.36) 40.14,98.39 40.14,98.4 40.45,98.71 UG1.BD6
  TOP w0.14: v1(33.32,43.05) 33.58,43.31 PR314.1
  IN1 w0.086: v1(21.91,90.49) 22.85,90.49 25.01,92.65 27.19,92.65 27.54,93.01 31.73,93.01 32.71,93.99 35.89,93.99 36.21,93.67 36.85,93.67 37.04,93.85 38.59,93.85 39.63,93.85 39.88,94.1 39.88,95.27 39.77,95.38 39.77,97.83 40.11,98.17 v2(40.11,98.36)
  IN2 w0.089: v1(21.91,90.49) 21.91,89.91 22.42,89.4 22.42,87.45 21.72,86.74 16.38,86.74 15.99,86.36 14.67,86.36 12.73,84.42 12.73,83.42 11.8,82.48 11.8,76.47 12.72,75.55 12.72,73.51 12.89,73.34 12.89,71.69 13.46,71.13 13.46,61.21 13.73,60.93 13.73,60.23 16.02,57.94 16.02,57.26 17.65,55.64 19.15,55.64 20.21,54.58 20.21,53.52 20.28,53.45 20.28,53.35 21.52,52.1 21.52,47.89 22.08,47.33 24.91,47.33 29.97,42.27 29.97,39.95 30.15,39.77 30.54,39.77 30.8,40.03 30.8,41.01 31.38,41.59 31.86,41.59 v1(33.32,43.05)
NVVDD_SENSE_I: length 33.4
  TOP w0.127: PR361.1 44.7,29.73 43.95,29.73 v1(43.92,29.77) ; PR298.1 27.42,47.12 27.55,46.99 27.55,46.49 v1(27.43,46.37)
  BOTTOM w0.127: v1(43.92,29.77) 43.65,29.77 43.48,29.94 43.48,30.6 41.95,32.12 41.95,32.83 41.45,33.34 40.71,33.34 40.45,33.09 38.9,33.09 38.25,33.74 38.25,34.89 37.54,35.6 37.54,36.28 36.46,37.36 36.46,39.18 32.73,42.91 32.73,43.42 33.52,44.21 33.52,44.82 33.1,45.24 33.1,47.38 32.69,47.79 28.69,47.79 28.34,47.44 27.85,47.44 27.58,47.16 27.58,46.52 v1(27.43,46.37)
NVVDD_SENSE_V: length 35.1
  TOP w0.127: PR358.1 46.28,30.3 PR362.2 45.3,29.31 45.06,29.31 45.06,29.31 44.39,29.31 44.39,29.31 43.73,29.31 43.73,29.31 v1(43.46,29.31) ; v1(28.05,46.55) 27.8,46.8 27.8,46.94 PR299.1
  BOTTOM w0.127: v1(43.46,29.31) 43.46,29.6 43.22,29.83 43.22,30.49 41.7,32.02 41.7,32.73 41.34,33.09 40.81,33.09 40.56,32.83 38.79,32.83 37.99,33.63 37.99,34.78 37.28,35.49 37.28,36.17 36.21,37.25 36.21,39.07 32.47,42.8 32.47,43.52 33.27,44.32 33.27,44.72 32.85,45.13 32.85,47.27 32.58,47.54 28.79,47.54 28.44,47.18 27.96,47.18 27.83,47.06 27.83,46.77 v1(28.05,46.55)
NVVDDPG: length 84.1
  TOP w0.14: DG4.1 43.31,79.18 43.39,79.1 RG78.2 44.23,79.1 v1(45.19,80.06)
  IN2 w0.089: v1(34.22,45.74) 33.71,45.23 32.54,45.23 31.75,46.02 31.75,46.81 30.9,47.66 29.88,47.66 29.8,47.75 27.97,47.75 27.61,48.11 27.61,51.74 25.68,53.67 25.68,54.08 25.4,54.37 24.96,54.37 24.09,53.5 22.79,53.5 22.16,54.12 21.72,54.12 21.56,54.28 21.56,55.05 19.62,56.98 18.52,56.98 17.66,57.84 17.66,59.08 16.71,60.02 16.71,60.04 16.56,60.19 16.56,60.68 15.54,61.69 15.54,70.85 15.29,71.1 15.29,77.43 15.73,77.87 22.57,77.87 24.73,80.03 27.09,80.03 27.52,79.59 32.37,79.59 32.59,79.38 37.28,79.38 37.64,79.73 40.09,79.73 40.74,80.38 43.33,80.38 43.45,80.5 44.75,80.5 v1(45.19,80.06)
  BOTTOM w0.14: v1(34.22,45.74) 34.27,45.69 PR527.1 ; QG23.5 45.68,79.52 45.52,79.36 v1(45.23,79.36) 45.19,79.4 v1(45.19,80.06)
OUT_DP_TXN0: length 17.1
  TOP w0.14: v1(95.34,158.65) 95.49,158.65 95.71,158.44 95.71,158.31 94.61,157.21 92.25,157.21 91.67,156.63 91.67,156.36 91.39,156.08 90.28,156.08 89.41,156.96 89.41,158.62 90.27,159.48 90.27,159.62 90.55,159.9 91,159.9 C31.2
  BOTTOM w0.14: v1(95.34,158.65) 95.48,158.65 95.64,158.5 95.64,158.2 94.8,157.37 94.8,156.57 94.62,156.38 94.62,155.79 94.02,155.19 U39.39
OUT_DP_TXN1: length 13.6
  TOP w0.14: C25.2 88.79,159.95 88.3,159.95 88.16,159.81 88.16,159.53 88.42,159.28 88.42,156.02 88.53,155.91 89.05,155.91 89.95,155.01 91.97,155.01 92.37,154.61 92.86,154.61 93.46,155.21 93.46,156.06 93.27,156.25 v1(93.23,156.25)
  BOTTOM w0.14: U39.36 92.82,155.18 92.9,155.26 92.9,155.26 93.45,155.8 93.45,156.04 v1(93.23,156.25)
OUT_DP_TXN2: length 8.6
  TOP w0.14: C27.2 93.18,159.84 93.04,159.7 93.04,159.43 93.18,159.29 v1(93.33,159.29)
  BOTTOM w0.14: U39.34 92.02,155.4 91.98,155.44 91.98,156.44 92.38,156.84 93.73,156.84 94.14,157.26 94.14,157.8 93.82,158.13 92.98,158.13 92.84,158.27 92.84,158.48 93.08,158.72 93.08,159.05 v1(93.33,159.29)
OUT_DP_TXN3: length 9.7
  TOP w0.14: C29.2 95.38,159.81 95.22,159.66 95.22,159.45 93.84,158.07 92.95,158.07 92.75,158.27 92.21,158.27 92.01,158.07 91.51,158.07 90.52,157.08 90.52,156.76 v1(90.54,156.74)
  BOTTOM w0.14: v1(90.54,156.74) 90.34,156.74 90.13,156.53 90.13,156.2 90.26,156.06 90.4,156.06 90.82,155.65 U39.31
OUT_DP_TXP0: length 17.1
  TOP w0.14: C30.2 89.95,159.77 89.95,159.62 89.09,158.76 89.09,156.82 90.15,155.77 91.52,155.77 91.99,156.23 91.99,156.5 92.38,156.9 94.75,156.9 96.03,158.18 96.03,158.44 v1(96.24,158.65)
  BOTTOM w0.14: v1(96.24,158.65) 95.95,158.36 95.95,158.07 95.12,157.23 95.12,156.44 94.94,156.25 94.94,155.65 94.42,155.14 U39.40
OUT_DP_TXP1: length 13.6
  TOP w0.14: C24.2 87.84,159.75 87.84,159.4 88.1,159.14 88.1,155.89 88.39,155.59 88.92,155.59 89.81,154.7 91.84,154.7 92.24,154.3 92.99,154.3 93.78,155.08 93.78,156.03 v1(93.91,156.16)
  BOTTOM w0.14: v1(93.91,156.16) 93.77,156.02 93.77,155.67 93.22,155.13 U39.37
OUT_DP_TXP2: length 8.6
  TOP w0.14: C26.2 92.52,159.84 92.72,159.64 92.72,159.43 92.58,159.29 v1(92.42,159.29)
  BOTTOM w0.14: U39.33 91.62,155.4 91.66,155.44 91.66,156.57 92.25,157.16 93.6,157.16 93.83,157.39 93.83,157.67 93.69,157.81 92.85,157.81 92.53,158.13 92.53,158.62 92.77,158.86 92.77,158.95 v1(92.42,159.29)
OUT_DP_TXP3: length 9.7
  TOP w0.14: v1(90.06,157.33) 90.08,157.3 90.3,157.3 91.38,158.39 91.87,158.39 92.08,158.59 92.88,158.59 93.08,158.39 93.7,158.39 94.9,159.58 94.9,159.75 94.84,159.81 C28.2
  BOTTOM w0.14: U39.30 90.42,155.19 90.5,155.27 90.5,155.52 90.27,155.75 90.13,155.75 89.81,156.07 89.81,156.66 90.17,157.02 90.17,157.22 v1(90.06,157.33)
OVERT#: length 31.7
  TOP w0.102: UG1.BG5 39.45,96.95 v2(39.4,96.95)
  TOP w0.14: v1(22.2,86.56) 21.49,87.27 QG9.1 21.27,86.45 20.81,85.99 RG45.2 22.15,84.02 RG51.1
  BOTTOM w0.14: v2(39.4,96.95) 38.96,96.51 36.72,96.51 35.17,94.96 35.17,90.44 34,89.27 27.81,89.27 27.14,88.6 22.89,88.6 22.65,88.36 22.65,87.21 22.45,87.01 22.45,86.82 v1(22.2,86.56)
OVRM_VCC: length 20.1
  TOP w0.14: PR353.1 39.8,32.35 38.5,33.65 PR348.1 38.82,33.82 39.04,34.03 39.43,34.03 39.77,33.7 PR349.1 39.8,34.38 PR346.1 39.52,34.71 39.11,34.71 38.67,35.16 v1(38.67,35.25) 38.67,36.01 39.01,36.36 39.75,36.36 PR343.2 ; v1(46.04,36.36) 46.2,36.36 46.35,36.21 47.21,36.21 47.36,36.36 PR344.2 47.62,36.78 PR342.2
  IN4 w0.086: v1(46.04,36.36) 45.85,36.36 45.09,35.6 43.07,35.6 41.15,33.68 40.12,33.68 38.67,35.14 v1(38.67,35.25)
PA_DP_MODE: length 40.4
  TOP w0.14: U13.21 252.9,34.77 253.61,34.05 v1(253.64,34.05) ; v1(280.71,49.6) 281.15,49.6 281.29,49.74 U5.16
  IN2 w0.089: v1(253.64,34.05) 255.26,34.05 256.3,35.09 256.3,36.26 258.87,38.83 258.87,41.47 258.39,41.95 258.39,42.59 258.84,43.04 269.21,43.04 269.54,43.37 269.54,45.23 271.65,47.34 278.45,47.34 v1(280.71,49.6)
PA_POL: length 42.9
  TOP w0.14: U5.11 280.27,52.28 279.83,52.72 v1(279.83,52.8) ; U5.15 280.27,50.68 v1(279.8,50.21) ; U13.22 252.96,35.17 253.41,34.71 v1(253.71,34.71)
  IN2 w0.089: v1(279.83,52.8) 280.1,52.52 280.1,50.51 v1(279.8,50.21) 277.16,47.57 271.61,47.57 269.35,45.31 269.35,43.45 269.13,43.23 258.77,43.23 258.2,42.67 258.2,41.87 258.68,41.39 258.68,38.91 256.08,36.31 255.54,36.31 254.68,35.45 254.68,34.97 254.43,34.71 v1(253.71,34.71)
PA_TBT_MODE: length 42.4
  TOP w0.14: v1(280.61,53.48) 280.79,53.66 281.15,53.66 281.29,53.52 U5.10 ; v1(254.2,35.17) 253.36,35.17 252.96,35.57 U13.23
  IN2 w0.089: v1(280.61,53.48) 280.51,53.38 279.39,53.38 278.96,52.95 278.96,50.92 275.81,47.77 271.54,47.77 269.16,45.39 269.16,43.54 269.04,43.43 258.69,43.43 258.01,42.74 258.01,41.79 258.49,41.31 258.49,38.99 256,36.5 255.45,36.5 254.2,35.25 v1(254.2,35.17)
PA_USB2_RBIAS: length 1.6
  TOP w0.14: v2(265.31,47.52) 265.31,47.52 U7.H19
  BOTTOM w0.14: R812.2 265.22,46.62 265.22,47.43 v2(265.31,47.52)
PB_USB2_RBIAS: length 1.8
  TOP w0.127: U7.F19 v2(265.96,47.52)
  BOTTOM w0.14: v2(265.96,47.52) 265.52,47.08 265.52,46.73 R811.1
PBLED: length 237.5
  TOP w0.14: Q1.2 40.69,160.97 v1(41.46,161.73) 41.93,161.25 R12.2 ; R388.1 88.31,27.6 89.18,27.6 C353.1 89.69,28.58 89.5,28.78 v1(89.5,28.83)
  IN2 w0.089: v1(41.46,161.73) 41.61,161.57 41.89,161.57 42.22,161.24 43.6,161.24 44.99,162.63 48.61,162.63 49.66,161.59 56.46,161.59 56.99,162.12 61.21,162.12 61.25,162.08 63.15,162.08 64.94,160.29 66.64,160.29 68.44,162.09 69.31,162.09 71.55,164.33 77.32,164.33 78.13,163.52 88.05,163.52 88.63,162.94 89.79,162.94 90.33,162.4 90.33,161.92 91.17,161.08 97.13,161.08 97.74,160.47 103.16,160.47 103.4,160.72 105.31,160.72 106.09,159.94 106.09,157.7 104.36,155.97 104.36,151.8 106.09,150.07 106.09,147.03 108.21,144.91 108.21,131.8 108.86,131.15 108.86,126.13 107.79,125.06 107.79,111.12 106.81,110.14 106.81,98.56 105.51,97.26 105.51,92.87 105.39,92.76 105.39,90.07 105.82,89.64 107.05,89.64 108.19,88.5 108.19,87.2 107.77,86.78 107.77,83.81 107.16,83.2 107.16,80.6 104.1,77.55 104.1,76.52 103.21,75.63 103.21,75.16 102.08,74.02 102.08,73.61 99.97,71.5 99.97,67.89 99.03,66.95 99.03,65.3 98.28,64.54 98.28,63.99 99.03,63.23 99.03,58.39 98.23,57.59 98.23,56.59 97.57,55.93 97.57,52.81 97.34,52.58 97,52.58 95.94,51.51 95.94,49.65 96.49,49.1 97.08,49.1 98.49,47.69 98.49,47.01 98.11,46.63 97.55,46.63 96.39,47.78 96.02,47.78 95.41,48.4 91.59,48.4 89.38,46.19 89.38,45.57 88.66,44.84 88.66,42.63 v1(87.42,41.39)
  BOTTOM w0.14: v1(87.42,41.39) 86.89,40.86 86.89,40.63 87.09,40.43 87.09,40.1 87.74,39.44 v1(88.62,39.44) 88.66,39.44 90.86,37.24 91.18,37.24 92.45,35.97 92.45,33.66 92.01,33.21 90.83,33.21 90.44,32.82 90.44,31.82 91.08,31.18 91.08,30.43 89.5,28.85 v1(89.5,28.83)
PBLED#: length 12.6
  TOP w0.14: v1(37.66,163.03) 37.66,162.93 38.23,162.36 v1(38.23,162.18) 38.23,162.13 37.51,161.4 D9.1 38.4,160.93 Q1.3
  BOTTOM w0.14: v1(37.66,163.03) 37.23,163.47 31.97,163.47 30.85,162.34 30.85,161.22 CN8.5
PBLED_R: length 2.3
  TOP w0.14: U18.81 85.84,27.42 86.23,27.8 86.99,27.8 R388.2
PCBEEP_EC: length 63.9
  TOP w0.14: v1(26.88,36.59) 27.16,36.87 D36.2 ; v1(70.97,20.53) 71.2,20.53 71.43,20.29 U18.34
  IN4 w0.086: v1(26.88,36.59) 26.57,36.27 26.57,35.63 26.67,35.53 26.67,34.83 26.87,34.64 26.87,33.87 27.79,32.94 28.83,32.94 30.63,31.14 30.75,31.02 35.34,31.02 35.65,30.7 37.11,30.7 37.86,29.95 43.26,29.95 43.81,30.5 46.96,30.5 47.03,30.57 52.09,30.57 53.59,29.07 53.59,20.99 53.98,20.6 54.97,20.6 55.57,20.01 59.15,20.01 59.16,20 60.46,20 61.89,18.57 62.43,18.57 62.89,18.12 63.62,18.12 64.07,17.67 64.96,17.67 65.18,17.46 66.44,17.46 67.98,19.01 69.46,19.01 70.1,19.65 70.1,20.23 70.4,20.53 v1(70.97,20.53)
PCH_2_CPU_TRIG: length 171.8
  TOP w0.114: U3.H23 123.81,121.39 v1(123.81,121.41)
  TOP w0.14: R232.2 193.36,40.88 192.49,41.74 192.49,42.25 191.72,43.02 191.28,43.02 191,42.74 190.62,42.74 188.93,44.43 188.04,44.43 v1(187.62,44.85)
  IN2 w0.089: v1(187.62,44.85) 187.62,45.03 186.42,46.24 186.42,47.58 186.04,47.97 186.04,49.81 185.76,50.08 183.62,50.08 181.57,52.14 181.57,52.8 180.83,53.54 180.83,54 181.26,54.43 181.26,56.12 180.05,57.33 179.55,57.33 179.41,57.47 179.41,57.77 178.52,58.66 178.52,59.26 177.97,59.81 177.75,59.81 175.36,62.19 v1(175.02,62.19) ; v1(104.19,71.81) 104.19,72.08 105.82,73.71 105.82,73.92 106.74,74.84 106.74,75.14 109.62,78.02 109.62,83.71 110.04,84.13 110.04,92.34 110.34,92.64 110.34,103.9 111.89,105.45 111.89,106.11 117.62,111.84 117.62,119.47 119.97,121.82 123.4,121.82 v1(123.81,121.41)
  IN4 w0.086: v1(104.19,71.81) 104.7,71.3 112.8,71.3 115.29,73.79 164.65,73.79 174.93,63.5 174.93,62.28 v1(175.02,62.19)
PCH_2_CPU_TRIG_R: length 16.5
  TOP w0.102: U14.AK3 204.69,31.46 202.64,31.46 202.45,31.28 201.98,31.28 201.64,31.61 201.64,31.79 201.32,32.12
  TOP w0.14: R232.1 193.53,39.65 193.96,40.08 194.97,40.08 195.99,39.06 v1(195.99,38.8) 195.99,38.44 198.21,36.22 198.21,36.01 198.9,35.33 198.9,34.54 201.32,32.12
PCH_AZ_CODEC_BITCLK: length 205.7
  TOP w0.14: v1(29.1,34.54) C277.1 29.23,35.02 29.53,34.71 29.53,34.35 29.61,34.28 U17.11 ; v1(202.26,18.38) R488.1
  IN2 w0.089: v1(29.1,34.54) 29.24,34.54 29.93,33.84 31.62,33.84 32.56,34.78 33.14,34.78 33.72,35.36 35.46,35.36 36.77,34.05 38.69,34.05 38.81,34.17 39.57,34.17 40.32,33.42 40.32,32.61 40.71,32.22 42.15,32.22 42.44,31.93 45.13,31.93 45.36,31.7 45.36,30.97 48.75,27.58 51.73,27.58 51.89,27.74 52.38,27.74 52.54,27.58 52.54,27.23 54.58,25.19 55.18,25.19 55.58,24.78 55.58,23.82 57.8,21.61 58.47,21.61 59.41,20.66 59.41,20.63 61.17,18.88 63.3,18.88 63.48,18.7 66.76,18.7 67.25,18.2 67.58,18.2 68.39,17.4 69.12,17.4 69.25,17.52 71.12,17.52 72.38,18.78 78.22,18.78 80.17,20.73 80.17,22.36 80.62,22.82 82.05,22.82 82.28,23.05 84.09,23.05 84.21,22.94 87.72,22.94 88.14,22.52 89.42,22.52 89.45,22.55 90.57,22.55 90.95,22.93 92.13,22.93 93.63,24.44 95.03,24.44 95.73,25.14 97.14,25.14 98.37,26.36 98.37,26.73 99.46,27.82 100.59,27.82 102.13,26.28 111.56,26.28 112.51,25.33 114.17,25.33 115.76,23.75 115.76,21.48 116.8,20.44 122.99,20.44 125.1,22.55 130.34,22.55 133.58,25.78 139.22,25.78 139.89,26.45 141.15,26.45 141.35,26.24 148.23,26.24 149.47,27.49 151.79,27.49 152.05,27.23 164.31,27.23 164.87,27.79 166.54,27.79 166.82,28.08 168.22,28.08 168.62,28.48 176.91,28.48 177.69,27.7 178,27.7 179.69,26.01 179.69,25.5 180,25.18 186.24,25.18 187.73,23.69 192.3,23.69 193.74,22.25 195.45,22.25 195.95,21.75 195.95,21.12 198.14,18.94 199.81,18.94 200.79,17.96 201.84,17.96 v1(202.26,18.38)
PCH_AZ_CODEC_RST#: length 195.8
  TOP w0.14: v1(200.93,18.43) 200.9,18.43 R496.1 ; U17.10 30.01,34.17 30.15,34.31 v1(30.15,34.31)
  IN2 w0.089: v1(200.93,18.43) 200.93,18.77 199.92,19.79 198.07,19.79 196.42,21.43 196.42,21.94 195.65,22.72 193.94,22.72 191.84,24.81 187.27,24.81 186.04,26.05 180.72,26.05 180.45,26.32 180.04,26.32 178.2,28.17 177.89,28.17 177.08,28.97 168.45,28.97 168.02,28.55 166.63,28.55 166.34,28.26 164.68,28.26 164.12,27.7 152.32,27.7 152.06,27.96 111.87,27.96 110.66,26.75 102.33,26.75 100.78,28.29 99.27,28.29 97.9,26.92 97.9,26.56 96.95,25.61 95.36,25.61 94.95,26.02 94.16,26.02 92.84,24.71 92.84,24.31 91.93,23.4 90.76,23.4 90.37,23.02 89.04,23.02 89.04,23.02 88.31,23.02 87.91,23.41 84.4,23.41 84.29,23.52 82.09,23.52 81.85,23.29 80.43,23.29 79.7,22.56 79.7,20.93 78.02,19.25 72.18,19.25 71.68,18.75 67.37,18.75 66.95,19.17 63.67,19.17 63.49,19.35 61.66,19.35 61.31,19.7 61.31,20.37 60.95,20.72 60.02,20.72 58.67,22.08 57.99,22.08 56.05,24.01 56.05,24.98 54.75,26.28 54.15,26.28 53.07,27.37 53.07,28.15 52.67,28.55 52.67,29.6 52.36,29.9 50.9,29.9 50.2,30.61 46.87,30.61 46.43,31.04 46.43,31.55 45.59,32.4 42.77,32.4 41.8,33.37 41.04,33.37 39.75,34.66 37.63,34.66 37.22,35.07 36.5,35.07 35.53,36.04 35.5,36.08 31.6,36.08 30.15,34.63 v1(30.15,34.31)
PCH_AZ_CODEC_SDIN0: length 199.6
  TOP w0.14: v1(201.59,18.41) 201.59,18.72 R491.1 ; v1(27.37,34.51) 27.32,34.56 R294.2
  IN2 w0.089: v1(27.37,34.51) 27.99,35.12 30.16,35.12 31.46,36.42 35.81,36.42 36.47,35.76 38.77,35.76 39.52,35 39.93,35 41.22,33.71 41.94,33.71 42.91,32.74 45.73,32.74 46.81,31.66 48.89,31.66 49.6,30.95 50.35,30.95 51.05,30.25 52.5,30.25 53.01,29.74 53.01,28.69 53.41,28.29 53.41,27.51 54.29,26.62 54.89,26.62 56.4,25.12 56.4,24.16 58.13,22.42 58.81,22.42 60.16,21.06 62.23,21.06 62.9,20.39 62.9,19.92 63.06,19.75 63.57,19.75 63.81,19.52 67.09,19.52 67.51,19.09 71.44,19.09 72,19.65 77.94,19.65 79.36,21.07 79.36,22.7 80.29,23.63 81.71,23.63 82.53,24.45 84.25,24.45 84.61,24.08 84.63,24.1 88.76,24.1 89.1,23.75 89.69,23.75 90,24.06 90.4,24.06 90.71,23.75 91.79,23.75 92.5,24.46 92.5,25.16 94.2,26.86 94.77,26.86 95.61,26.03 96.77,26.03 97.55,26.81 97.55,27.85 98.34,28.64 100.93,28.64 102.47,27.09 110.52,27.09 111.73,28.3 152.25,28.3 152.51,28.05 163.98,28.05 164.54,28.61 166.2,28.61 166.48,28.89 167.88,28.89 168.32,29.33 177.21,29.33 178.03,28.51 178.34,28.51 180,26.86 180.41,26.86 180.87,26.39 186.18,26.39 187.42,25.15 191.99,25.15 194.08,23.06 195.79,23.06 196.77,22.08 196.77,21.58 198.21,20.13 200.06,20.13 201.54,18.65 201.54,18.46 v1(201.59,18.41)
PCH_AZ_CODEC_SDOUT: length 208
  TOP w0.102: v1(204.62,18.38) 204.31,18.68 R492.1
  TOP w0.14: v1(27.27,36.06) 26.92,35.71 26.92,34.33 27.17,34.08 28.21,34.08 28.41,33.88 U17.14
  IN2 w0.089: v1(27.27,36.06) 27.79,35.54 29.18,35.54 29.99,36.35 30.27,36.35 30.69,36.76 35.97,36.76 36.63,36.1 38.91,36.1 39.66,35.34 40.43,35.34 40.69,35.09 41.85,35.09 42.28,34.67 42.28,33.86 43.06,33.08 45.87,33.08 46.95,32 49.04,32 49.75,31.29 50.49,31.29 51.19,30.59 52.65,30.59 53.35,29.89 53.35,28.83 54.53,27.65 54.74,27.65 55.03,27.36 55.03,26.97 56.74,25.26 56.74,24.43 57.03,24.14 57.82,24.14 57.97,23.99 57.97,23.54 58.32,23.19 59.07,23.19 60.05,22.21 62.09,22.21 62.76,21.55 62.76,21.02 63.19,20.59 63.72,20.59 63.8,20.52 64.78,20.52 65.43,19.86 67.23,19.86 67.66,19.43 71.3,19.43 71.87,20.01 76.12,20.01 76.8,20.69 76.8,21.63 79.14,23.97 81.57,23.97 82.45,24.85 82.51,24.85 83.18,25.52 84.04,25.52 85.12,24.44 88.91,24.44 88.99,24.35 88.99,24.35 89.23,24.11 89.23,24.11 89.25,24.1 89.55,24.1 89.85,24.4 90.54,24.4 90.85,24.09 91.65,24.09 92.16,24.6 92.16,25.3 94.05,27.2 94.92,27.2 95.72,26.4 96.59,26.4 97.21,27.02 97.21,27.99 98.2,28.98 101.07,28.98 102.61,27.44 110.38,27.44 111.58,28.64 152.39,28.64 152.65,28.39 163.83,28.39 164.39,28.95 166.06,28.95 166.34,29.23 167.74,29.23 168.17,29.67 178.57,29.67 178.85,29.39 178.85,28.89 181.02,26.73 186.32,26.73 187.56,25.5 192.13,25.5 193.05,24.58 195.57,24.58 195.97,24.18 195.97,23.37 197.11,22.23 197.11,21.72 198.35,20.48 200.2,20.48 200.53,20.15 203.51,20.15 204.62,19.04 v1(204.62,18.38)
PCH_AZ_CODEC_SYNC: length 204.8
  TOP w0.14: U17.12 29.21,33.92 29.03,34.1 28.9,34.1 28.24,34.76 v1(28.24,36.03) ; v1(205.91,18.41) 206.25,18.74 R494.1
  IN2 w0.089: v1(28.24,36.03) 28.89,36.69 30.13,36.69 30.55,37.11 36.19,37.11 36.83,36.46 40.26,36.46 40.5,36.23 40.5,35.76 40.83,35.43 42,35.43 42.62,34.81 42.62,34 43.2,33.42 46.02,33.42 47.09,32.35 49.18,32.35 49.89,31.63 50.63,31.63 51.28,30.98 52.74,30.98 53.69,30.03 53.69,29.97 55.8,27.86 55.8,26.69 57.08,25.4 57.08,24.76 57.36,24.48 58.41,24.48 60.34,22.55 62.24,22.55 63.1,21.69 63.1,21.16 63.33,20.93 63.86,20.93 63.94,20.86 64.92,20.86 65.58,20.2 67.39,20.2 67.76,20.57 70.43,20.57 70.83,20.97 71.3,20.97 71.92,20.35 75.97,20.35 76.46,20.83 76.46,21.77 77.15,22.46 79.21,24.53 80.16,24.53 81.07,25.44 82.62,25.44 83.04,25.86 84.19,25.86 85.27,24.78 87.32,24.78 87.47,24.93 90.49,24.93 92.96,27.4 92.96,27.87 93.97,28.89 95.37,28.89 95.61,28.64 96.98,28.64 97.66,29.32 101.21,29.32 102.75,27.78 110.23,27.78 111.44,28.99 151.82,28.99 152.13,29.29 165.91,29.29 166.2,29.58 167.6,29.58 168.03,30.01 178.71,30.01 179.2,29.53 179.2,29.14 181.27,27.07 187.28,27.07 187.74,26.62 189.61,26.62 190.39,25.84 192.27,25.84 193.19,24.92 195.74,24.92 196.31,24.35 196.31,23.51 197.45,22.37 197.45,21.86 198.49,20.82 200.34,20.82 200.67,20.49 203.85,20.49 205.78,18.56 205.78,18.53 v1(205.91,18.41)
PCH_BLON_EC: length 211.7
  TOP w0.14: v1(86.26,30.32) 86.17,30.22 U18.88 ; v1(180.33,114.21) 181.03,114.21 181.38,113.86 R89.1
  IN3 w0.089: v1(180.79,53.01) 180.5,53.3 180.5,54.36 180.91,54.78 180.91,60.16 180.21,60.86 180.21,62.63 179.88,62.96 179.88,64.46 175.25,69.08 175.25,83.51 178.12,86.38 178.12,86.84 180.05,88.78 180.05,95.16 178.82,96.4 178.82,102.05 178.06,102.8 178.06,105.95 179.87,107.76 179.87,112.59 180.33,113.05 v1(180.33,114.21)
  IN4 w0.086: v1(85.87,42.56) 86.42,42.01 87.85,42.01 89.98,39.88 91.59,39.88 92,39.47 95.86,39.47 96.79,40.4 98.35,40.4 99.43,41.48 99.43,43.83 100.15,44.55 100.15,49.56 101.84,51.25 101.84,55.38 102.71,56.25 103.69,56.25 103.95,56.51 103.95,56.84 103.62,57.17 102.83,57.17 102.35,57.66 102.35,63.55 103.61,64.81 111.01,64.81 111.22,65.03 115.55,65.03 117.93,67.41 162.05,67.41 171.66,57.8 172.9,57.8 177.62,53.07 180.73,53.07 v1(180.79,53.01)
  BOTTOM w0.14: v1(85.87,42.56) 85.64,42.33 85.64,41.89 85.29,41.54 85.29,41.12 84.91,40.73 84.91,39.83 85.29,39.44 85.29,38.53 86.4,37.42 86.4,34.89 85.74,34.23 85.74,30.84 v1(86.26,30.32)
PCH_BRIGHT: length 37.8
  TOP w0.14: Q15.3 178.8,105.84 R100.2 180.93,105.84 v1(181.13,106.05) 182.25,107.17 182.25,130 181.17,131.08 179.97,131.08 R45.2 178.93,132.12 177.8,132.12 R44.2 176.57,130.88 v1(176.57,130.69)
  BOTTOM w0.14: v1(176.57,130.69) 176.57,130.38 175.7,129.52 175.7,128.95 175.5,128.75 CN10.34
PCH_DISP_ON: length 157.6
  TOP w0.14: v1(224.37,28.09) 224.37,27.73 U14.AV44
  IN2 w0.102: v1(224.37,28.09) 224.38,28.07 224.38,27.67 224.63,27.41 227.04,27.41 227.36,27.74 231.64,27.74 232.81,28.91 232.81,34.2 235.2,36.59 235.2,38.5 236.59,39.89 236.59,40.77 234.37,42.99 233.41,42.99 233.11,43.28 233.11,43.99 229.87,47.24 225.22,47.24 223.25,49.21 221.01,49.21 217.39,52.83 205.48,52.83 203.14,55.17 v1(203.14,56.16)
  IN3 w0.089: v1(203.14,56.16) 200.84,58.46 197.48,58.46 195.52,60.42 192.27,60.42 188.05,56.2 188.05,55.46 188.99,54.52 188.99,50.8 188.57,50.37 184.42,50.37 182.7,52.09 182.7,52.82 182.33,53.19 181.45,53.19 180.88,53.76 180.88,54.21 181.29,54.62 181.29,59.94 182.09,60.74 182.09,61.61 181.19,62.51 180.87,62.51 180.26,63.12 180.26,64.64 175.63,69.26 175.63,83.36 178.5,86.22 178.5,86.68 180.63,88.81 180.63,95.57 179.46,96.74 179.46,102.57 179,103.04 v1(179,103.64)
  BOTTOM w0.14: R698.1 178.24,104.94 178.24,103.91 178.51,103.64 v1(179,103.64)
PCH_DMICCLK: length 137.6
  TOP w0.102: U14.BD16 210.58,24.56 210.58,24.26 210.76,24.08 210.76,23.79 210.44,23.46 210.33,23.46 209.98,23.11 209.98,22.88 209.89,22.79 209.89,22.32 v1(210.08,22.12)
  IN2 w0.089: v1(210.08,22.12) 209.08,23.12 209.08,25.54 209.31,25.77 209.31,27.78 207.72,29.37 206.64,29.37 205.93,30.08 205.47,30.08 203.67,31.87 202.9,31.87 202.38,32.4 201.88,32.4 196.84,37.44 196.84,38.1 195.52,39.41 195.52,39.89 194.89,40.53 194.56,40.53 192.86,42.23 192.86,44.24 192.75,44.34 192.75,48.05 189.52,51.28 189.52,53.89 190.17,54.54 190.48,54.54 190.87,54.93 190.87,56.07 190.08,56.86 187.16,56.86 183.79,60.23 183.79,60.74 180.74,63.79 178.58,63.79 176.36,66.01 176.36,75.87 176.72,76.23 176.72,78.41 176.36,78.77 176.36,82.89 180.99,87.53 180.99,88.3 179.66,89.64 179.66,92.92 178.65,93.93 178.65,102.56 177.77,103.43 177.77,108.85 177.16,109.46 176.71,109.46 173.67,112.51 173.67,123.65 170.63,126.69 v1(170.22,126.69)
  BOTTOM w0.14: R691.2 171.53,126.15 170.76,126.15 v1(170.22,126.69)
PCH_DMICDAT: length 134.4
  TOP w0.102: U14.BF15 209.77,23.2 209.77,22.97 209.65,22.84 v1(209.65,21.68)
  IN2 w0.089: v1(170.99,125.67) 173.48,123.18 173.48,112.43 176.63,109.27 177.08,109.27 177.58,108.77 177.58,103.35 178.45,102.48 178.45,93.85 179.47,92.84 179.47,89.56 180.8,88.22 180.8,87.61 176.17,82.97 176.17,78.69 176.53,78.33 176.53,76.3 176.17,75.95 176.17,65.93 178.5,63.6 180.66,63.6 183.6,60.66 183.6,60.15 187.08,56.67 190,56.67 190.44,56.23 190.44,55.87 190.12,55.54 189.56,55.54 189.33,55.31 189.33,51.18 192.55,47.96 192.55,44.26 192.65,44.16 192.65,43.55 192.55,43.45 192.55,42.26 194.49,40.33 194.78,40.33 195.29,39.81 195.29,39.37 196.65,38.02 196.65,37.36 201.81,32.2 202.3,32.2 202.82,31.68 203.59,31.68 205.47,29.8 205.78,29.8 205.9,29.68 206.06,29.68 206.72,29.02 207.59,29.02 209.09,27.52 209.09,26.33 208.64,25.88 208.64,22.69 v1(209.65,21.68)
  BOTTOM w0.14: v1(170.99,125.67) 171.08,125.76 171.59,125.76 R692.2
PCH_DPST_PWM: length 147.9
  TOP w0.102: U14.AU48 226.8,28.15 227.41,28.15 227.7,28.44 227.7,28.82 227.88,29 228.52,29 228.87,28.64 v1(228.87,28.59)
  TOP w0.14: R45.1 v1(181.17,131.61)
  IN2 w0.089: v1(228.87,28.59) 228.5,28.97 226.59,28.97 225.98,29.58 225.37,29.58 224.66,28.87 223.98,28.87 223.43,28.32 223.14,28.32 222.47,28.99 220.34,28.99 220,29.33 220,31.5 218.93,32.57 218.93,33.58 219.26,33.92 219.26,34.43 219.46,34.63 219.46,35.24 219.59,35.37 219.59,37.24 219.26,37.57 218.99,37.57 218.46,38.09 216.3,38.09 213,41.39 213,43.99 211.93,45.07 211.93,47.4 207.15,52.18 205.21,52.18 201.32,56.07 199.75,56.07 196.75,59.07 195.1,59.07 193.56,60.61 192.33,60.61 191.78,61.15 190.99,61.15 189.89,62.26 188.45,62.26 185.93,64.77 185.93,65 180.21,70.72 180.21,83.53 183.44,86.76 183.44,88.99 181.94,90.49 181.94,104.94 181.01,105.87 181.01,111.61 182.12,112.73 182.12,130.66 v1(181.17,131.61)
  BOTTOM w0.14: v1(228.87,28.59) 229.2,28.91 v1(230.73,28.91) 230.84,29.03 230.84,29.31 231.37,29.84 232.16,29.84 232.62,30.29 R909.1
PCH_GPD7: length 15.1
  TOP w0.102: U14.BE41 223.18,24.7 v1(223.09,24.8)
  TOP w0.14: R533.2 231.98,16.96 R532.1 230.98,16.72 v1(230.6,16.35)
  IN1 w0.102: v1(230.6,16.35) 228.86,18.09 228.86,19.43 227.25,21.04 225.18,21.04 223.09,23.13 v1(223.09,24.8)
PCH_GPP_H15: length 9.3
  TOP w0.14: v1(225.74,34.65) 225.74,34.67 225.96,34.88 U14.AC47
  BOTTOM w0.14: R836.1 230.32,39.35 229.46,39.35 229.23,39.13 227.44,39.13 226.99,38.67 v1(226.99,38.47) 226.99,38.03 227.03,37.99 R850.2 227.03,37.33 226.35,36.65 226.35,35.11 225.89,34.65 v1(225.74,34.65)
PCH_JTAGX: length 10.8
  TOP w0.102: 200.63,35.67 200.73,35.58 200.73,34.34 201.98,33.09 202.55,33.09 202.82,33.36 203.79,33.36 204.07,33.08 204.48,33.08 204.88,32.68 U14.AH4
  TOP w0.14: 200.63,35.67 200.63,37.6 199.49,38.74 R248.1
PCH_LVDS_BLON: length 134.5
  TOP w0.14: R91.1 181.86,111.71 181.86,108.28 v1(181.6,108.02) ; U14.AV46 225.16,27.83 225.02,27.97 v1(225.02,27.98)
  IN2 w0.089: v1(181.6,108.02) 182.32,107.29 182.32,90.76 183.82,89.26 183.82,86.6 180.62,83.4 180.62,72.03 181.56,71.09 182.05,70.6 182.05,69.62 186.84,64.83 186.84,64.41 188.61,62.64 190.04,62.64 191.07,61.61 191.9,61.61 192.52,60.99 193.72,60.99 195.23,59.48 196.89,59.48
  IN2 w0.102: v1(225.02,27.98) 225.05,27.95 231.56,27.95 232.61,29 232.61,34.28 235,36.67 235,38.58 236.39,39.97 236.39,40.68 234.29,42.79 233.32,42.79 232.91,43.2 232.91,43.91 229.79,47.03 225.14,47.03 223.16,49.01 220.93,49.01 217.31,52.63 205.4,52.63 201.57,56.45 199.91,56.45 196.89,59.48
PCH_PECI: length 130.1
  TOP w0.089: 165.37,130.47 163.99,130.47 R52.1
  TOP w0.102: U14.AF2 204.13,33.31 203.87,33.56 202.74,33.56 202.47,33.3 202.06,33.3 200.94,34.42 200.94,37.64 200.61,37.96
  TOP w0.14: 165.37,130.47 166.11,130.47 166.73,129.84 168.18,129.84 v1(168.38,130.04) ; v1(191.03,45.74) 191.03,45.6 191.17,45.46 R193.2 191.7,45.18 191.88,45 192.43,45 193.25,44.18 193.25,43.49 193.9,42.83 193.9,42.32 194.39,41.84 195.28,41.84 196.93,40.19 198.55,40.19 198.75,39.99 199.13,39.99 199.42,39.7 199.42,39.16 200.61,37.96
  IN3 w0.089: v1(168.38,130.04) 168.22,129.88 168.22,121.81 168.67,121.35 168.67,119.85 168.33,119.5 168.33,111.83 169.2,110.96 169.81,110.96 171.74,109.03 171.74,94.67 170.84,93.76 170.84,91.58 171.47,90.95 171.47,86.34 169.97,84.84 169.97,81.04 170.77,80.24 170.77,66.82 172.63,64.97 172.63,62.9 175.19,60.34 175.19,58.67 175.64,58.22 175.85,58.22 177.92,56.15 177.92,54.35 178.61,53.66 178.61,49.11 181.63,46.09 183.56,46.09 184.96,47.49 185.64,47.49 187.19,45.94 190.82,45.94 v1(191.03,45.74)
PCH_PWROK: length 174.9
  TOP w0.14: v1(83.25,25.01) 83.25,25.16 84.31,26.22 U18.78
  IN4 w0.086: v1(83.25,25.01) 86.12,27.88 92.53,27.88 93.59,28.94 95.32,28.94 95.7,28.56 96.69,28.56 96.76,28.49 101.19,28.49 102.32,27.36 110.19,27.36 112.01,29.18 148.3,29.18 148.85,28.63 152.1,28.63 152.76,29.3 172.07,29.3 172.45,29.68 175.55,29.68 180.71,34.84 184.42,34.84 186.58,32.68 186.58,28.51 190.13,24.96 190.13,22.86 190.94,22.06 192.38,22.06 193.48,20.97 195.6,20.97 196.48,20.08 196.48,18.41 197.72,17.17 203.71,17.17 204.12,17.58 219.27,17.58 221.36,19.67 223.75,19.67 224.13,19.29 227.68,19.29 229.88,17.09 234.67,17.09 v1(234.89,17.31)
  BOTTOM w0.14: v1(234.89,17.31) 235.34,16.87 R1108.2
PCH_RSMRST#: length 11.7
  TOP w0.102: U14.BA47 226.56,26.25 226.9,26.25 227.08,26.43 227.34,26.43 227.5,26.28 229.41,26.28 v1(229.6,26.47)
  BOTTOM w0.14: v1(229.6,26.47) 230.26,26.47 230.44,26.29 R951.1 230.44,25.76 230.63,25.56 231.13,25.56 231.15,25.55 231.27,25.43 231.27,25.42 231.43,25.26 R965.1 231.43,24.25 v1(231.64,24.04) 232.15,23.54 234.6,23.54 R981.2
