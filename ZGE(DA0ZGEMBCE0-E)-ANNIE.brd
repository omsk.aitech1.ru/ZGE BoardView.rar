# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CKE2: length 81.2
  TOP w0.079: U3.AT3 146.46,106.46 147.06,106.46 147.2,106.33 147.2,102.63 v1(148.17,101.66)
  IN2 w0.14: v1(144.75,39.46) 145.06,39.77 145.06,40.48 146.45,41.87 146.45,44.35 146.85,44.75 147.67,44.75 147.95,45.03 147.95,45.73 147.48,46.2 147.48,47.69 149.36,49.57 149.36,50.77 149.55,50.95 149.55,58 150.11,58.57 150.11,63.27 150.63,63.79 150.63,76.43 150.49,76.58 150.27,76.58 150.13,76.72 150.13,77 150.27,77.14 151.04,77.14 151.18,77.28 151.18,77.56 151.04,77.7 150.27,77.7 150.13,77.84 150.13,78.11 150.27,78.25 151.04,78.25 151.18,78.39 151.18,78.67 151.04,78.81 150.4,78.81 150.26,78.96 150.26,79.23 150.4,79.37 151.04,79.37 151.18,79.51 151.18,79.79 151.04,79.93 150.77,79.93 150.63,80.07 150.63,80.51 152.01,81.89 152.01,93.34 150.23,95.12 150.23,96.85 148.64,98.45 148.64,101.2 v1(148.17,101.66)
  BOTTOM w0.102: v1(144.75,39.46) 144.17,38.88 JDIM4.109
M_A_CKE3: length 76.2
  TOP w0.089: v1(145.73,107.17) 145.86,107.17 U3.AT5
  IN2 w0.079: v1(145.73,107.17) 145.53,107.17 144.97,106.61 144.97,104.26 146.26,102.97 146.26,100.8 146.88,100.18 146.88,96.62 147.25,96.25
  IN2 w0.14: 147.25,96.25 147.25,94.2 148.44,93.01 148.44,83.58 146.58,81.72 146.58,75.42 146.44,75.28 145.92,75.28 145.78,75.14 145.78,74.86 145.92,74.72 146.44,74.72 146.58,74.58 146.58,74.3 146.44,74.16 145.92,74.16 145.78,74.02 145.78,73.74 145.92,73.6 146.44,73.6 146.58,73.46 146.58,73.18 146.44,73.04 145.92,73.04 145.78,72.9 145.78,72.62 145.92,72.48 146.44,72.48 146.58,72.34 146.58,72.06 146.44,71.92 145.92,71.92 145.78,71.78 145.78,71.5 145.92,71.36 146.44,71.36 146.58,71.23 146.58,70.95 146.44,70.81 145.92,70.81 145.78,70.67 145.78,70.39 145.92,70.25 146.44,70.25 146.58,70.11 146.58,69.83 146.44,69.69 145.92,69.69 145.78,69.55 145.78,69.27 145.92,69.13 146.44,69.13 146.58,68.99 146.58,68.71 146.44,68.57 145.92,68.57 145.78,68.43 145.78,68.15 145.92,68.01 146.44,68.01 146.58,67.87 146.58,67.47 146.45,67.34 145.89,67.34 145.69,67.14 145.69,63.79 145.99,63.5 145.99,59.67 144.87,58.56 144.87,55.62 144.26,55.01 144.26,50.49 143.29,49.51 v1(143.29,46.9)
  BOTTOM w0.102: v1(143.29,46.9) 143.58,46.9 143.92,46.55 JDIM4.110
M_A_CS#0: length 76.3
  TOP w0.079: U3.AD5 136.44,107.17 136.95,107.17 137.36,106.76 137.36,104.64 137.23,104.5 137.23,104.24 v1(137.74,103.73)
  TOP w0.216: JDIM2.149 134.07,46.61 133.91,46.77 132.69,46.77 131.66,47.8 131.26,47.8 130.73,48.32 v1(129.54,48.32)
  IN2 w0.079: v1(137.74,103.73) 137.83,103.73 138.18,103.37 138.18,101.04 138.37,100.85 138.37,98.64 137.89,98.16 137.89,97.51 137.92,97.48 137.92,96.62 137.81,96.51
  IN2 w0.14: 137.81,96.51 136.01,94.71 136.01,90.62 130.36,84.97 130.36,84.53 130.5,84.39 130.62,84.39 130.76,84.25 130.76,83.98 130.61,83.83 130.5,83.83 130.36,83.69 130.36,83.41 130.5,83.27 130.64,83.27 130.78,83.13 130.78,82.88 130.61,82.71 130.5,82.71 130.36,82.57 130.36,82.29 130.5,82.15 130.55,82.15 130.69,82.01 130.69,81.73 130.55,81.59 130.5,81.59 130.36,81.45 130.36,81.18 130.5,81.04 130.55,81.04 130.69,80.9 130.69,80.62 130.55,80.48 130.5,80.48 130.36,80.34 130.36,80.06 130.5,79.92 130.55,79.92 130.69,79.78 130.69,79.5 130.55,79.36 130.5,79.36 130.36,79.22 130.36,78.96 129.82,78.43 129.82,64.79 129.35,64.32 129.35,62.42 129.61,62.15 129.61,61.16 129.35,60.9 129.35,60.1 129.61,59.84 129.61,59.03 129.39,58.81 129.39,58.42 129.61,58.19 129.61,57.78 129.3,57.47 129.1,57.47 128.68,57.88 128.48,57.88 128.29,57.69 128.29,57.49 128.7,57.07 128.7,56.87 128.53,56.69 128.11,56.69 127.97,56.56 127.97,51.05 129.37,49.65 129.37,48.5 v1(129.54,48.32)
M_A_CS#1: length 80.3
  TOP w0.079: U3.AE2 136.58,105.26 136.58,102.12 137.58,101.11 v1(137.76,101.11)
  TOP w0.102: v1(128.3,47.68) 128.77,47.21 129.33,47.21 129.66,47.54 130.47,47.54 130.79,47.23 131.26,47.23 132.07,46.41 JDIM2.157
  IN2 w0.079: 137.1,97.53 137.1,98.67 137.38,98.95 137.38,100.74 v1(137.76,101.11)
  IN2 w0.14: 137.1,97.53 137.1,97.31 134.67,94.88 134.67,91.17 128.49,84.99 128.49,65.34 128.02,64.87 128.02,64.25 127.88,64.11 127.26,64.11 127.1,63.95 127.1,63.73 127.38,63.45 127.38,63.25 127.15,63.02 126.38,63.02 126.34,62.98 126.22,62.86 126.22,62.64 126.39,62.46 127.88,62.46 128.02,62.32 128.02,62.07 127.88,61.93 127.59,61.93 127.49,61.83 127.45,61.79 127.45,61.52 127.59,61.38 127.88,61.38 128.02,61.24 128.02,60.84 127.8,60.62 127.6,60.62 127.06,61.16 126.83,61.16 126.67,61 126.67,60.78 127.22,60.24 127.22,60.04 126.21,59.03 126.21,57.98 126.07,57.84 125.35,57.84 125.21,57.71 125.21,57.44 125.35,57.3 126.07,57.3 126.21,57.16 126.21,56.89 126.07,56.75 125.35,56.75 125.21,56.61 125.21,56.35 125.35,56.21 126.07,56.21 126.21,56.07 126.21,55.93 125.23,54.95 125.23,51.3 125.65,50.89 126.25,50.89 127.95,49.19 127.95,48.03 v1(128.3,47.68)
M_A_CS#2: length 81.1
  TOP w0.079: U3.AD2 136.41,105.25 136.41,101.83 v1(137.78,100.46)
  IN2 w0.079: 137.68,96.92 137.68,98.25 138.17,98.74 138.17,100.62 138.09,100.7 137.86,100.7 137.78,100.62 v1(137.78,100.46)
  IN2 w0.14: 137.68,96.92 135.56,94.8 135.56,90.81 129.91,85.16 129.91,84.79 129.75,84.62 129.52,84.62 129.38,84.48 129.38,84.18 129.52,84.04 129.77,84.04 129.91,83.9 129.91,83.62 129.77,83.48 129.52,83.48 129.38,83.34 129.38,83.06 129.52,82.92 129.77,82.92 129.91,82.78 129.91,82.5 129.77,82.36 129.52,82.36 129.38,82.22 129.38,81.94 129.52,81.8 129.77,81.8 129.91,81.66 129.91,81.38 129.77,81.24 129.52,81.24 129.38,81.1 129.38,80.83 129.52,80.69 129.77,80.69 129.91,80.55 129.91,80.27 129.77,80.13 129.52,80.13 129.38,79.99 129.38,79.71 129.52,79.57 129.77,79.57 129.91,79.43 129.91,79.15 129.77,79.01 129.52,79.01 129.38,78.87 129.38,64.98 128.9,64.5 128.9,58.94 127.1,57.13 127.1,51.3 128.93,49.47 128.93,48.31 129.51,47.73 129.51,46.47 130.77,45.21 130.77,44.29 131.14,43.92 131.14,40.89 132.46,39.58 v1(132.92,39.58)
  BOTTOM w0.102: JDIM4.149 132.17,38.83 v1(132.92,39.58)
M_A_CS#3: length 82.2
  TOP w0.089: U3.AE5 136.55,107.79 135.97,107.79 135.7,107.52 v1(135.7,107.2)
  IN2 w0.079: v1(135.7,107.2) 136.29,106.61 136.29,105.91 136.64,105.55 136.64,101.22 135.73,100.31 135.73,98.19 135.64,98.1
  IN2 w0.14: v1(129.13,41.9) 128.7,42.32 128.7,44.6 127.85,45.45 126.94,45.45 125.16,47.23 125.16,47.84 121.79,51.21 121.79,57.82 123.88,59.91 123.88,64.04 126.15,66.31 126.15,85.96 132.34,92.14 132.34,94.8 135.64,98.1
  BOTTOM w0.102: JDIM4.157 130.17,39.02 129.72,39.47 129.72,40.44 129.51,40.66 129.51,41.52 v1(129.13,41.9)
M_A_DIM0_CLKN0: length 82.3
  TOP w0.079: v1(142.86,97.96) 142.65,98.17 140.09,98.17 138.46,99.8 138.46,103.8 138.35,103.91 138.35,104.5 138.04,104.81 138.04,105.15 138.27,105.38 138.47,105.38 U3.AG2
  TOP w0.114: v1(138.12,47.4) 138.12,47.48 138.38,47.74 138.57,47.74 139.03,47.28 139.03,46.6 138.92,46.49 138.69,46.49 138.57,46.37 JDIM2.139
  IN2 w0.089: v1(138.12,47.4) 138.4,47.68 138.68,47.96 138.68,51.23 138.87,51.42 138.87,53.15 138.65,53.37 138.65,53.96 139.12,54.43 139.12,57.05 139.78,57.7 139.78,61.61 140.1,61.93 140.1,76.79 140.19,76.88 140.95,76.88 141.16,77.09 141.16,77.68 141.06,77.78 141.06,77.78 140.95,77.89 140.19,77.89 140.1,77.97 140.1,78.39 140.19,78.48 141.9,78.48 142.13,78.72 142.13,79.26 141.91,79.49 140.19,79.49 140.1,79.57 140.1,79.99 140.19,80.08 141.9,80.08 142.17,80.35 142.17,80.86 141.94,81.09 140.19,81.09 140.1,81.17 140.1,81.59 140.19,81.68 141.85,81.68 142.06,81.89 142.06,82.47 141.85,82.69 140.19,82.69 140.1,82.77 140.1,83.27 143.92,87.09 143.92,92.42 143.89,92.46 143.89,93.43 143.12,94.2 143.12,94.57 142.71,94.98 142.71,96.97 142.31,97.37 142.31,97.96 142.5,98.14 142.75,98.14 142.86,98.03 v1(142.86,97.96)
M_A_DIM0_CLKN1: length 79.8
  TOP w0.079: v1(143.07,100.36) 143.07,100.19 142.98,100.1 142.51,100.1 140.98,101.62 140.98,104.48 140.78,104.69 140.78,105.02 141,105.24 141.19,105.24 141.27,105.16 141.27,105.01 U3.AK1
  TOP w0.102: JDIM2.140 138.32,38.2 138.52,38.4 138.52,39.05 v1(138.18,39.39)
  IN2 w0.079: 142.98,93.48 142.98,93.49 142.11,94.36 142.11,96.65 141.75,97.01 141.75,99.27 142.63,100.15 142.86,100.15 v1(143.07,100.36)
  IN2 w0.089: 142.98,93.48 142.98,87.7 139.19,83.9 139.19,83.31 139.1,83.22 138.8,83.22 138.59,83.01 138.59,82.43 138.8,82.22 139.1,82.22 139.19,82.13 139.19,81.71 139.1,81.62 138.8,81.62 138.59,81.41 138.59,80.83 138.8,80.62 139.1,80.62 139.19,80.53 139.19,80.11 139.1,80.02 138.8,80.02 138.59,79.81 138.59,79.23 138.8,79.02 139.1,79.02 139.19,78.93 139.19,78.51 139.1,78.42 138.8,78.42 138.59,78.21 138.59,77.63 138.8,77.42 139.1,77.42 139.19,77.33 139.19,76.83 139.1,76.75 138.8,76.75 138.59,76.54 138.59,75.95 138.8,75.74 139.1,75.74 139.19,75.65 139.19,75.23 139.1,75.14 138.86,75.14 138.65,74.94 138.65,74.35 138.86,74.14 139.1,74.14 139.19,74.05 139.19,62.29 138.87,61.98 138.87,58.08 138.22,57.42 138.22,54.81 137.53,54.12 137.53,49.55 137.33,49.35 137.33,46.58 138.11,45.8 138.11,41.19 138.49,40.81 138.49,39.69 v1(138.18,39.39)
M_A_DIM0_CLKP0: length 82.3
  TOP w0.079: U3.AG1 138.71,104.96 138.71,105.14 138.63,105.22 138.33,105.22 138.21,105.09 138.21,104.88 138.51,104.57 138.51,103.98 138.63,103.87 138.63,99.87 140.16,98.34 142.83,98.34 142.91,98.42 142.91,98.57 v1(142.86,98.62)
  TOP w0.114: JDIM2.137 139.07,46.3 139.25,46.48 139.25,47.37 138.66,47.96 138.41,47.96 138.04,48.05 v1(138.04,48.05)
  IN2 w0.089: v1(138.04,48.05) 138.04,48.04 138.19,47.88 138.31,47.88 138.47,48.04 138.47,51.31 138.67,51.51 138.67,53.07 138.45,53.29 138.45,54.05 138.91,54.52 138.91,57.13 139.57,57.79 139.57,61.69 139.9,62.02 139.9,76.88 140.1,77.09 140.87,77.09 140.96,77.18 140.96,77.59 140.87,77.68 140.1,77.68 139.9,77.89 139.9,78.48 140.1,78.69 141.81,78.69 141.93,78.8 141.93,79.17 141.82,79.28 140.1,79.28 139.9,79.49 139.9,80.08 140.1,80.29 141.82,80.29 141.97,80.43 141.97,80.78 141.86,80.88 140.1,80.88 139.9,81.09 139.9,81.68 140.1,81.89 141.77,81.89 141.86,81.97 141.86,82.39 141.76,82.48 140.1,82.48 139.9,82.69 139.9,83.35 143.72,87.18 143.72,93.36 142.95,94.13 142.95,94.5 142.54,94.91 142.54,96.9 142.14,97.3 142.14,98.03 142.43,98.31 142.58,98.31 142.86,98.59 v1(142.86,98.62)
M_A_DIM0_CLKP1: length 79.8
  TOP w0.079: v1(143.07,99.7) 142.84,99.93 142.45,99.93 140.82,101.57 140.82,104.41 140.61,104.62 140.61,105.07 140.94,105.4 141.01,105.4 U3.AK2
  TOP w0.102: v1(138.96,39.39) 138.83,39.39 138.73,39.28 138.73,38.4 138.82,38.3 JDIM2.138
  IN2 w0.079: 143.15,93.54 142.27,94.42 142.27,96.71 141.9,97.08 141.9,99.2 142.69,99.99 143.03,99.99 143.11,99.9 143.11,99.74 v1(143.07,99.7)
  IN2 w0.089: v1(138.96,39.39) 138.88,39.39 138.69,39.58 138.69,40.9 138.31,41.28 138.31,45.88 137.53,46.66 137.53,49.26 137.73,49.46 137.73,54.03 138.42,54.72 138.42,57.34 139.08,57.99 139.08,61.9 139.39,62.21 139.39,74.14 139.18,74.34 138.94,74.34 138.85,74.43 138.85,74.85 138.94,74.94 139.18,74.94 139.39,75.15 139.39,75.74 139.18,75.94 138.89,75.94 138.8,76.03 138.8,76.45 138.89,76.54 139.18,76.54 139.39,76.75 139.39,77.41 139.18,77.62 138.89,77.62 138.8,77.71 138.8,78.13 138.89,78.22 139.18,78.22 139.39,78.43 139.39,79.01 139.18,79.22 138.89,79.22 138.8,79.31 138.8,79.73 138.89,79.82 139.18,79.82 139.39,80.03 139.39,80.61 139.18,80.82 138.89,80.82 138.8,80.91 138.8,81.33 138.89,81.42 139.18,81.42 139.39,81.63 139.39,82.21 139.18,82.42 138.89,82.42 138.8,82.51 138.8,82.93 138.89,83.02 139.18,83.02 139.39,83.23 139.39,83.82 143.19,87.62 143.19,92.42 143.15,92.46 143.15,93.54
M_A_DIM1_CLKN0: length 81.1
  TOP w0.079: U3.AK3 141.41,106.19 141.69,106.47 142.01,106.47 142.17,106.31 142.17,106.1 142.36,105.9 142.36,104.72 142.13,104.49 142.13,103.45 142.28,103.31 142.45,103.31 v1(142.68,103.54)
  IN2 w0.079: 139.84,94.32 139.84,97.04 139.76,97.12 139.76,99.38 140.84,100.45 140.84,102.02 142.12,103.31 142.45,103.31 v1(142.68,103.54)
  IN2 w0.089: v1(136.18,39.47) 136,39.66 135.72,39.66 135.47,39.91 135.47,43.51 135.3,43.68 135.3,45.01 134.48,45.83 134.48,46.75 134.15,47.08 134.15,47.36 133.68,47.84 133.68,50.59 133.01,51.26 133.01,54.34 133.32,54.65 133.32,57.49 133.59,57.76 134.09,57.76 134.26,57.93 134.26,58.49 133.97,58.79 133.97,59.71 134.52,60.26 134.52,66.62 134.73,66.82 135.19,66.82 135.28,66.91 135.28,67.33 135.19,67.42 134.73,67.42 134.52,67.63 134.52,68.22 134.73,68.42 135.15,68.42 135.24,68.51 135.24,68.93 135.15,69.02 134.73,69.02 134.52,69.23 134.52,83.86 139.72,89.06 139.72,94.2 139.84,94.32
  BOTTOM w0.102: v1(136.18,39.47) 136.18,39.48 136.18,39.62 136.28,39.72 136.65,39.72 137.06,39.32 137.06,38.48 136.96,38.38 136.76,38.38 136.67,38.29 JDIM4.139
M_A_DIM1_CLKN1: length 80.1
  TOP w0.079: v1(142.69,102.07) 142.69,101.73 142.61,101.65 142.29,101.65 141.6,102.34 141.6,105.12 141.68,105.2 141.86,105.2 141.94,105.12 141.94,104.94 U3.AL1
  IN2 w0.079: v1(142.69,102.07) 142.47,101.85 141.62,101.85 141.29,101.52 141.29,100.34 140.18,99.23 140.18,98.3 140.31,98.16 140.31,93.42
  IN2 w0.089: v1(134.85,47.39) 134.85,47.65 134.38,48.12 134.38,50.87 134.25,51.01 134.25,55.32 134.48,55.55 134.48,56.34 135.18,57.04 135.18,57.9 135.24,57.96 135.24,65.22 135.47,65.45 135.89,65.45 135.97,65.54 135.97,69.71 135.88,69.81 135.44,69.81 135.24,70.02 135.24,70.6 135.44,70.81 135.98,70.81 136.07,70.9 136.07,71.32 135.98,71.41 135.44,71.41 135.24,71.62 135.24,72.28 135.44,72.49 135.98,72.49 136.07,72.58 136.07,73 135.98,73.08 135.44,73.08 135.24,73.29 135.24,73.88 135.44,74.09 135.98,74.09 136.07,74.18 136.07,74.6 135.98,74.68 135.44,74.68 135.24,74.89 135.24,75.48 135.44,75.69 135.98,75.69 136.07,75.78 136.07,76.2 135.98,76.28 135.44,76.28 135.24,76.49 135.24,77.08 135.44,77.29 135.98,77.29 136.07,77.38 136.07,77.8 135.98,77.89 135.44,77.89 135.24,78.09 135.24,78.68 135.44,78.89 135.98,78.89 136.07,78.98 136.07,79.4 135.98,79.49 135.43,79.49 135.22,79.69 135.22,80.28 135.43,80.49 135.98,80.49 136.07,80.58 136.07,81 135.98,81.09 135.44,81.09 135.22,81.3 135.22,81.88 135.43,82.09 135.98,82.09 136.07,82.18 136.07,82.6 135.98,82.69 135.44,82.69 135.24,82.89 135.24,83.56 140.43,88.75 140.43,93.31 140.31,93.42
  BOTTOM w0.114: JDIM4.140 136.42,46.5 136.5,46.58 136.65,46.58 136.71,46.64 136.71,47.04 136.02,47.73 135.07,47.73 134.85,47.5 v1(134.85,47.39)
M_A_DIM1_CLKP0: length 81
  TOP w0.079: v1(142.68,102.78) 142.68,103.07 142.61,103.14 142.21,103.14 141.97,103.38 141.97,104.56 142.2,104.79 142.2,105.83 142.15,105.89 141.6,105.89 141.52,105.96 141.52,106.06 141.65,106.19 U3.AL3
  IN2 w0.079: 139.98,94.23 140,94.24 140,97.1 139.91,97.18 139.91,99.31 140.99,100.39 140.99,101.96 142.19,103.15 142.74,103.15 142.82,103.07 142.82,102.86 142.75,102.78 v1(142.68,102.78)
  IN2 w0.089: 139.98,94.23 139.89,94.13 139.89,92.46 139.92,92.42 139.92,88.97 134.72,83.77 134.72,69.31 134.81,69.22 135.23,69.22 135.44,69.02 135.44,68.43 135.23,68.22 134.81,68.22 134.72,68.13 134.72,67.71 134.81,67.62 135.27,67.62 135.48,67.42 135.48,66.83 135.27,66.62 134.81,66.62 134.72,66.53 134.72,60.18 134.17,59.62 134.17,58.87 134.46,58.58 134.46,57.84 134.17,57.56 133.67,57.56 133.52,57.41 133.52,54.57 133.21,54.26 133.21,51.34 133.88,50.68 133.88,47.92 134.35,47.45 134.35,47.16 134.68,46.83 134.68,45.91 135.51,45.09 135.51,43.76 135.68,43.6 135.68,39.99 135.8,39.86 136.08,39.86 136.18,39.97 v1(136.18,40.12)
  BOTTOM w0.102: JDIM4.137 137.17,38.31 137.26,38.4 137.26,39.4 136.74,39.93 136.38,39.93 v1(136.18,40.12)
M_A_DIM1_CLKP1: length 80
  TOP w0.079: v1(142.69,101.25) 142.45,101.5 142.21,101.5 141.44,102.27 141.44,105.19 141.61,105.37 141.72,105.37 U3.AL2
  IN2 w0.079: 140.48,93.5 140.48,98.22 140.33,98.36 140.33,99.17 141.45,100.28 141.45,101.45 141.69,101.7 142.76,101.7 142.88,101.57 142.88,101.35 142.79,101.25 v1(142.69,101.25)
  IN2 w0.089: 140.48,93.5 140.59,93.38 140.59,92.46 140.63,92.42 140.63,88.66 135.44,83.47 135.44,82.98 135.53,82.89 136.06,82.89 136.27,82.68 136.27,82.09 136.06,81.89 135.51,81.89 135.42,81.8 135.42,81.39 135.52,81.29 136.06,81.29 136.27,81.08 136.27,80.49 136.06,80.29 135.51,80.29 135.42,80.2 135.42,79.78 135.51,79.69 136.06,79.69 136.27,79.48 136.27,78.89 136.06,78.69 135.53,78.69 135.44,78.6 135.44,78.18 135.53,78.09 136.06,78.09 136.27,77.88 136.27,77.29 136.06,77.08 135.53,77.08 135.44,77 135.44,76.58 135.53,76.49 136.06,76.49 136.27,76.28 136.27,75.69 136.06,75.48 135.53,75.48 135.44,75.4 135.44,74.98 135.53,74.89 136.06,74.89 136.27,74.68 136.27,74.09 136.06,73.88 135.53,73.88 135.44,73.8 135.44,73.38 135.53,73.29 136.06,73.29 136.27,73.08 136.27,72.49 136.06,72.28 135.53,72.28 135.44,72.2 135.44,71.7 135.53,71.61 136.06,71.61 136.27,71.4 136.27,70.82 136.06,70.61 135.53,70.61 135.44,70.52 135.44,70.1 135.53,70.01 135.96,70.01 136.18,69.8 136.18,65.46 135.97,65.25 135.55,65.25 135.44,65.14 135.44,57.88 135.38,57.82 135.38,56.96 134.68,56.26 134.68,55.47 134.45,55.24 134.45,51.09 134.59,50.96 134.59,48.2 134.76,48.03 134.9,48.03 134.99,48.12 v1(134.99,48.26)
  BOTTOM w0.114: JDIM4.138 136.92,47.13 136.11,47.95 135.3,47.95 v1(134.99,48.26)
M_A_DQ0: length 98.3
  TOP w0.079: 160.67,108.19 160.49,108.01 159.96,108.01 159.89,108.08 U3.BR6
  TOP w0.089: 160.67,108.19 161.19,108.19 161.55,107.83 v1(161.55,107.72)
  TOP w0.102: v1(171.51,43.76) 171.12,43.76 170.99,43.89 170.99,44.17 171.14,44.32 171.42,44.32 171.57,44.48 JDIM2.7
  IN2 w0.079: 165.74,107.6 163.86,107.6 162.74,106.48 162.38,106.48 161.55,107.31 v1(161.55,107.72)
  IN2 w0.127: 165.74,107.6 168.05,107.6 173.22,102.43 173.22,95.57 167.97,90.32 167.97,71.48 171.69,67.76 171.69,60.63 176.85,55.47 176.85,53 176.6,52.75 176.6,52.23 176.85,51.98 176.85,51.8 176.68,51.63 176.5,51.63 176.27,51.86 175.94,51.86 175.82,51.73 175.82,51.55 176.23,51.14 176.23,50.96 176.07,50.8 175.89,50.8 175.36,51.33 175.18,51.33 175,51.15 175,50.97 175.44,50.53 175.44,50.3 175.29,50.14 175.11,50.14 174.64,50.61 174.46,50.61 174.2,50.35 174.2,50 174.33,49.87 174.68,49.87 174.81,49.74 174.81,49.49 174.68,49.36 174.33,49.36 174.2,49.23 174.2,48.98 174.33,48.85 174.95,48.85 175.07,48.73 175.07,48.49 174.93,48.35 174.33,48.35 174.2,48.22 174.2,47.96 174.33,47.84 174.95,47.84 175.07,47.71 175.07,47.47 174.93,47.33 174.33,47.33 174.2,47.2 174.2,45.67 173.96,45.43 173.07,45.43 172.94,45.3 172.94,44.41 172.8,44.28 172.6,44.28 172.41,44.47 172.04,44.47 171.51,43.94 v1(171.51,43.76)
  BOTTOM w0.102: v1(171.51,43.76) 171.51,43.93 171.35,44.08 170.64,44.08 170.42,44.3 JDIM4.4
M_A_DQ1: length 100.3
  TOP w0.089: v1(164.31,106.32) 164.89,106.9 164.89,108.85 164.75,108.99 164.33,108.99 164.1,108.77 164.1,108.32 163.92,108.14 162.19,108.14 161.74,108.58 160.32,108.58 U3.BT6
  TOP w0.102: JDIM2.16 169.32,39.02 167.82,40.52 v1(167.75,40.52)
  IN2 w0.127: v1(167.75,40.52) 167.75,41.92 169.5,43.66 169.5,44.02 172.73,47.26 172.73,50.96 175.39,53.62 175.39,54.86 171.78,58.47 171.41,58.47 170.23,59.65 170.23,65.87 169.83,66.26 169.49,66.26 169.29,66.46 169.29,66.8 169.19,66.91 169.01,66.91 168.6,66.5 168.42,66.5 168.24,66.68 168.24,66.86 168.53,67.16 168.53,67.35 168.37,67.51 168.17,67.51 167.88,67.22 167.7,67.22 167.52,67.4 167.52,67.58 167.8,67.86 167.8,68.04 167.64,68.2 167.42,68.2 167.16,67.94 166.98,67.94 166.8,68.12 166.8,68.3 167.21,68.71 167.21,68.88 167.02,69.07 166.5,69.07 166.37,69.2 166.37,90.81 171.76,96.2 171.76,101.82 167.46,106.12 165.09,106.12 164.5,106.12 v1(164.31,106.32)
  BOTTOM w0.102: v1(167.75,40.52) 167.44,40.52 166.17,39.25 JDIM4.21
M_A_DQ2: length 97.4
  TOP w0.089: U3.BP3 159.2,106.65 159.85,106.65 159.92,106.57 160.52,106.57 160.65,106.44 160.92,106.44 161.32,106.05 v1(161.32,105.55)
  TOP w0.102: v1(167.36,39.38) 167.76,39.38 168.32,38.81 JDIM2.20
  IN2 w0.079: v1(161.32,105.55) 161.41,105.65 162.95,105.65 164.02,106.72 164.47,106.72 164.72,106.47 166.87,106.47
  IN2 w0.127: 166.87,106.47 167.61,106.47 172.11,101.97 172.11,96.05 166.73,90.67 166.73,69.87 166.98,69.62 167.16,69.62 167.62,70.08 167.8,70.08 167.98,69.9 167.98,69.73 167.52,69.26 167.52,69.08 167.7,68.9 167.88,68.9 168.34,69.37 168.52,69.37 168.7,69.19 168.7,69.01 168.23,68.54 168.23,68.36 169.12,67.47 170.58,66.02 170.58,60.17 175.74,55.01 175.74,53.46 173.09,50.8 173.09,47.11 169.85,43.87 169.85,43.52 168.17,41.83 168.17,39.51 167.96,39.3 167.44,39.3 v1(167.36,39.38)
  BOTTOM w0.102: JDIM4.17 167.17,38.36 167.27,38.46 167.27,38.63 166.92,38.98 166.92,39.12 167.18,39.38 v1(167.36,39.38)
M_A_DQ3: length 98
  TOP w0.089: U3.BR3 160.04,105.8 160.35,105.8 160.99,105.16 161.74,105.16 162.54,105.96 v1(162.54,106.87)
  TOP w0.102: v1(171.21,42.62) 171.24,42.65 172.23,42.65 172.57,43 JDIM2.3
  IN2 w0.079: 165.39,107.95 163.63,107.95 v1(162.54,106.87)
  IN2 w0.127: v1(171.21,42.62) 171.99,42.62 172.57,43.2 172.57,43.54 174.82,45.79 174.82,46.69 175.48,47.34 175.48,47.94 176.13,48.6 176.13,50.37 176.29,50.53 176.52,50.53 176.65,50.4 176.65,49.28 176.82,49.11 177.01,49.11 177.2,49.3 177.2,55.62 172.04,60.78 172.04,67.91 168.33,71.62 168.33,90.18 173.57,95.42 173.57,102.58 168.2,107.95 165.39,107.95
  BOTTOM w0.102: JDIM4.8 169.42,44.48 170.66,43.24 171.05,43.24 171.21,43.08 v1(171.21,42.62)
M_A_DQ4: length 98.6
  TOP w0.089: v1(163.71,108.7) 163.66,108.65 162.01,108.65 161.89,108.77 160.4,108.77 160.36,108.8 160.06,108.8 159.94,108.68 158.96,108.68 158.58,108.3 158.58,107.84 U3.BN5
  TOP w0.102: JDIM2.8 171.32,38.19 171.59,38.46 171.59,38.97 v1(171.11,39.46)
  IN2 w0.127: v1(163.71,108.7) 164.25,109.24 166.01,109.24 166.54,108.7 168.45,108.7 174.28,102.87 174.28,95.13 169.04,89.88 169.04,71.92 172.75,68.2 172.75,61.07 177.92,55.91 177.92,48.78 175.83,46.69 175.83,40.77 174.76,39.71 171.36,39.71 v1(171.11,39.46)
  BOTTOM w0.102: v1(171.11,39.46) 170.74,39.09 170.74,38.38 170.67,38.31 JDIM4.3
M_A_DQ5: length 100.5
  TOP w0.079: U3.BP6 159.15,108.45 159.82,108.45 160.09,108.19 160.34,108.19 160.53,108.38 160.55,108.38
  TOP w0.089: 160.55,108.38 161.63,108.38 162.14,107.88 163.99,107.88 164.51,108.39 v1(164.51,108.6)
  TOP w0.102: v1(171.1,40.1) 171.98,40.1 172.45,39.64 172.45,39.33 172.21,39.09 172.21,38.52 172.32,38.4 JDIM2.4
  IN2 w0.127: v1(164.51,108.6) 164.66,108.45 164.84,108.45 164.99,108.6 164.99,108.75 165.12,108.88 165.47,108.88 165.6,108.75 165.6,108.43 165.73,108.31 168.34,108.31 173.93,102.72 173.93,95.27 168.68,90.03 168.68,71.77 172.4,68.06 172.4,60.93 177.56,55.76 177.56,48.92 175.47,46.84 175.47,40.92 174.61,40.06 171.14,40.06 v1(171.1,40.1)
  BOTTOM w0.102: JDIM4.7 169.67,38.18 169.51,38.34 169.51,39.37 170.24,40.1 v1(171.1,40.1)
M_A_DQ6: length 98.2
  TOP w0.089: v1(164.64,105.48) 163.17,104.01 159.4,104.01 158.85,104.56 158.79,104.56 158.59,104.75 158.59,105.44 U3.BP2
  TOP w0.102: v1(167.69,42.62) 167.9,42.62 169.07,43.8 JDIM2.17
  IN2 w0.079: 166.54,105.76 165.18,105.76 164.9,105.48 v1(164.64,105.48)
  IN2 w0.127: 166.54,105.76 167.31,105.76 171.4,101.68 171.4,96.35 166.01,90.96 166.01,68.32 167.99,66.34 168.43,65.9 169.69,65.9 169.87,65.72 169.87,65.42 169.74,65.29 168.21,65.29 168.07,65.15 168.07,64.91 168.2,64.78 169.74,64.78 169.87,64.66 169.87,64.4 169.74,64.28 168.21,64.28 168.07,64.14 168.07,63.89 168.2,63.77 169.74,63.77 169.87,63.64 169.87,63.39 169.74,63.26 169.26,63.26 169.14,63.13 169.14,62.88 169.26,62.75 169.74,62.75 169.87,62.62 169.87,58.74 170.92,57.69 170.92,50.74 171.26,50.4 171.62,50.4 172.37,49.65 172.37,47.4 169.14,44.17 169.14,43.81 167.95,42.62 v1(167.69,42.62)
  BOTTOM w0.102: JDIM4.20 166.42,43.89 v1(167.69,42.62)
M_A_DQ7: length 97.6
  TOP w0.089: v1(163.32,105.45) 162.23,104.35 159.68,104.35 159.3,104.73 159.27,104.96 159.27,105.22 159.19,105.3 159.19,105.7 159.14,105.9 159.04,106.04 158.45,106.15 U3.BN3
  TOP w0.102: JDIM2.21 168.07,44.35 168.24,44.18 168.24,43.6 167.9,43.26 v1(167.71,43.26)
  IN2 w0.079: 166.44,105.41 165.27,105.41 164.96,105.1 163.67,105.1 v1(163.32,105.45)
  IN2 w0.127: v1(167.71,43.26) 168.31,43.86 168.31,44.11 171.86,47.66 171.86,49.3 171.51,49.65 170.96,49.65 170.56,50.04 170.56,56.78 169.51,57.83 169.51,58.86 169.39,58.98 168.62,58.98 168.49,59.11 168.49,59.36 168.62,59.49 169.39,59.49 169.51,59.62 169.51,59.87 169.39,60 167.85,60 167.72,60.13 167.72,60.38 167.85,60.51 169.39,60.51 169.51,60.63 169.51,60.89 169.39,61.01 167.85,61.01 167.72,61.14 167.72,61.4 167.85,61.52 169.39,61.52 169.51,61.65 169.51,61.9 169.37,62.04 167.85,62.04 167.72,62.17 167.72,62.42 167.85,62.55 168.64,62.55 168.78,62.69 168.78,62.91 168.63,63.06 167.85,63.06 167.72,63.19 167.72,66.11 165.66,68.17 165.66,91.11 171.04,96.49 171.04,101.51 167.14,105.41 166.44,105.41
  BOTTOM w0.102: JDIM4.16 167.42,44.45 167.27,44.3 167.27,43.54 167.56,43.26 v1(167.71,43.26)
M_A_DQ8: length 90.7
  TOP w0.089: U3.BL4 156.9,106.84 v1(156.58,106.51)
  TOP w0.102: v1(165.82,39.46) 165.86,39.43 165.94,39.43 166.19,39.17 166.19,38.45 166.32,38.32 JDIM2.28
  IN2 w0.079: 166.44,104.62 160.62,104.62 159.35,105.89 157.2,105.89 v1(156.58,106.51)
  IN2 w0.127: v1(165.82,39.46) 165.79,39.46 165.37,39.88 165.37,40.67 166.73,42.03 166.73,43.13 166.9,43.31 166.9,44.23 169.41,46.73 169.41,47.32 169.09,47.63 169.09,50.8 169.78,51.49 169.78,51.84 169.65,51.97 169.22,51.97 169.09,52.09 169.09,52.35 169.22,52.48 169.65,52.48 169.78,52.6 169.78,56.46 166.93,59.3 166.93,65.78 164.87,67.84 164.87,91.43 170.26,96.82 170.26,101.18 166.82,104.62 166.44,104.62
  BOTTOM w0.102: v1(165.82,39.46) 165.17,38.82 JDIM4.25
M_A_DQ9: length 92.3
  TOP w0.089: U3.BL5 156.9,107.49 v1(156.58,107.16)
  TOP w0.102: v1(165.81,40.1) 165.84,40.07 166.25,40.07 166.92,39.4 166.92,39.02 167.26,38.68 167.26,38.32 167.32,38.25 JDIM2.24
  IN2 w0.079: 166.44,104.97 165.21,104.97 165.13,104.89 160.71,104.89 159.42,106.18 157.56,106.18 v1(156.58,107.16)
  IN2 w0.127: 166.44,104.97 166.96,104.97 170.61,101.33 170.61,96.67 165.23,91.29 165.23,67.99 167.29,65.93 167.29,59.45 170.13,56.61 170.13,50.99 169.84,50.7 169.84,49.24 170.47,48.61 170.47,47.29 167.26,44.08 167.26,43.16 167.08,42.98 167.08,41.88 165.81,40.6 v1(165.81,40.1)
  BOTTOM w0.102: v1(165.81,40.1) 165.47,40.1 164.17,38.8 JDIM4.29
M_A_DQ10: length 91
  TOP w0.089: U3.BL2 157.02,104.81 157.27,104.56 157.72,104.56 158.75,103.53 158.75,103.08 159.37,102.46 v1(159.65,102.46)
  TOP w0.102: JDIM2.37 164.07,43.74 162.98,42.64 v1(162.5,42.64)
  IN2 w0.079: 160.29,99.74 160.29,101.42 159.65,102.06 v1(159.65,102.46)
  IN2 w0.127: v1(162.5,42.64) 163.3,43.44 163.3,45.75 165.3,47.75 165.3,49.42 165.43,49.54 165.68,49.54 165.8,49.67 165.8,49.92 165.68,50.05 165.43,50.05 165.3,50.18 165.3,50.43 165.43,50.56 165.68,50.56 165.8,50.69 165.8,50.94 165.68,51.07 165.43,51.07 165.3,51.19 165.3,57.02 163.86,58.47 163.86,59.21 162.85,60.23 162.85,66.27 162.31,66.8 162.31,83.45 162.18,83.58 161.31,83.58 161.18,83.71 161.18,83.96 161.31,84.09 162.18,84.09 162.31,84.21 162.31,84.47 162.18,84.6 161.31,84.6 161.18,84.72 161.18,84.98 161.31,85.1 162.18,85.1 162.31,85.23 162.31,85.48 162.18,85.61 161.31,85.61 161.18,85.74 161.18,85.99 161.31,86.12 162.18,86.12 162.31,86.25 162.31,86.5 162.18,86.63 161.31,86.63 161.18,86.75 161.18,87.01 161.31,87.14 162.18,87.14 162.31,87.26 162.31,87.52 162.18,87.64 161.31,87.64 161.18,87.77 161.18,88.02 161.31,88.15 162.18,88.15 162.31,88.28 162.31,88.53 162.18,88.66 161.31,88.66 161.18,88.79 161.18,89.04 161.31,89.17 162.18,89.17 162.31,89.29 162.31,89.55 162.18,89.68 161.31,89.68 161.18,89.8 161.18,90.06 161.31,90.18 162.18,90.18 162.31,90.31 162.31,90.56 162.18,90.69 161.31,90.69 161.15,90.85 161.15,96.32 160.29,97.19 160.29,99.74
  BOTTOM w0.102: v1(162.5,42.64) 162.1,42.64 161.03,43.72 161.03,44.43 160.92,44.53 JDIM4.42
M_A_DQ11: length 88.3
  TOP w0.089: U3.BM1 157.7,104.89 159.18,103.41 v1(159.18,103.3)
  TOP w0.102: v1(162.52,43.28) 162.62,43.28 163.07,43.73 JDIM2.41
  IN2 w0.079: v1(159.18,103.3) 158.81,102.93 158.81,102.51 159.93,101.39 159.93,99.74
  IN2 w0.127: v1(162.52,43.28) 162.94,43.7 162.94,45.89 164.95,47.9 164.95,50.77 164.82,50.9 164.7,50.9 164.57,51.03 164.57,51.28 164.7,51.41 164.82,51.41 164.95,51.53 164.95,56.88 163.5,58.32 163.5,59.07 162.49,60.08 162.49,66.12 161.96,66.65 161.96,74.84 161.83,74.97 160.92,74.97 160.8,75.1 160.8,75.35 160.92,75.48 161.83,75.48 161.96,75.6 161.96,75.86 161.83,75.99 160.92,75.99 160.8,76.11 160.8,76.37 160.92,76.49 161.83,76.49 161.96,76.62 161.96,76.87 161.83,77 160.92,77 160.8,77.13 160.8,77.38 160.92,77.51 161.83,77.51 161.96,77.64 161.96,77.89 161.83,78.02 160.92,78.02 160.8,78.14 160.8,78.4 160.92,78.53 161.83,78.53 161.96,78.65 161.96,78.91 161.83,79.03 160.92,79.03 160.8,79.16 160.8,79.41 160.92,79.54 161.83,79.54 161.96,79.67 161.96,79.92 161.83,80.05 160.92,80.05 160.8,80.18 160.8,80.43 160.92,80.56 161.83,80.56 161.96,80.68 161.96,80.94 161.83,81.07 160.92,81.07 160.8,81.19 160.8,81.45 160.92,81.57 161.83,81.57 161.96,81.7 161.96,81.95 161.83,82.08 160.92,82.08 160.8,82.21 160.8,82.46 160.92,82.59 161.83,82.59 161.96,82.72 161.96,82.97 161.83,83.1 160.92,83.1 160.8,83.22 160.8,96.17 159.93,97.04 159.93,99.74
  BOTTOM w0.102: v1(162.52,43.28) 161.92,43.87 JDIM4.38
M_A_DQ12: length 91
  TOP w0.089: v1(155.79,106.51) U3.BK4
  TOP w0.102: v1(165.85,43.41) 166.26,43.82 166.26,44.23 166.07,44.42 JDIM2.29
  IN2 w0.079: v1(155.79,106.51) 155.79,105.78 157.01,104.56 159.84,104.56 160.49,103.91 166.49,103.91
  IN2 w0.127: v1(165.85,43.41) 166.19,43.75 166.19,44.52 167.76,46.09 167.76,47.34 168.33,47.91 168.33,56.9 165.68,59.54 165.68,61.04 165.56,61.17 164.79,61.17 164.66,61.3 164.66,61.55 164.79,61.68 165.33,61.68 165.47,61.82 165.47,62.02 165.31,62.18 164.79,62.18 164.66,62.31 164.66,62.57 164.79,62.69 165.33,62.69 165.47,62.83 165.47,63.03 165.31,63.2 164.79,63.2 164.66,63.33 164.66,63.58 164.79,63.71 165.33,63.71 165.47,63.85 165.47,64.05 165.31,64.22 164.79,64.22 164.66,64.34 164.66,64.6 164.79,64.72 165.33,64.72 165.47,64.86 165.47,65.07 165.31,65.23 164.79,65.23 164.66,65.36 164.66,65.61 164.79,65.74 165.33,65.74 165.47,65.88 165.47,66.08 165.31,66.25 164.79,66.25 164.66,66.38 164.66,67.02 164.16,67.52 164.16,91.73 169.55,97.12 169.55,100.88 166.52,103.91 166.49,103.91
  BOTTOM w0.102: v1(165.85,43.41) 165.27,43.99 165.27,44.42 165.42,44.57 JDIM4.24
M_A_DQ13: length 92.3
  TOP w0.089: v1(155.79,107.16) U3.BK5
  TOP w0.102: v1(165.87,42.78) 166.11,42.78 167.07,43.75 JDIM2.25
  IN2 w0.079: 166.44,104.26 160.62,104.26 160.03,104.85 157.22,104.85 156.18,105.89 156.18,106.77 v1(155.79,107.16)
  IN2 w0.127: v1(165.87,42.78) 166.55,43.46 166.55,44.37 168.12,45.94 168.12,47.2 168.68,47.76 168.68,57.05 166.04,59.69 166.04,60.05 166.17,60.17 166.45,60.17 166.58,60.3 166.58,60.55 166.45,60.68 166.17,60.68 166.04,60.81 166.04,61.06 166.17,61.19 166.45,61.19 166.58,61.32 166.58,61.57 166.45,61.7 166.17,61.7 166.04,61.82 166.04,62.08 166.17,62.21 166.45,62.21 166.58,62.33 166.58,62.59 166.45,62.71 166.17,62.71 166.04,62.84 166.04,63.09 166.17,63.22 166.45,63.22 166.58,63.35 166.58,63.6 166.45,63.73 166.17,63.73 166.04,63.86 166.04,64.11 166.17,64.24 166.45,64.24 166.58,64.36 166.58,64.62 166.45,64.75 166.17,64.75 166.04,64.87 166.04,65.13 166.17,65.25 166.45,65.25 166.58,65.38 166.58,65.63 166.45,65.76 166.17,65.76 166.04,65.89 166.04,66.14 164.52,67.67 164.52,91.58 169.9,96.97 169.9,101.03 166.67,104.26 166.44,104.26
  BOTTOM w0.102: v1(165.87,42.78) 164.42,44.22 JDIM4.28
M_A_DQ14: length 89.6
  TOP w0.089: v1(160.29,102.5) 159.86,102.07 159.43,102.07 158.48,103.03 158.48,103.51 157.6,104.39 157.12,104.39 U3.BK1
  TOP w0.102: v1(162.52,39.43) 162.96,39 162.96,38.35 162.82,38.22 JDIM2.42
  IN2 w0.079: 161,100.19 161,100.88 161.37,101.25 161.37,102.45 161.11,102.71 160.49,102.71 v1(160.29,102.5)
  IN2 w0.127: v1(162.52,39.43) 162.93,39.43 163.49,39.99 163.49,42.62 164.47,43.6 164.47,44.43 164.93,44.89 164.93,45.07 164.37,45.63 164.37,45.81 164.55,45.99 164.73,45.99 165.29,45.43 165.47,45.43 165.65,45.61 165.65,45.79 165.09,46.35 165.09,46.53 165.27,46.71 165.45,46.71 166.01,46.15 166.19,46.15 166.62,46.57 166.62,56.76 164.57,58.81 164.57,59.51 163.56,60.52 163.56,66.56 163.02,67.1 163.02,93.32 163.15,93.45 164.31,93.45 164.44,93.57 164.44,93.81 164.3,93.96 163.15,93.96 163.02,94.08 163.02,94.34 163.15,94.46 165.33,94.46 165.46,94.59 165.46,94.84 165.32,94.97 163.15,94.97 163.02,95.1 163.02,95.45 161,97.48 161,100.19
  BOTTOM w0.102: JDIM4.37 162.17,38.25 162.02,38.4 162.02,38.93 v1(162.52,39.43)
M_A_DQ15: length 91.6
  TOP w0.089: U3.BK2 155.95,105.3 155.95,104.08 158.55,101.48 160.54,101.48 160.9,101.83 v1(160.9,102.26)
  TOP w0.102: JDIM2.38 163.82,38.34 163.92,38.43 163.92,39.1 162.99,40.02 162.57,40.02 v1(162.52,40.07)
  IN2 w0.079: v1(160.9,102.26) 160.9,101.48 160.64,101.23 160.64,99.84
  IN2 w0.127: v1(162.52,40.07) 162.7,40.07 163.13,40.5 163.13,42.77 163.8,43.43 163.8,45.74 165.3,47.24 166.01,47.24 166.18,47.41 166.18,47.65 166.05,47.78 165.8,47.78 165.67,47.9 165.67,48.16 165.8,48.29 166.14,48.29 166.26,48.41 166.26,56.61 164.22,58.66 164.22,59.36 163.2,60.37 163.2,66.41 162.67,66.95 162.67,91.05 162.54,91.17 161.63,91.17 161.51,91.3 161.51,91.56 161.63,91.68 162.54,91.68 162.67,91.81 162.67,92.06 162.54,92.19 161.63,92.19 161.51,92.32 161.51,92.57 161.63,92.7 162.54,92.7 162.67,92.83 162.67,93.08 162.54,93.21 161.63,93.21 161.51,93.33 161.51,93.59 161.63,93.71 162.54,93.71 162.67,93.84 162.67,94.1 162.54,94.22 161.63,94.22 161.51,94.35 161.51,94.6 161.63,94.73 162.54,94.73 162.67,94.86 162.67,95.17 162.48,95.35 161.62,95.35 161.51,95.47 161.51,96.47 160.64,97.33 160.64,99.84
  BOTTOM w0.102: v1(162.52,40.07) 162.15,40.07 161.02,38.94 161.02,38.39 161.17,38.24 JDIM4.41
M_A_DQ16: length 81.7
  TOP w0.089: U3.BG4 154.66,106.84 154.75,106.75 154.75,105.37 154.98,105.14 154.98,104.7 154.55,104.27 154.55,103.85 155.04,103.35 155.17,103.22 v1(156.17,103.22)
  TOP w0.102: v1(160.54,40.02) 160.89,40.02 161.96,38.94 161.96,38.54 161.82,38.4 JDIM2.46
  IN2 w0.079: v1(156.17,103.22) 156.66,103.22 157.43,102.46 158.15,102.46 159.14,101.46 159.14,100.51
  IN2 w0.127: v1(160.54,40.02) 160.49,40.02 160.12,40.38 160.12,41.05 161.65,42.58 161.65,45.71 164,48.06 164,49.62 163.51,50.11 163.51,57.2 162.72,58 162.72,58.74 161.7,59.75 161.7,65.79 161.17,66.33 161.17,73.48 160.01,74.64 160.01,95.85 159.14,96.71 159.14,100.51
  BOTTOM w0.102: JDIM4.49 159.17,38.2 159.02,38.35 159.02,38.92 160.13,40.02 v1(160.54,40.02)
M_A_DQ17: length 80.2
  TOP w0.089: v1(155.7,103.68) 155.01,103.68 154.76,103.93 154.76,104.2 155.17,104.61 155.17,105.23 155.06,105.34 155.06,106.89 U3.BG5
  TOP w0.102: JDIM2.50 160.82,38.18 161,38.36 161,38.95 v1(160.58,39.37)
  IN2 w0.079: 159.5,100.15 159.5,101.48 158.27,102.71 157.42,102.71 156.45,103.68 v1(155.7,103.68)
  IN2 w0.127: v1(160.58,39.37) 160.64,39.37 160.96,39.7 160.96,41.39 162,42.43 162,45.56 164.35,47.91 164.35,49.77 163.87,50.25 163.87,57.35 163.07,58.14 163.07,58.89 162.06,59.9 162.06,65.94 161.52,66.48 161.52,73.63 160.36,74.79 160.36,95.99 159.5,96.86 159.5,100.15
  BOTTOM w0.102: v1(160.58,39.37) 160.1,38.89 160.1,38.29 160.17,38.22 JDIM4.45
M_A_DQ18: length 81.5
  TOP w0.089: v1(153.28,106.51) 153.4,106.51 U3.BF4
  TOP w0.102: JDIM2.58 158.82,38.56 158.72,39.07 158.4,39.46 v1(157.27,40.59)
  IN2 w0.079: 156.29,100.89 156.29,101.96 153.87,104.38 153.87,105.92 v1(153.28,106.51)
  IN2 w0.127: v1(157.27,40.59) 157.27,40.6 157.27,40.79 158.02,41.54 158.02,46.13 159.97,48.09 159.97,50.36 160.83,51.22 160.83,53.84 160.1,54.57 160.1,57.54 158.99,58.65 158.99,66.62 158.86,66.75 157.96,66.75 157.84,66.88 157.84,67.13 157.96,67.26 158.85,67.26 158.98,67.38 158.98,67.64 158.85,67.76 157.96,67.76 157.84,67.89 157.84,94.91 156.46,96.29 156.46,100.72 156.29,100.89
  BOTTOM w0.102: JDIM4.63 155.67,38.72 156.1,39.14 156.15,39.27 156.91,40.23 v1(157.27,40.59)
M_A_DQ19: length 79.9
  TOP w0.089: v1(153.28,107.16) 153.4,107.16 U3.BF5
  TOP w0.102: v1(157.28,39.32) 157.82,38.78 JDIM2.62
  IN2 w0.079: 156.82,99.84 156.82,101.83 154.73,103.91 154.73,106.26 153.82,107.16 v1(153.28,107.16)
  IN2 w0.127: v1(157.28,39.32) 158.37,40.41 158.37,45.99 161.19,48.8 161.19,49.59 161.06,49.71 160.59,49.71 160.46,49.84 160.46,50.1 160.59,50.22 161.06,50.22 161.19,50.35 161.19,56.95 159.35,58.8 159.35,68.12 159.22,68.25 158.32,68.25 158.19,68.37 158.19,95.06 156.82,96.44 156.82,99.84
  BOTTOM w0.102: v1(157.28,39.32) 156.67,38.71 JDIM4.59
M_A_DQ20: length 79.9
  TOP w0.089: v1(157.07,102.21) 157.01,102.16 156.6,102.16 155.83,102.92 155.22,102.92 154.34,103.8 154.34,104.32 154.78,104.76 154.78,105.02 154.46,105.34 U3.BG2
  TOP w0.102: JDIM2.45 162.07,42.87 161.71,42.5 161.19,42.5 v1(160.95,42.74)
  IN2 w0.079: v1(157.07,102.21) 158.05,102.21 158.79,101.47 158.79,100.86
  IN2 w0.127: v1(160.95,42.74) 161.29,43.08 161.29,44.52 161.16,44.65 160.99,44.65 160.86,44.78 160.86,45.03 160.99,45.16 161.16,45.16 161.29,45.29 161.29,45.86 163.16,47.72 163.16,57.05 162.36,57.85 162.36,58.59 161.35,59.61 161.35,65.65 160.81,66.18 160.81,72.32 160.69,72.45 159.78,72.45 159.65,72.57 159.65,72.83 159.78,72.95 160.69,72.95 160.81,73.08 160.81,73.34 160.69,73.46 159.78,73.46 159.65,73.59 159.65,95.7 158.79,96.56 158.79,100.86
  BOTTOM w0.102: JDIM4.50 158.92,44.27 160.45,42.74 v1(160.95,42.74)
M_A_DQ21: length 77.4
  TOP w0.089: v1(157.52,101.75) 157.48,101.71 156.51,101.71 155.58,102.63 155.25,102.63 154.14,103.74 154.14,104.39 154.46,104.7 U3.BG1
  TOP w0.102: JDIM2.49 161.07,43.45 160.9,43.27 v1(160.58,43.27)
  IN2 w0.079: 158.43,101.08 158.43,101.24 157.92,101.75 v1(157.52,101.75)
  IN2 w0.127: v1(160.58,43.27) 160.15,43.71 160.15,45.22 162.8,47.87 162.8,56.9 162.01,57.7 162.01,58.35 161.17,59.19 160.79,59.19 160.45,59.52 160.45,69.72 160.32,69.85 159.44,69.85 159.3,69.99 159.3,70.23 159.42,70.36 160.32,70.36 160.45,70.48 160.45,70.74 160.32,70.86 159.44,70.86 159.3,71 159.3,71.25 159.42,71.37 160.32,71.37 160.45,71.5 160.45,71.75 160.32,71.88 159.44,71.88 159.3,72.02 159.3,95.55 158.43,96.42 158.43,101.08
  BOTTOM w0.102: v1(160.58,43.27) 159.92,43.93 JDIM4.46
M_A_DQ22: length 79.3
  TOP w0.089: v1(153.28,104.56) 153.6,104.89 U3.BF1
  TOP w0.102: v1(157.24,42.27) 157.29,42.27 158.57,43.55 JDIM2.59
  IN2 w0.079: v1(153.28,104.56) 153.29,104.56 156.1,101.75 156.1,100.58
  IN2 w0.127: 156.1,100.58 156.1,96.14 157.48,94.76 157.48,66.39 157.61,66.27 158.51,66.27 158.64,66.14 158.64,65.89 158.51,65.76 157.61,65.76 157.48,65.63 157.48,65.38 157.61,65.25 158.51,65.25 158.64,65.12 158.64,64.87 158.51,64.74 157.61,64.74 157.48,64.62 157.48,64.36 157.61,64.23 158.51,64.23 158.64,64.11 158.64,59.99 158.14,59.49 158.14,59 159.03,58.1 159.03,57.29 159.18,57.15 159.55,57.15 159.74,56.95 159.74,50.95 159.03,50.24 159.03,47.65 157.66,46.28 157.66,42.69 v1(157.24,42.27)
  BOTTOM w0.102: v1(157.24,42.27) 155.92,43.58 JDIM4.62
M_A_DQ23: length 77.9
  TOP w0.089: U3.BF2 153.6,105.54 v1(153.28,105.21)
  TOP w0.102: v1(157.24,43.53) 157.48,43.53 157.7,43.76 157.7,44.16 157.57,44.29 JDIM2.63
  IN2 w0.079: 155.76,100.24 155.76,101.7 153.94,103.52 153.1,103.52 152.87,103.75 152.87,104.81 v1(153.28,105.21)
  IN2 w0.127: v1(157.24,43.53) 157.24,46.76 158.68,48.19 158.68,57.86 157.13,59.41 157.13,59.83 157.25,59.96 158.1,59.96 158.23,60.08 158.23,60.34 158.1,60.47 157.25,60.47 157.13,60.59 157.13,60.85 157.25,60.97 158.1,60.97 158.23,61.1 158.23,61.35 158.1,61.48 157.25,61.48 157.13,61.61 157.13,61.86 157.25,61.99 158.1,61.99 158.23,62.12 158.23,62.37 158.1,62.5 157.25,62.5 157.13,62.62 157.13,62.88 157.25,63.01 158.1,63.01 158.23,63.13 158.23,63.39 158.1,63.51 157.25,63.51 157.13,63.64 157.13,94.62 155.75,95.99 155.75,100.24 155.76,100.24
  BOTTOM w0.102: JDIM4.58 156.92,43.85 v1(157.24,43.53)
M_A_DQ24: length 79.4
  TOP w0.079: 152.75,102.93 152.22,103.46 152.22,105.09 151.94,105.37 U3.BD2
  TOP w0.089: 152.75,102.93 154.03,101.65 v1(154.9,101.65)
  TOP w0.102: v1(155.39,40.48) 155.55,40.48 156.73,39.3 156.73,38.52 156.82,38.43 JDIM2.66
  IN2 w0.079: v1(154.9,101.65) 154.69,101.43 154.69,100.29 154.62,100.22 154.62,99.43
  IN2 w0.127: v1(155.39,40.48) 156.43,41.52 156.43,44.88 156.31,45.01 156.02,45.01 155.89,45.14 155.89,45.38 156.02,45.5 156.29,45.5 156.43,45.64 156.43,45.88 156.31,46.01 156.02,46.01 155.89,46.14 155.89,46.39 156.02,46.52 156.29,46.52 156.43,46.66 156.43,47.06 157.69,48.32 157.69,48.85 156.74,49.8 156.74,51.05 157.69,52 157.69,57.73 156.34,59.08 156.34,94.29 154.62,96.01 154.62,99.43
  BOTTOM w0.102: v1(155.39,40.48) 155.32,40.48 153.67,38.83 JDIM4.71
M_A_DQ25: length 77
  TOP w0.089: v1(155.38,101.21) 154.21,101.21 151.94,103.48 U3.BD1
  TOP w0.102: JDIM2.70 155.82,38.28 155.72,38.38 155.72,38.51 155.82,38.61 156.04,38.61 156.1,38.66 156.1,38.9 155.82,39.18 155.66,39.18 v1(155.6,39.24)
  IN2 w0.079: 154.97,98.33 154.97,100.8 v1(155.38,101.21)
  IN2 w0.127: v1(155.6,39.24) 155.87,39.51 156.66,39.51 156.79,39.64 156.79,39.97 156.64,40.12 156.36,40.12 156.15,40.33 156.15,40.66 156.79,41.29 156.79,46.92 158.04,48.17 158.04,49.14 157.59,49.6 157.59,51.18 158.04,51.63 158.04,57.88 156.69,59.23 156.69,94.44 154.97,96.16 154.97,98.33
  BOTTOM w0.102: v1(155.6,39.24) 155.15,39.24 154.67,38.77 JDIM4.67
M_A_DQ26: length 80.7
  TOP w0.089: U3.BC4 151.09,106.84 v1(150.76,106.51)
  TOP w0.102: JDIM2.80 153.32,39.51 152.27,40.57 152.13,40.57 v1(152.1,40.6)
  IN2 w0.079: v1(150.76,106.51) 149.94,105.69 149.94,100.97 151.97,98.94
  IN2 w0.127: 151.97,98.94 151.97,95.24 153.69,93.52 153.69,73.85 153.57,73.73 153.03,73.73 152.91,73.6 152.91,73.34 153.03,73.22 153.57,73.22 153.69,73.09 153.69,72.84 153.57,72.71 153.03,72.71 152.91,72.58 152.91,72.33 153.03,72.2 153.57,72.2 153.69,72.07 153.69,71.82 153.57,71.69 153.03,71.69 152.91,71.57 152.91,51.93 151.05,50.07 151.05,42.91 151.32,42.63 151.32,41.37 v1(152.1,40.6)
  BOTTOM w0.102: v1(152.1,40.6) 150.67,39.18 JDIM4.83
M_A_DQ27: length 79
  TOP w0.089: U3.BC5 151.09,107.49 v1(150.76,107.16)
  TOP w0.102: v1(152.08,39.3) 152.52,38.86 152.52,38.38 152.32,38.19 JDIM2.84
  IN2 w0.079: 151.72,98.8 149.77,100.76 149.77,106.17 v1(150.76,107.16)
  IN2 w0.127: v1(152.08,39.3) 151.77,39 151.02,39 150.69,39.33 150.69,50.22 152.5,52.03 152.5,74.08 152.63,74.21 152.97,74.21 153.11,74.35 153.11,74.62 152.97,74.76 152.63,74.76 152.5,74.89 152.5,75.13 152.64,75.27 153.21,75.27 153.34,75.39 153.34,93.44 151.72,95.06 151.72,98.8
  BOTTOM w0.102: v1(152.08,39.3) 151.88,39.3 151.56,38.98 151.56,38.42 151.67,38.31 JDIM4.79
M_A_DQ28: length 79.3
  TOP w0.079: 152.75,103.55 152.55,103.75 152.55,105.35 152.46,105.44 152.46,106.97 U3.BD5
  TOP w0.089: 152.75,103.55 153.19,103.12 v1(153.43,103.12)
  TOP w0.102: JDIM2.71 155.57,43.87 v1(155.16,43.45)
  IN2 w0.079: 153.91,98.33 153.91,100.58 154.07,100.75 154.07,101.35 153.43,102 v1(153.43,103.12)
  IN2 w0.127: 153.91,98.33 153.91,95.72 155.63,94 155.63,58.14 155.75,58.01 156.24,58.01 156.38,57.87 156.38,57.63 156.25,57.5 155.75,57.5 155.63,57.38 155.63,57.12 155.75,57 156.24,57 156.38,56.86 156.38,56.61 156.25,56.49 155.75,56.49 155.63,56.36 155.63,55.41 155.76,55.28 155.76,51.11 155.63,50.99 154.62,50.99 154.5,50.86 154.5,50.6 154.62,50.48 155.63,50.48 155.76,50.35 155.76,50.1 155.63,49.97 154.21,49.97 154.09,49.84 154.09,49.59 154.21,49.46 155.63,49.46 155.76,49.33 155.76,48.89 154.29,47.41 154.29,43.98 154.82,43.45 v1(155.16,43.45)
  BOTTOM w0.102: v1(155.16,43.45) 154.97,43.45 154.73,43.7 154.73,44.38 154.92,44.58 JDIM4.66
M_A_DQ29: length 80.6
  TOP w0.079: 152.75,103.21 152.39,103.57 152.39,104.49 152.39,105.17 152.24,105.33 152.24,106.54 U3.BD4
  TOP w0.089: 152.75,103.21 153.33,102.63 v1(153.97,102.63)
  TOP w0.102: JDIM2.67 156.57,44.19 156.45,44.07 156.45,42.77 155.85,42.17 v1(155.26,42.17)
  IN2 w0.079: 154.26,98.33 154.26,100.42 154.51,100.67 154.51,101.21 153.97,101.75 v1(153.97,102.63)
  IN2 w0.127: 154.26,98.33 154.26,95.86 155.98,94.14 155.98,58.93 156.73,58.18 156.73,56.13 156.61,56 156.11,56 155.98,55.88 155.98,55.65 156.14,55.5 156.52,55.5 156.66,55.36 156.66,55.12 156.53,54.99 156.27,54.99 156.12,54.84 156.12,54.61 156.24,54.48 156.52,54.48 156.66,54.34 156.66,54.1 156.53,53.97 156.27,53.97 156.12,53.82 156.12,53.59 156.24,53.46 156.52,53.46 156.66,53.32 156.66,53.08 156.53,52.96 156.27,52.96 156.12,52.8 156.12,48.74 155.3,47.92 155.3,47.37 155.18,47.24 155,47.24 154.87,47.11 154.87,46.86 155,46.73 155.16,46.73 155.3,46.59 155.3,46.35 155.18,46.22 155,46.22 154.87,46.1 154.87,45.84 155.01,45.7 155.18,45.7 155.3,45.58 155.3,44.57 156.08,43.8 156.08,42.58 155.66,42.17 v1(155.26,42.17)
  BOTTOM w0.102: v1(155.26,42.17) 153.92,43.5 JDIM4.70
M_A_DQ30: length 77.8
  TOP w0.089: v1(150.77,104.53) 151.13,104.89 U3.BC1
  TOP w0.102: v1(151.96,43.33) 151.96,43.48 152.57,44.1 JDIM2.83
  IN2 w0.079: v1(150.77,104.53) 151.33,103.97 151.33,101.43 152.6,100.17
  IN2 w0.127: 152.6,100.17 152.6,95.59 154.52,93.67 154.52,66.71 154.38,66.57 153.75,66.57 153.62,66.44 153.62,66.19 153.75,66.06 154.39,66.06 154.52,65.94 154.52,63.43 154.39,63.31 153.75,63.31 153.62,63.18 153.62,62.92 153.75,62.8 154.33,62.8 154.46,62.67 154.46,62.43 154.32,62.29 153.75,62.29 153.62,62.16 153.62,61.91 153.75,61.78 154.33,61.78 154.46,61.65 154.46,61.41 154.32,61.27 153.75,61.27 153.62,61.15 153.62,60.89 153.75,60.77 154.33,60.77 154.46,60.64 154.46,60.4 154.32,60.26 153.75,60.26 153.62,60.13 153.62,59.88 153.75,59.75 154.33,59.75 154.46,59.62 154.46,59.38 154.32,59.24 153.75,59.24 153.62,59.11 153.62,58.86 153.75,58.73 154.17,58.73 154.3,58.61 154.3,58.28 154.15,58.12 153.75,58.12 153.62,58 153.62,51.64 152.66,50.68 152.66,43.78 152.21,43.33 v1(151.96,43.33)
  BOTTOM w0.102: JDIM4.80 151.42,43.73 151.83,43.33 v1(151.96,43.33)
M_A_DQ31: length 78.8
  TOP w0.089: U3.BC2 150.88,105.21 v1(150.76,105.21)
  TOP w0.102: v1(151.94,42.68) 153.57,44.31 JDIM2.79
  IN2 w0.079: 152.28,99 150.2,101.08 150.2,104.65 v1(150.76,105.21)
  IN2 w0.127: v1(151.94,42.68) 151.4,43.22 151.4,49.92 153.26,51.78 153.26,66.98 153.39,67.11 153.93,67.11 154.09,67.26 154.09,67.49 153.96,67.61 153.39,67.61 153.26,67.74 153.26,67.99 153.39,68.12 153.93,68.12 154.09,68.27 154.09,68.5 153.96,68.63 153.39,68.63 153.26,68.76 153.26,69.01 153.39,69.14 153.93,69.14 154.09,69.29 154.09,69.52 153.96,69.65 153.39,69.65 153.26,69.77 153.26,70.03 153.39,70.15 153.93,70.15 154.09,70.31 154.09,70.53 153.96,70.66 153.39,70.66 153.26,70.79 153.26,71.04 153.39,71.17 153.92,71.17 154.05,71.3 154.05,93.65 152.28,95.41 152.28,99
  BOTTOM w0.102: v1(151.94,42.68) 150.59,44.03 150.59,44.38 150.42,44.55 JDIM4.84
M_A_DQ32: length 82.9
  TOP w0.079: v1(134.72,101.29) 134.23,101.78 134.23,104.77 U3.AB1
  TOP w0.102: JDIM2.174 127.82,38.19 127.99,38.35 127.99,38.99 v1(127.58,39.39)
  IN2 w0.079: 134.65,99.01 134.71,99.08 134.71,101.28 v1(134.72,101.29)
  IN2 w0.127: 134.65,99.01 130.36,94.73 130.36,92.93 124.15,86.71 124.15,69.33 122.53,67.71 122.53,66.43 122.41,66.31 122.05,66.31 121.9,66.46 121.9,66.87 121.77,67 121.52,67 121.36,66.83 121.36,64.97 121.01,64.62 120.65,64.62 120.5,64.48 120.5,59.29 118.79,57.57 118.79,55.33 118.98,55.14 118.98,54.52 118.79,54.33 118.79,51.46 123.22,47.03 123.22,46.42 126.42,43.22 126.42,40.56 v1(127.58,39.39)
  BOTTOM w0.102: v1(127.58,39.39) 127.06,38.87 127.06,38.37 127.17,38.26 JDIM4.169
M_A_DQ33: length 85.3
  TOP w0.079: v1(135.19,101.74) 134.48,102.44 134.48,104.62 134.63,104.76 134.63,105.25 U3.AB2
  TOP w0.102: JDIM2.170 128.82,39.36 v1(127.48,40.7)
  IN2 w0.079: 134.82,98.75 134.94,98.87 134.94,100.87 135.62,101.55 135.62,101.78 135.54,101.86 135.31,101.86 v1(135.19,101.74)
  IN2 w0.127: v1(127.48,40.7) 126.77,41.41 126.77,43.37 123.57,46.57 123.57,47.17 119.71,51.03 119.71,58 121.4,59.68 121.4,63.29 121.27,63.42 121.05,63.42 120.92,63.55 120.92,63.8 121.05,63.93 121.27,63.93 121.4,64.05 121.4,64.51 122.08,65.19 122.08,65.37 121.85,65.59 121.85,65.78 122.02,65.95 122.21,65.95 122.44,65.73 122.62,65.73 122.89,65.99 122.89,67.57 124.5,69.18 124.5,86.56 130.72,92.78 130.72,94.65 134.82,98.75
  BOTTOM w0.102: JDIM4.173 126.17,39.58 127.29,40.7 v1(127.48,40.7)
M_A_DQ34: length 84.7
  TOP w0.089: U3.AA4 133.49,106.84 v1(133.16,106.51)
  TOP w0.102: JDIM2.187 124.57,44.23 124.75,44.05 124.75,43.38 v1(124.28,42.9)
  IN2 w0.079: v1(133.16,106.51) 133.56,106.11 133.82,106.11 133.89,106.19 133.89,106.41 133.97,106.49 134.2,106.49 134.28,106.41 134.28,101.84 133.6,101.16 133.6,100.5 132.8,99.7 132.8,99.03 131.97,98.19
  IN2 w0.127: 131.97,98.19 128.84,95.06 128.84,93.48 122.69,87.33 122.69,70.28 118.97,66.57 118.97,63.08 118.81,62.92 118.44,62.92 118.28,62.75 118.28,62.49 118.43,62.34 118.75,62.34 118.85,62.24 118.85,61.92 118.37,61.44 117.92,61.44 117.78,61.29 117.78,61.02 117.9,60.89 118.72,60.89 118.85,60.76 118.85,60.52 118.71,60.38 117.9,60.38 117.78,60.25 117.78,60 117.9,59.87 118.09,59.87 118.22,59.75 118.22,59.49 118.09,59.37 117.9,59.37 117.78,59.24 117.78,58.76 117.33,58.31 117.33,50.63 121.58,46.37 121.58,45.94 124.28,43.25 v1(124.28,42.9)
  BOTTOM w0.102: v1(124.28,42.9) 123.92,43.25 JDIM4.182
M_A_DQ35: length 86.1
  TOP w0.089: U3.AA5 133.48,107.49 v1(133.16,107.16)
  TOP w0.102: JDIM2.183 125.57,43.52 124.32,42.27 v1(124.25,42.27)
  IN2 w0.079: 132.37,98.12 133.09,98.84 133.09,99.56 133.87,100.34 133.87,101.1 134.53,101.77 134.53,107.15 134.31,107.37 133.37,107.37 v1(133.16,107.16)
  IN2 w0.127: v1(124.25,42.27) 124.25,41.94 124.4,41.8 124.62,41.8 124.75,41.92 124.75,43.28 121.94,46.09 121.94,46.61 117.68,50.87 117.68,58.16 118.69,59.17 118.69,59.71 118.78,59.8 119.2,59.8 119.33,59.93 119.33,61.07 119.17,61.24 119.17,61.58 119.33,61.74 119.33,66.42 123.04,70.14 123.04,87.18 129.19,93.33 129.19,94.94 132.37,98.12
  BOTTOM w0.102: JDIM4.186 122.92,44.25 123.41,43.77 123.41,43.11 v1(124.25,42.27)
M_A_DQ36: length 86.1
  TOP w0.079: v1(135.23,103.68) 134.82,104.09 134.82,104.51 134.94,104.63 134.94,106.35 134.79,106.5 134.79,107.04 U3.AB5
  TOP w0.102: v1(127.46,42.66) 127.77,42.66 129.07,43.96 JDIM2.169
  IN2 w0.079: v1(135.23,103.68) 135.46,103.91 136.02,103.91 136.07,103.87 136.07,101.33 135.32,100.58 135.32,98.52 135.17,98.37
  IN2 w0.127: 135.17,98.37 131.45,94.65 131.45,92.51 125.27,86.33 125.27,68.03 125.14,67.9 124.23,67.9 124.1,67.77 124.1,67.54 124.25,67.39 125.14,67.39 125.27,67.26 125.27,66.97 125.13,66.84 124.12,66.84 123.89,66.61 123.89,65.74 123,64.85 123,60.28 120.91,58.19 120.91,50.84 124.28,47.47 124.28,46.86 126.58,44.57 127.49,44.57 127.82,44.24 127.82,43.03 v1(127.46,42.66)
  BOTTOM w0.102: v1(127.46,42.66) 127.18,42.66 126.66,43.19 126.66,43.45 125.92,44.19 JDIM4.174
M_A_DQ37: length 84.9
  TOP w0.079: U3.AB4 134.56,106.62 134.56,106.43 134.79,106.2 134.79,104.7 134.65,104.56 134.65,103.61 v1(135.23,103.03)
  TOP w0.102: JDIM2.173 128.07,44.4 127.97,44.29 127.97,44.08 128.16,43.89 128.16,43.74 127.78,43.36 v1(127.38,43.36)
  IN2 w0.079: 135.08,98.61 135.12,98.65 135.12,100.71 135.85,101.43 135.85,103.28 135.77,103.36 135.56,103.36 v1(135.23,103.03)
  IN2 w0.127: 135.08,98.61 131.1,94.62 131.1,92.65 124.86,86.41 124.86,69.03 123.24,67.42 123.24,65.85 122.65,65.25 122.65,63.97 122.52,63.84 121.93,63.84 121.79,63.7 121.79,63.44 121.9,63.33 122.52,63.33 122.65,63.2 122.65,62.95 122.52,62.82 121.91,62.82 121.75,62.66 121.75,62.41 121.85,62.31 122.52,62.31 122.65,62.19 122.65,61.93 122.52,61.81 121.88,61.81 121.75,61.68 121.75,61.43 121.88,61.3 122.52,61.3 122.65,61.17 122.65,61.03 122.49,60.87 121.91,60.87 121.75,60.71 121.75,60.43 121.85,60.34 122.1,60.34 122.19,60.25 122.19,59.97 120.07,57.85 120.07,51.18 123.93,47.32 123.93,46.72 127.28,43.36 v1(127.38,43.36)
  BOTTOM w0.102: JDIM4.170 126.92,43.75 127.31,43.36 v1(127.38,43.36)
