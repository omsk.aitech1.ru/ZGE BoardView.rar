# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SLP_S0IX#: length 37.6
  TOP w0.14: v1(216.68,15.59) 216.56,15.71 R552.2 ; v1(231.41,13.56) 231.41,13.76 231.11,14.06 CN5.15
  IN1 w0.086: v1(244.37,18.96) 244.3,18.9 244.3,17.57 243.27,16.55 243.27,15.49 241.62,13.83 238.14,13.83 237.31,13 231.97,13 v1(231.41,13.56) 230.95,13.1 230.45,13.1 229.92,12.57 228.56,12.57 227.89,13.24 227.89,13.63 227.34,14.18 225.22,14.18 223.61,12.57 221.49,12.57 220.61,13.45 220.61,13.47 218.72,15.36 216.91,15.36 v1(216.68,15.59)
  BOTTOM w0.14: R1072.1 243.87,18.47 v1(244.37,18.96)
PCH_SLP_S0IX#_L: length 10.5
  TOP w0.102: 217.67,20.17 217.11,20.74 217.11,20.85 217.25,21 217.25,21.71 216.88,22.07 216.88,23.01 216.85,23.04 216.85,23.39 217.04,23.58 217.04,24.25 216.88,24.4 216.88,25.03 U14.BC28
  TOP w0.14: R552.1 216.92,17.01 217.02,16.91 v1(217.44,16.91) 217.6,17.07 217.6,17.38 218.33,18.12 218.33,19.36 R495.1 217.67,20.03 217.67,20.17
PCH_SLP_SUS#: length 3.5
  TOP w0.14: U14.BD39 222.07,25.18 v1(221.9,25.36)
  BOTTOM w0.102: v1(221.9,25.36) 221.9,25.73 222.71,26.55 223.29,26.55 223.72,26.12 TP105.1
PCH_SMBCLK: length 113.1
  TOP w0.102: 107.21,52.21 107.41,52.21 107.97,52.77 107.97,57.18 108.07,57.29 JDIM1.253 108.07,58.49 ; v1(107.78,43.72) 108.07,44.01 JDIM2.253
  TOP w0.14: 108.07,58.49 108.07,62.78 113.07,67.78 164.71,67.78 172.02,60.47 173.97,60.47 174.46,60.97 175.87,60.97 179.1,64.2 v1(179.24,64.2) ; v1(105.91,52.21) 107.21,52.21
  IN1 w0.086: v1(106.32,39.95) 107.07,39.95 107.41,40.28 107.41,43.35 v1(107.78,43.72) 106.23,45.26 106.23,51.89 v1(105.91,52.21)
  BOTTOM w0.102: v1(106.32,39.95) 106.02,39.65 106.02,38.81 106.17,38.66 JDIM4.253 ; v1(105.91,52.21) 105.99,52.21 106.17,52.03 JDIM3.253
  BOTTOM w0.14: Q66.1 179.83,64.79 v1(179.24,64.2) 179.24,64.18 179.76,63.66 R726.2
PCH_SMBDATA: length 132.1
  TOP w0.14: JDIM1.254 107.82,49.01 106.93,48.12 106.93,47.18 105.93,46.18 105.93,42.45 107.15,41.24 v1(108.07,41.24) 108.07,41 107.36,40.29 107.36,38.9 107.82,38.44 JDIM2.254 ; v1(106.32,59.91) 106.17,59.91 105.74,60.34 105.74,61.08 106.09,61.43 106.09,61.5 112.87,68.28 164.92,68.28 172.23,60.97 173.76,60.97 174.29,61.5 175.7,61.5 178.75,64.54 v1(178.75,64.72)
  IN1 w0.086: v1(106.32,59.91) 106.67,59.55 106.67,45.48 108.22,43.94 108.22,43.53 107.85,43.16 107.85,41.46 v1(108.07,41.24)
  BOTTOM w0.102: v1(106.32,59.91) 106.22,59.91 105.92,59.62 JDIM3.254 ; v1(108.07,41.24) 107.58,41.73 107.58,42.73 105.92,44.39 JDIM4.254
  BOTTOM w0.14: v1(178.75,64.72) 178.17,65.3 178.17,65.94 v1(178.75,66.52) 178.75,66.87 179.57,67.7 180.33,67.7 181.43,66.6 Q66.4 181.93,66.38 182.43,65.88 R723.2
PCH_SPI1_CLK: length 14.5
  TOP w0.14: R360.1 233.66,31.25 234.6,31.25 234.84,31.49 234.84,31.76 EC5.2 235.62,30.6 236.72,29.51 239.17,29.51 239.54,29.88 U19.6 239.54,31.28 240.16,31.91 240.43,31.91 241.14,32.62 241.14,33.52 R321.1
PCH_SPI1_CLK_L: length 23.9
  TOP w0.102: U14.AW47 226.18,27.45 226.18,27.46 226.47,27.74 228.71,27.74 229.38,28.41 229.38,29.21 230.76,30.59
  TOP w0.14: 230.76,30.59 v1(231.86,30.59) 231.87,30.58 232.06,30.58 R360.2
  IN1 w0.086: v1(238.86,19.57) 238.86,20.22 237.18,21.89 237.18,22.35 234.98,24.56 234.98,27.57 234.64,27.91 233.85,27.91 233.12,28.64 233.12,29.34 233.03,29.43 233.02,29.43 v1(231.86,30.59)
  BOTTOM w0.14: R1067.1 238.86,19.11 v1(238.86,19.57)
PCH_SPI1_SI: length 12.1
  TOP w0.14: R335.1 243.08,33.93 242.61,33.47 242.21,33.47 R341.1 241.71,32.46 240.81,31.55 U19.5 240.81,29.94 239.86,28.99 237.67,28.99 237.41,28.72 237.41,28.44 236.67,27.7 v1(236.67,27.22)
  BOTTOM w0.14: v1(236.67,27.22) 236.37,27.52 R936.1
PCH_SPI1_SI_L: length 28.1
  TOP w0.14: U14.AU41 223.31,27.79 v1(223.08,27.56)
  IN1 w0.086: v1(240.81,19.52) 240.72,19.52 240.15,20.09 240.15,20.91 239.87,21.19 239.1,21.19 238.41,21.88 238.41,22.34 236.55,24.2 236.55,25.07 236.06,25.56 236.06,26.18 235.67,26.57 v1(235.67,27.22)
  BOTTOM w0.14: R1066.1 240.81,19.19 v1(240.81,19.52) ; v1(223.08,27.56) 223.27,27.75 223.87,27.75 224.12,27.5 225.16,27.5 225.62,27.96 226.23,27.96 R940.2 226.7,26.86 227.23,26.33 227.98,26.33 229.63,27.98 231.54,27.98 R919.1 233.21,28.78 235.13,28.78 235.59,28.33 R936.2 235.59,27.3 v1(235.67,27.22)
PCH_SPI1_SO: length 6
  TOP w0.14: v1(236.58,25.82) 236.58,25.58 238.27,23.89 U19.2 238.27,22.09 R454.1
  BOTTOM w0.14: v1(236.58,25.82) 236.58,26.06 236.33,26.31 R945.1
PCH_SPI1_SO_L: length 27
  TOP w0.102: v1(225.58,26.69) 225.58,26.63 U14.BA45
  IN1 w0.086: v1(242.58,20.39) 242.58,19.66 242,19.08 240.61,19.08 239.76,19.93 239.76,20.56 239.52,20.8 238.94,20.8 238.02,21.72 238.02,22.18 236.16,24.04 236.16,24.91 235.63,25.44 v1(235.63,25.82)
  BOTTOM w0.14: v1(242.58,20.39) 243.21,20.39 R1044.1 ; v1(225.58,26.69) 226.25,26.69 227.05,25.89 228.17,25.89 229.39,27.11 R944.2 229.93,27.54 v1(231.73,27.54) 232.42,28.23 R931.1 233.14,27.76 234.65,27.76 235.07,27.35 235.07,27.04 R945.2 235.63,26.49 v1(235.63,25.82)
PCH_SPI_CLK_EC: length 194.9
  TOP w0.14: R321.2 242.85,34.46 243.71,34.46 244,34.17 244,32.14 244.35,31.79 244.35,27.89 244.16,27.7 244.16,25.49 243.67,25 243.67,23.83 243.1,23.26 243.1,22.7 v1(243.17,22.62) ; v1(80.44,32.77) 80.23,32.98 U18.105
  IN3 w0.089: v1(243.17,22.62) 242.47,21.92 241.59,21.92 240.23,20.57 240.23,19.5 238.72,17.98 236.13,17.98 235.06,16.91 229.37,16.91 227.37,18.91 225.85,18.91 225.44,18.51 225.44,18.23 225.15,17.94 220.96,17.94 220.27,17.25 217.92,17.25 217.78,17.1 203.91,17.1 203.34,16.53 197.57,16.53 195.71,18.39 195.12,18.39 194.24,19.28 192.65,19.28 191.68,20.25 191.25,20.25 189.36,22.14 189.36,23.46 188.55,24.27 188.55,24.52 186.77,26.31 183.46,26.31 183.04,26.72 180.63,26.72 179.4,27.95 178.76,28.58 177.45,28.58 174.93,31.1 168.45,31.1 168.1,30.76 152.79,30.76 152.1,31.45 151.75,31.45 151.51,31.2 151.51,31.01 151.36,30.86 149.37,30.86 149.16,31.07 111.29,31.07 110.13,32.23 100.39,32.23 98.61,30.45 97.09,30.45 96.8,30.74 96.2,30.74 95.85,30.4 91.18,30.4 90.61,29.83 85.45,29.83 84.1,31.18 82.04,31.18 v1(80.44,32.77)
PCH_SPI_CS0#: length 12.5
  TOP w0.14: R453.2 R452.2 236.75,22.09 237,22.34 U19.1 237,24.39 236.11,25.28 236.11,26.48 236.16,26.53 236.16,29.25 234.69,30.73 234,30.73 R369.1
PCH_SPI_CS0#_L: length 8.7
  TOP w0.102: U14.AY47 226.31,26.94 226.73,26.94 226.83,27.04 227.6,27.04 227.73,26.92 228.03,26.92 228.58,27.46
  TOP w0.14: 228.58,27.46 228.81,27.46 229.69,28.35 229.69,29.08 230.65,30.04 232.53,30.04 R369.2
PCH_SPI_IO2: length 1.9
  TOP w0.14: U19.3 239.54,22.45 239.84,22.15 239.84,21.75 239.94,21.65 R455.1
PCH_SPI_IO3: length 4.7
  TOP w0.14: U19.7 238.27,31.03 238.97,31.73 239.25,31.73 239.95,32.43 240.21,32.43 240.62,32.83 R340.2 R320.1
PCH_SPI_SI_EC: length 192.4
  TOP w0.14: v1(242.51,22.65) 242.51,23.44 243.15,24.07 243.15,25.21 243.6,25.67 243.6,27.88 243.83,28.1 243.83,31.57 243.27,32.12 242.74,32.12 242.49,32.37 R341.2 ; v1(81.13,32.8) 81.23,32.9 81.23,33.89 81.43,34.09 U18.102 81.43,35.91 81.64,36.11 81.64,36.68 81.77,36.82 R276.1
  IN3 w0.089: v1(81.13,32.8) 82.28,31.65 84.3,31.65 85.15,30.79 89.02,30.79 89.17,30.95 91.06,30.95 91.13,30.87 95.66,30.87 96,31.21 96.99,31.21 97.28,30.92 98.42,30.92 100.19,32.7 110.32,32.7 111.01,32.01 168.56,32.01 168.65,32.1 174.6,32.1 176.81,29.89 178.13,29.89 180.82,27.19 183.24,27.19 183.65,26.78 186.96,26.78 189.02,24.72 189.02,24.46 189.83,23.66 189.83,22.35 190.86,21.32 191.46,21.32 191.93,20.85 191.93,20.66 192.26,20.33 194.23,20.33 194.61,19.96 194.61,19.57 195.32,18.86 195.91,18.86 197.77,17 202.42,17 203.38,17.97 203.71,17.97 204.11,17.57 217.58,17.57 217.73,17.72 219.37,17.72 220.61,18.96 225.24,18.96 225.66,19.38 227.57,19.38 229.57,17.38 234.4,17.38 234.73,17.71 235.17,17.71 235.9,18.45 238.52,18.45 239.77,19.7 239.77,20.76 241.39,22.39 242.26,22.39 v1(242.51,22.65)
PCH_SPI_SO_EC: length 193.2
  TOP w0.14: v1(238.43,20.06) 238.77,20.4 R454.2 ; R272.1 81.06,37.15 81.06,36.06 81.03,36.03 U18.103 81.03,34.23 80.77,33.97 v1(80.77,33.33)
  IN3 w0.089: v1(238.43,20.06) 237.63,19.25 237.08,19.25 236.8,18.98 236.34,18.98 235.07,20.24 233.59,20.24 233.5,20.33 233.5,21.07 233.41,21.17 233.2,21.17 233.11,21.08 233.11,20.33 233.02,20.24 232.8,20.24 232.72,20.33 232.72,21.07 232.62,21.17 232.41,21.17 232.32,21.08 232.32,19.74 232.21,19.62 232.02,19.62 231.93,19.71 231.93,21.26 231.79,21.41 231.66,21.41 231.47,21.22 231.47,19.73 231.34,19.6 231.13,19.6 231.04,19.69 231.04,21.57 230.95,21.66 230.73,21.66 230.58,21.51 230.58,19.1 230.5,19.01 230.27,19.01 230.15,19.13 230.15,21.49 230.02,21.62 229.78,21.62 229.63,21.46 229.63,19.48 229.51,19.36 229.23,19.36 229.09,19.5 229.09,20.62 228.99,20.72 228.66,20.72 228.03,20.09 225.81,20.09 225.07,19.36 220.33,19.36 219.72,18.75 217.12,18.75 216.34,17.97 204.39,17.97 203.53,18.83 200.77,18.83 200.5,18.57 200.5,18.13 199.77,17.4 197.93,17.4 197.19,18.14 197.19,18.55 195.01,20.72 193.2,20.72 192.21,21.71 191.25,21.71 190.22,22.74 190.22,23.82 189.42,24.62 189.42,25.78 188.59,26.61 187.69,26.61 187.13,27.17 183.82,27.17 183.4,27.58 180.99,27.58 178.29,30.28 176.97,30.28 174.76,32.49 166.81,32.49 166.73,32.41 111.28,32.41 110.85,32.84 110.85,32.84 110.6,33.09 100.03,33.09 98.26,31.32 97.52,31.32 97.23,31.61 95.84,31.61 95.49,31.26 91.31,31.26 91.19,31.38 86.86,31.38 86.48,31.76 85.34,31.76 84.48,32.62 81.87,32.62 81.16,33.33 v1(80.77,33.33)
PCH_TBT_PLTRST#: length 39
  TOP w0.102: U14.AM48 226.83,30.32 227.3,30.32 227.6,30.62 227.68,30.62 227.96,30.9 v1(228.12,30.9)
  TOP w0.14: v1(214.03,51.45) 213.96,51.45 213.29,50.78 R1150.2 212.43,50.78 212.11,51.1 U6.2
  IN2 w0.089: v1(228.12,30.9) 228.12,31.32 228.62,31.82 229.86,31.82 230.4,32.35 230.4,36.95 230.96,37.51 230.96,39.79 229.79,40.96 228.85,40.96 227.65,42.16 227.65,44.24 223.08,48.81 220.85,48.81 217.52,52.14 215.08,52.14 214.41,51.46 214.05,51.46 v1(214.03,51.45)
PCH_TBT_WAKE#: length 14.5
  TOP w0.102: v1(228.29,39.89) 227.88,39.49 227.17,39.49 226.28,38.6 U14.T47
  TOP w0.14: Q27.1 236.74,41.1 R223.1 R222.2 235.83,40.48 235.98,40.32 v1(235.98,40.15)
  IN3 w0.089: v1(228.29,39.89) 229.2,40.81 235.78,40.81 235.98,40.61 v1(235.98,40.15)
PCH_TCK: length 7.8
  TOP w0.102: 201.29,32.6 201.79,32.1 202.58,32.1 202.75,31.92 203.63,31.92 203.84,32.13 U14.AJ3
  TOP w0.14: R283.2 199.27,35.48 199.44,35.32 v1(199.44,34.77) 199.44,34.45 201.29,32.6
PCH_TDI: length 11.3
  TOP w0.102: U14.AH2 203.76,32.63 203.46,32.33 202.92,32.33 202.75,32.5 201.99,32.5 200.27,34.22 200.27,35.35 199.99,35.63 199.99,36.11
  TOP w0.14: 199.99,36.11 199.99,37.56 199.47,38.08 198.55,38.08 197.72,38.91 R244.1
PCH_TDO: length 24.5
  TOP w0.102: 200.3,35.65 200.5,35.45 200.5,34.28 201.9,32.88 202.63,32.88 202.91,33.15 203.7,33.15 203.98,32.88 204.31,32.88 U14.AH3
  TOP w0.14: 200.3,35.65 200.3,37.59 199.57,38.32 198.65,38.32 198.39,38.58 198.39,39.26 197.96,39.69 196.55,39.69 195.02,41.22 194.15,41.22 193.29,42.07 193.29,42.58 192.64,43.23 192.64,43.84 192.09,44.39 v1(190.15,44.39) 189.85,44.68 R189.2 R188.1
PCH_TMS: length 11.7
  TOP w0.102: U14.AJ4 205.16,32.37 203.79,32.37 203.54,32.12 202.84,32.12 202.66,32.3 201.9,32.3 200.02,34.19 200.02,35.14
  TOP w0.14: 200.02,35.14 200.02,35.25 199.74,35.53 199.74,36.94 v1(199.27,37.41) 199.1,37.57 198.7,37.57 198.04,38.24 R264.1
PCH_WAKE#: length 3.9
  TOP w0.14: R223.2 237.52,41.31 237.18,41.64 Q27.3 236.74,42.98 R1153.1
PCH_WAKE#_L: length 8.2
  TOP w0.102: U14.BB47 226.9,25.19 227.04,25.33 228.28,25.33 229.05,24.56
  TOP w0.14: R449.1 231.98,21.42 v1(231.9,21.5) 231.53,21.88 231.33,21.88 231.13,22.08 231.13,22.63 R436.1 230.51,23.1 229.05,24.56
PCI_PLTRST#: length 74
  TOP w0.14: v1(218.18,28.19) 217.94,28.19 217.57,27.82 U14.AV29 ; v1(208.52,11.71) 208.52,10.87 209.01,10.38 U31.2 210.11,10.38 210.25,10.24 210.25,9.87 210.11,9.73 U31.1 ; v1(207.94,50.54) 208.04,50.64 R1152.2
  IN1 w0.086: v1(208.52,11.71) 208.21,11.71 208.13,11.63 202.03,11.63 201.38,12.28 201.38,13.29 204.54,16.45 206.5,16.45 206.96,15.99 206.96,15.34 207.46,14.84 209.35,14.84 209.82,15.31 209.82,18.89 211.5,20.57 211.5,21.62 212.6,22.73 212.6,23 213.68,24.08 216.39,24.08 217.67,25.36 217.67,27.92 217.94,28.19 v1(218.18,28.19)
  IN2 w0.089: v1(218.18,28.19) 218.51,28.19 219.7,29.38 219.7,30.19 219.08,30.8 218.17,30.8 217.54,31.43 217.54,33.65 217.7,33.8 217.7,34.38 217.76,34.44 217.76,35.31 218.59,36.14 218.59,37.56 218.34,37.8 216.18,37.8 212.71,41.27 212.71,43.87 211.64,44.95 211.64,47.27 209.13,49.78 208.7,49.78 v1(207.94,50.54)
PCIE_CLKREQ2#: length 23.8
  TOP w0.14: U14.AR32 218.94,29.34 219.26,29.02 219.26,28.41 v1(219.6,28.07)
  IN1 w0.102: v1(210.67,14.48) 210.13,15.02 210.13,18.78 211.79,20.44 211.79,20.84 212.11,21.15 212.59,21.15 212.9,21.45 212.9,22.88 213.8,23.78 216.51,23.78 218.88,26.15 218.88,27.16 218.6,27.43 218.6,27.95 218.99,28.33 219.34,28.33 v1(219.6,28.07)
  BOTTOM w0.14: R1120.1 211.01,14.15 v1(210.67,14.48)
PCIE_CLKREQ7#: length 7.7
  TOP w0.102: 229.13,36.08 228.45,35.39 228.18,35.39 228.03,35.24 226.71,35.24 U14.AC48
  TOP w0.14: 229.13,36.08 232.87,36.08 R279.1
PCIE_CLKREQ8#: length 10.3
  TOP w0.14: v1(223.46,33.44) 223.46,33.71 U14.AE41
  BOTTOM w0.14: v1(223.46,33.44) 224.1,34.08 226.04,34.08 226.26,34.3 226.26,34.62 226.63,34.99 226.63,36.21 v1(226.97,36.55) 227.58,37.17 228.07,37.17 228.32,36.92 228.56,36.92 228.75,36.74 230.35,36.74 R864.1
PCIE_CLKREQ9#: length 4.2
  TOP w0.14: R338.1 229.06,33.26 228.93,33.39 226.92,33.39 226.84,33.31 U14.AF48
PCIE_CLKREQ10#: length 12.8
  TOP w0.14: U14.AC41 223.13,34.96 v1(223.13,34.56)
  BOTTOM w0.14: v1(223.13,34.56) 223.69,35.12 223.83,35.12 224.25,35.54 224.51,35.54 224.8,35.83 225.33,35.83 225.76,36.26 225.76,36.98 226.25,37.47 226.25,38.13 226.05,38.33 226.05,38.76 226.56,39.27 v1(226.56,39.78) 227.19,40.4 227.63,40.4 228.49,41.26 230.29,41.26 R832.1
PCIE_CLKREQ11#: length 17.3
  TOP w0.14: v1(222.47,34.56) 222.47,35.06 U14.AC39
  BOTTOM w0.14: R831.1 233.15,41.57 231.06,41.57 231.03,41.54 228.36,41.54 227.82,41 v1(227.11,41) 226.62,41 225.85,40.23 225.85,38.96 225.75,38.85 225.75,38.24 225.97,38.02 225.97,37.58 225.48,37.09 225.48,36.38 225.21,36.11 224.68,36.11 224.39,35.82 224.13,35.82 223.71,35.4 223.31,35.4 v1(222.47,34.56)
PCIE_CLKREQ12#: length 18.4
  TOP w0.14: v1(222.8,33.47) 222.8,33.6 U14.AE39
  BOTTOM w0.14: R825.1 232.49,43.03 231.26,43.03 230.94,42.72 227.83,42.72 225.57,40.46 225.57,39.07 225.04,38.54 225.04,37.39 224.58,36.92 224.07,36.92 223.88,36.73 223.88,35.96 223.59,35.68 223.19,35.68 222.57,35.06 222.23,35.06 221.99,34.81 221.99,34.28 v1(222.8,33.47)
PCIE_CLKREQ13#: length 4.5
  TOP w0.102: R281.1 229.19,36.56 228.36,35.73 228.21,35.73 227.99,35.5 226.78,35.5 U14.AB48
PCIE_CLKREQ14#: length 8.5
  TOP w0.102: U14.AC44 225.45,35.75 225.7,35.75 226.09,36.14 226.8,36.14 227.03,35.91 227.79,35.91 228.14,36.26
  TOP w0.14: v1(228.98,38.61) 228.98,38.29 228.87,38.19 228.87,36.99 228.14,36.26
  BOTTOM w0.14: v1(228.98,38.61) 229.54,38.61 v1(229.63,38.69) 229.63,38.69 229.68,38.75 230.41,38.75 R846.1
PCIE_CLKREQ15#: length 11.1
  TOP w0.14: v1(223.8,34.56) 223.8,34.87 U14.AC43
  BOTTOM w0.14: v1(223.8,34.56) 223.8,34.7 224.36,35.26 224.63,35.26 224.91,35.55 225.44,35.55 226.04,36.15 226.04,36.86 226.53,37.35 226.53,38.25 226.42,38.36 226.33,38.45 226.33,38.65 227.09,39.41 229.12,39.41 v1(229.68,39.97) 229.69,39.98 R835.1
PCIE_CLKREQ_LAN#: length 265.4
  TOP w0.14: v1(218.35,26.19) 218.28,26.19 217.99,25.9 U14.BB30
  IN2 w0.089: v1(218.35,26.19) 219.27,25.27 219.27,20.61 218.69,20.03 216.52,20.03 215.89,19.41 211.37,19.41 208.96,17 v1(208.96,15.69)
  IN3 w0.089: v1(218.35,26.19) 218.35,25.8 216.22,23.67 214.7,23.67 214.49,23.89 213.11,23.89 212.71,23.49 211.92,23.49 211.58,23.83 210.67,23.83 210.55,23.72 206.36,23.72 205.72,23.08 199.13,23.08 198.47,23.74 197.94,23.74 197.44,24.24 197.44,29.64 195.52,31.56 194.63,31.56 192.92,33.27 191.91,33.27 191.33,33.85 191.33,34.1 188.01,37.42 178.16,37.42 176.87,36.13 98.73,36.13 98.58,35.98 96.81,35.98 96.25,36.55 94.4,36.55 93.98,36.12 93.55,36.12 92.05,37.62 90.15,37.62 89.75,38.02 87.82,38.02 87.59,37.79 85.6,37.79 85.15,38.24 83.89,38.24 81.71,36.06 80.09,36.06 78.86,37.28 76.21,37.28 76.14,37.35 72.63,37.35 71.92,38.07 70.78,38.07 70.55,38.3 68.87,38.3 68.55,38.61 56.6,38.61 v1(56.42,38.79)
  IN4 w0.086: v1(12.52,29.07) 12.34,29.25 12.34,34.79 13.1,35.55 13.1,38.65 14.44,39.98 16.93,39.98 18.07,38.84 19.34,38.84 20.89,37.29 25.06,37.29 26.57,38.8 27.35,38.8 30.2,35.95 35.23,35.95 35.54,35.64 38.83,35.64 39.06,35.41 39.06,35.04 40.21,33.89 41.06,33.89 42.98,35.81 44.93,35.81 45.88,36.76 46.21,36.76 46.45,36.52 46.45,36.06 47.23,35.28 48.77,35.28 49.88,36.39 51.92,36.39 52.24,36.07 53.36,36.07 55.77,38.48 56.12,38.48 v1(56.42,38.79)
  BOTTOM w0.14: v1(12.52,29.07) 12.3,29.29 12.3,29.77 12.07,30 CN17.33 ; R1119.1 212.46,13.66 210.69,13.66 209.56,14.78 209.56,15.09 v1(208.96,15.69)
PCIE_CLKREQ_NGFF1#: length 54.1
  TOP w0.102: v1(217.68,20.75) 218.08,21.15 218.08,21.57 218.18,21.67 218.36,21.67 218.61,21.92 218.61,22.25 218.37,22.5 218.37,23.29 218.13,23.52 U14.BF31
  TOP w0.14: v1(217.68,20.75) 217.68,20.5 217.98,20.2 218.17,20.2 218.6,19.77 218.6,18.01 217.92,17.33 217.92,16.65 217.26,15.99 217.26,15.41 216.94,15.08 216.63,15.08 216.16,14.61 R576.1
  IN2 w0.089: v1(217.68,20.75) 216.92,20.75 216.17,19.99 211.12,19.99 210.12,18.99 207.92,18.99 207.35,19.56 207.35,21.24 208.39,22.28 208.39,23.22 207.09,24.52 207.09,25.66 206.29,26.46 206.29,27.14 206.01,27.42 205.73,27.42 204.81,28.33 204.81,30.16 203.68,31.29 202.01,31.29 201.48,31.82 201.48,31.95 196.24,37.19 196.24,37.85 194.47,39.62 v1(194.2,39.62)
  BOTTOM w0.14: v1(194.2,39.62) 194.84,40.25 CN15.52
PCIE_CLKREQ_NGFF2#: length 39.7
  TOP w0.14: U14.AN29 217.27,30.21 216.88,29.82 v1(216.88,29.66)
  IN4 w0.086: v1(214.77,14.54) 214.77,14.59 214.64,14.72 211.8,14.72 211.58,14.95 211.17,14.95 211.02,15.1 210.25,15.1 210.2,15.15 202.58,15.15 v1(200.1,12.67)
  BOTTOM w0.102: 214.76,22.79 214.4,23.15 214.4,23.73 213.99,24.15 213.99,24.77 214.33,25.11 214.33,26.18 214.73,26.59 214.73,27.19 215.74,28.19 215.74,28.51 v1(216.88,29.66)
  BOTTOM w0.14: 214.76,22.79 214.76,21.11 215.7,20.18 215.7,19.04 216.05,18.69 216.05,18.25 215.77,17.97 215.08,17.97 R1098.1 214.83,16.8 214.83,14.61 v1(214.77,14.54) ; v1(200.1,12.67) 200.1,13.29 v1(198.88,14.51) 198.19,15.2 CN18.52
PCIE_CLKREQ_TBT#: length 53.9
  TOP w0.14: R305.1 232.26,34.01 230.1,34.01 230.06,34.05 v1(229.71,34.05) 229.16,34.05 228.76,33.65 226.11,33.65 U14.AE47
  IN1 w0.086: v1(229.71,34.05) 229.71,36.57 228.47,37.81 227.68,37.81 226.92,38.57 226.92,42.69 228.57,44.34 229.82,44.34 v1(230.27,44.79)
  IN2 w0.089: v1(246.6,50.94) 246.6,49.64 244.98,48.01 244.98,45.99 243.74,44.76 241,44.76 240.18,43.93 237.93,43.93 v1(236.67,45.19)
  IN3 w0.089: v1(230.27,44.79) 232.19,44.79 233.04,43.94 233.04,43.34 233.33,43.05 234.39,43.05 234.6,43.27 235.73,43.27 236.67,44.2 v1(236.67,45.19)
  BOTTOM w0.14: v1(246.6,50.94) 247.59,50.94 248.38,50.15 Q69.1 252.28,50.69 253.24,50.69 253.61,50.33 R791.2
PCIE_CLKREQ_TBT#_C: length 9
  TOP w0.089: U7.AC5 257.79,54.32 257.63,54.47 256.36,54.47 v1(256.2,54.32)
  BOTTOM w0.14: v1(256.2,54.32) 256,54.52 R767.1 254.75,53.99 254.53,53.76 254.53,52.52 254.12,52.11 254.12,51.33 R791.1 252.67,51.1 Q69.3
PCIE_CLKREQ_VGA#: length 314.2
  TOP w0.102: U14.BE31 218.36,24.37 218.36,23.58 218.57,23.37 218.57,22.58 218.82,22.34 218.82,21.73 218.58,21.49 v1(218.58,21.24) 218.68,21.14 218.68,21 219.22,20.46 R490.1
  TOP w0.14: QG13.3 43.36,83.27 v1(43.24,83.15)
  IN2 w0.089: v1(43.24,83.15) 41.74,83.15 40.49,81.9 40.49,81.5 39.59,80.61 37.82,80.61 37.19,81.25 34.8,81.25 34.29,81.76 32,81.76 31.39,81.14 30.91,81.14 30.63,81.42 24.41,81.42 23.42,82.4 23.42,83.42 20.5,86.34 16.55,86.34 14.15,83.94 14.15,83.67 13.94,83.45 13.94,78.93 13.48,78.47 13.48,77.46 14.27,76.67 14.27,71.32 13.86,70.91 13.86,69.41 14.42,68.86 14.42,68.76 14.66,68.53 14.66,61.34 15.68,60.31 15.68,59.83 15.84,59.67 15.84,59.66 16.78,58.72 16.78,57.48 18.15,56.11 18.69,56.11 18.7,56.1 19.26,56.1 20.68,54.68 20.68,53.52 21.73,52.47 22.35,52.47 22.5,52.62 23.26,52.62 23.59,52.29 23.59,49.78 24.94,48.43 25.2,48.43 25.51,48.11 25.51,47.3 27.43,45.38 28.8,45.38 29.41,44.77 29.41,44.36 30.83,42.94 32.64,42.94 33.17,43.47 37.3,43.47 37.9,42.87 37.9,41.17 38.6,40.47 44.25,40.47 45.19,41.41 45.19,44.68 45.57,45.06 46.23,45.06 47.07,45.9 47.07,47.73 48.43,49.08 49.42,49.08 50.51,48 51.36,48 v1(51.86,47.5)
  IN3 w0.089: v1(51.86,47.5) 53.93,45.43 53.93,42.88 54.25,42.55 54.25,42.17 53.96,41.87 53.96,41.16 53.62,40.82 53.62,38.69 54.5,37.81 61.08,37.81 61.68,37.2 66.43,37.2 67.62,36.01 68.59,36.01 68.84,36.26 69.7,36.26 69.87,36.08 71.58,36.08 72.36,35.31 75.09,35.31 75.29,35.11 79.09,35.11 79.68,34.53 82.41,34.53 83.36,35.47 85.45,35.47 85.94,35.97 87.69,35.97 89.15,34.52 91.77,34.52 92.6,33.69 95.58,33.69 96.12,33.15 97,33.15 97.28,33.44 98.3,33.44 99.42,34.57 111.21,34.57 111.89,33.88 165.97,33.88 166.46,34.37 179.43,34.37 180.85,35.79 184.99,35.79 190.09,30.69 190.09,27.55 192.97,24.67 192.97,23.04 193.21,22.81 195.56,22.81 196.14,22.22 196.14,21.96 197.91,20.19 205.37,20.19 205.76,19.8 215.82,19.8 216.06,20.04 218.28,20.04 218.74,20.49 218.74,21.08 v1(218.58,21.24)
PCIE_CLKREQ_WLAN#: length 198.1
  TOP w0.14: Q28.3 54.7,40.95 54.7,40.03 v1(54.65,39.98) ; v1(218.43,26.89) 218.27,26.89 217.8,26.41 U14.BA30
  IN3 w0.089: v1(54.65,39.98) 54.65,39.98 55.57,39.98 55.67,40.08 56.62,40.08 57.87,38.83 68.64,38.83 68.96,38.52 70.42,38.52 70.86,38.96 71.9,38.96 72.32,38.55 72.32,37.97 72.72,37.57 76.23,37.57 76.3,37.5 79.08,37.5 79.37,37.2 82.55,37.2 83.8,38.45 85.24,38.45 85.69,38 87.5,38 87.73,38.24 89.84,38.24 90.24,37.84 92.14,37.84 93.53,36.45 94,36.45 94.31,36.76 96.34,36.76 96.9,36.2 98.49,36.2 98.64,36.34 176.78,36.34 178.07,37.64 188.1,37.64 191.55,34.19 191.55,33.94 192,33.49 193.01,33.49 194.72,31.78 195.61,31.78 197.66,29.73 197.66,24.35 198.05,23.96 198.58,23.96 199.24,23.3 205.63,23.3 206.27,23.93 210.46,23.93 210.58,24.05 211.67,24.05 212.01,23.7 212.62,23.7 213.02,24.1 214.58,24.1 214.79,23.89 216.13,23.89 217.95,25.7 217.95,26.57 218.27,26.89 v1(218.43,26.89)
  BOTTOM w0.102: 220.22,20.77 220.22,20.95 220.09,21.08 220.09,21.45 219.11,22.43 219.11,25.16 218.76,25.51 218.76,26.56 v1(218.43,26.89)
  BOTTOM w0.14: R1129.1 222.85,14.35 222.85,14.98 222.57,15.26 222.08,15.26 221.95,15.13 221.6,15.13 221.3,15.44 221.3,15.75 221.08,15.96 220.95,15.96 220.62,16.3 220.62,17.52 220.32,17.82 220.32,18.94 220.22,19.03 220.22,20.77
PCIE_RXN9_SSD: length 64.4
  TOP w0.14: v1(220.52,43.2) 220.52,42.76 U14.G36
  IN1 w0.086: v1(185.38,52.31) 185.61,52.08 185.8,52.08 186.12,52.41 186.46,52.41 186.78,52.08 187.02,52.08 187.11,52.17 187.11,52.27 187.29,52.45 187.72,52.45 187.91,52.27 187.91,52.17 187.99,52.08 188.39,52.08 188.78,52.47 188.78,53.09 188.97,53.28 189.42,53.28 189.8,52.9 189.8,51.6 189.61,51.42 188.82,51.42 188.68,51.28 188.68,51.05 188.76,50.96 192.32,50.96 192.57,51.21 193.73,51.21 194.35,51.83 195.37,51.83 195.66,52.12 196.39,52.12 196.94,52.68 199.7,52.68 199.99,52.39 199.99,51.96 200.11,51.84 200.4,51.84 200.49,51.93 200.49,52.34 200.67,52.53 201.12,52.53 201.3,52.34 201.3,52.04 201.39,51.95 202.16,51.95 202.29,52.08 202.29,53.25 202.53,53.49 206.69,53.49 207.24,54.04 208.83,54.04 209.74,53.13 218.23,53.13 219.49,51.87 219.49,51.47 219.58,51.38 220.16,51.38 220.4,51.14 220.4,50.64 220.16,50.4 219.63,50.4 219.54,50.31 219.54,49.94 219.63,49.85 221.07,49.85 221.31,49.61 221.31,49.08 221.13,48.9 220.29,48.9 220.21,48.81 220.21,48.5 220.38,48.33 221.11,48.33 221.29,48.14 221.29,47.84 221.07,47.62 221.07,45.92 221.18,45.81 221.64,45.81 221.85,45.6 221.85,45.2 221.66,45 220.25,45 220.08,44.84 220.08,44.6 220.17,44.52 221.7,44.52 221.85,44.37 221.85,43.92 221.23,43.3 220.62,43.3 v1(220.52,43.2)
  BOTTOM w0.14: R782.1 185.98,52.15 185.54,52.15 v1(185.38,52.31)
PCIE_RXN9_SSD_R: length 2.8
  BOTTOM w0.14: R782.2 187.43,51.9 188.71,51.9 188.81,52 CN15.5
PCIE_RXN10_SSD: length 64.3
  TOP w0.14: v1(220.82,42.1) 220.82,41.58 U14.K37
  IN1 w0.086: v1(184.87,49.3) 184.84,49.27 184.72,49.27 184.6,49.39 184.6,49.95 184.4,50.15 183.76,50.15 183.54,50.37 183.54,50.49 184.08,51.03 184.9,51.03 185.09,50.83 185.09,49.99 185.28,49.81 185.69,49.81 185.87,49.99 185.87,51.16 186.02,51.31 186.2,51.31 186.36,51.15 186.36,49.68 186.6,49.45 186.93,49.45 187.12,49.63 187.12,51.27 187.2,51.36 187.45,51.36 187.54,51.27 187.54,50.6 187.74,50.4 188.3,50.4 188.46,50.24 193.03,50.24 193.28,50.49 194.35,50.49 194.77,50.91 196.19,50.91 197.24,51.96 198.04,51.96 198.53,51.46 199.36,51.46 200.34,50.48 200.83,50.48 201.01,50.66 201.01,51.14 201.1,51.23 201.3,51.23 201.6,50.93 201.91,50.93 202.21,51.23 202.64,51.23 203.01,51.6 203.01,52.58 203.2,52.77 206.99,52.77 207.54,53.32 208.53,53.32 209.44,52.41 217.91,52.41 218.7,51.63 218.7,51.24 218.98,50.96 218.98,50.77 218.7,50.49 218.7,49.33 218.89,49.13 219.37,49.13 219.48,49.02 219.48,48.19 220.35,47.33 220.35,46.13 219.1,44.88 219.1,43.28 219.41,42.97 219.87,42.97 220.25,42.58 220.74,42.58 220.94,42.38 220.94,42.23 v1(220.82,42.1)
  BOTTOM w0.14: v1(184.87,49.3) 184.78,49.21 184.78,49.01 184.93,48.85 186.07,48.85 186.26,49.04 186.26,49.25 R796.1
PCIE_RXN10_SSD_R: length 2.8
  BOTTOM w0.14: CN15.17 188.79,49 188.7,48.91 187.38,48.91 R796.2
PCIE_RXN11_SSD: length 64.3
  TOP w0.14: U14.G38 221.88,42.99 v1(221.72,43.15)
  IN1 w0.086: v1(221.72,43.15) 222.02,42.85 222.02,42.73 221.91,42.62 221.91,42.43 221.15,41.67 220.31,41.67 219.85,41.21 219.5,41.21 219.34,41.05 218.4,41.05 217.93,41.52 217.93,44.26 219.7,46.04 219.7,47.42 218.81,48.31 217.41,48.31 216.23,49.5 216.23,50.22 215.58,50.87 214.81,50.87 214.43,50.49 212.42,50.49 210.9,48.97 210.15,48.97 210.06,49.06 210.06,49.19 210.43,49.55 210.43,49.86 210.25,50.04 209.32,50.04 209.24,50.13 209.24,50.28 209.02,50.5 208.6,50.5 208.41,50.32 208.41,49.81 207.38,48.77 197.28,48.77 195.85,47.34 195.44,47.34 195.26,47.16 195.26,46.54 195.15,46.43 194.87,46.43 194.77,46.53 194.77,47.16 194.59,47.34 194.23,47.34 193.96,47.07 193.74,47.07 193.48,47.34 192.93,47.34 192.73,47.14 192.73,46.79 192.63,46.69 192.42,46.69 192.33,46.78 192.33,47.15 192.15,47.34 190.38,47.34 190.2,47.16 190.2,46.31 190.11,46.22 189.79,46.22 189.61,46.04 189.61,44.86 189.48,44.72 189.31,44.72 189.22,44.81 189.22,46.04 189.04,46.22 188.68,46.22 188.5,46.04 188.5,45.55 188.41,45.46 188.2,45.46 188.11,45.56 188.11,46.14 187.9,46.34 187.57,46.34 187.39,46.16 187.39,45.41 187.3,45.32 187.09,45.32 186.99,45.42 186.99,46.04 186.81,46.22 186.5,46.22 186.08,45.81 185.93,45.81 185.63,46.1 185.3,46.1 v1(185.11,46.3)
  BOTTOM w0.14: v1(185.11,46.3) 185.25,46.16 185.82,46.16 R810.1
PCIE_RXN11_SSD_R: length 2.9
  BOTTOM w0.14: CN15.29 188.83,46 188.69,45.86 188.13,45.86 187.83,46.17 187.33,46.17 R810.2
PCIE_RXN12_SSD: length 65.1
  TOP w0.14: v1(223.01,41.57) 223.18,41.57 223.93,42.32 U14.H42
  IN1 w0.086: v1(223.01,41.57) 222.76,41.82 222.32,41.82 221.45,40.95 220.78,40.95 220.33,40.49 219.82,40.49 219.64,40.31 217.84,40.31 216.46,41.69 216.46,43.64 215.77,44.33 214.91,44.33 214.68,44.11 210.63,44.11 210.07,43.54 209.58,43.54 208.48,44.64 204.18,44.64 203.95,44.42 203.95,43.52 203.77,43.34 203.32,43.34 203.14,43.52 203.14,44.28 203.05,44.36 202.46,44.36 201.82,43.73 198.34,43.73 198.17,43.56 198.17,42.36 197.99,42.18 197.42,42.18 197.24,42.36 197.24,43.85 197,44.08 196.68,44.08 196.46,43.87 196.46,42.43 196.11,42.08 194.33,42.08 193.92,42.49 193.78,42.49 193.64,42.35 193.64,41.94 193.46,41.76 193.02,41.76 192.84,41.94 192.84,42.4 192.75,42.49 192.52,42.49 192.34,42.31 192.34,41.06 191.82,40.55 190.82,40.55 190.61,40.75 190.61,41.96 190.52,42.06 190.27,42.06 190.18,41.97 190.18,40.89 189.96,40.67 188.54,40.67 188.32,40.89 188.32,41.24 188.5,41.42 188.96,41.42 189.17,41.63 189.17,41.89 188.81,42.25 187.41,42.25 187.18,42.02 187.18,41.17 186.91,40.89 185.39,40.89 185.18,41.1 185.18,41.48 185.41,41.71 186.33,41.71 186.42,41.79 186.42,42.52 186.04,42.89 185.24,42.89 v1(185.01,42.66)
  BOTTOM w0.14: v1(185.01,42.66) 185.18,42.83 185.82,42.83 R827.1
PCIE_RXN12_SSD_R: length 2.9
  BOTTOM w0.14: R827.2 187.34,42.83 187.48,42.83 187.69,42.62 188.45,42.62 188.56,42.5 CN15.43
PCIE_RXN14_LAN: length 267.4
  TOP w0.14: U14.D46 225.69,44.48 v1(225.39,44.19)
  IN1 w0.086: v1(10.42,32.74) 10.42,32.37 10.34,32.28 10.06,32.28 9.86,32.47 9.86,35.64 11.31,37.08 11.31,39.67 12.13,40.49 12.13,43.81 13.44,45.12 14.97,45.12 16,44.09 18.84,44.09 20.18,42.75 20.18,40.46 22.38,38.26 25.51,38.26 27.45,40.2 27.45,40.83 28.53,41.91 30.26,41.91 31.72,40.45 33.87,40.45 34.56,39.75 37.03,39.75 37.11,39.68 38.83,39.68 39.16,39.35 44.4,39.35 44.88,39.83 47.95,39.83 49.65,38.14 53.21,38.14 54.31,37.04 57.11,37.04 57.72,36.43 59.45,36.43 59.58,36.3 61.49,36.3 62.09,36.91 63.73,36.91 64.08,36.56 66.74,36.56 67.44,35.86 74.52,35.86 75,35.38 83.02,35.38 83.12,35.29 84.86,35.29 85.03,35.11 88.46,35.11 90.11,33.47 92.28,33.47 92.56,33.75 100.63,33.75 101.35,33.03 151.91,33.03 151.95,32.99 174.79,32.99 181.21,39.41 181.21,45.04 181.64,45.47 181.64,46.06 181.24,46.45 181.24,50.87 181.79,51.41 182.6,51.41 183.53,52.34 183.53,52.8 184.33,53.6 184.79,53.6 187.57,56.38 188.75,56.38 189.03,56.67 190.1,56.67 191.32,55.44 195.06,55.44 195.5,54.99 199.4,54.99 199.59,54.8 205.51,54.8 206.19,55.48 208.97,55.48 210.22,54.23 218.95,54.23 220.45,52.74 221.44,52.74 222.24,51.95 222.24,50.97 221.78,50.52 221.78,48.89 224.69,45.98 225.49,45.98 226.04,45.43 226.04,44.87 225.88,44.71 225.88,44.32 225.75,44.19 v1(225.39,44.19)
  BOTTOM w0.14: CN17.38 11.33,32.5 11.2,32.37 10.56,32.37 10.42,32.51 v1(10.42,32.74)
PCIE_RXN15_WLAN: length 213.1
  TOP w0.14: v1(224.49,43.76) U14.F44
  IN1 w0.086: v1(55.62,43.36) 55.38,43.12 54.95,43.12 54.75,42.92 54.75,41.61 53.98,40.84 53.98,38.56 54.75,37.79 64.32,37.79 64.87,37.25 68.64,37.25 68.81,37.07 70.91,37.07 71.08,36.91 74.36,36.91 75.26,36.01 83.31,36.01 83.4,35.92 85.12,35.92 85.13,35.92 85.2,35.92 85.36,35.75 88.74,35.75 89.99,34.51 92.39,34.51 92.86,34.98 94.23,34.98 94.66,34.56 95.64,34.56 96.33,35.25 100.07,35.25 101.65,33.66 151.49,33.66 151.53,33.7 174.53,33.7 180.57,39.75 180.57,51.16 181.6,52.19 182.3,52.19 182.9,52.79 182.9,53.06 184.05,54.21 184.05,54.72 184.58,55.25 185.38,55.25 187.35,57.23 188.66,57.23 188.8,57.38 191.52,57.38 192.83,56.07 195.52,56.07 195.97,55.63 200.13,55.63 200.58,56.07 201.31,56.07 201.94,55.44 205.2,55.44 205.96,56.2 209.34,56.2 210.68,54.87 219.24,54.87 220.68,53.42 221.66,53.42 222.87,52.21 222.87,50.7 222.42,50.26 222.42,49.37 224.98,46.81 225.58,46.81 226.79,45.6 226.79,44.11 226.47,43.79 225.03,43.79 225,43.76 v1(224.49,43.76)
  BOTTOM w0.14: CN16.43 56.61,43.25 56.53,43.17 55.81,43.17 v1(55.62,43.36)
PCIE_RXN17_TBT: length 64.1
  TOP w0.14: U14.K43 v1(224.48,40.78) ; C215.2 260.33,42.79 260.33,42.14 v1(260.18,41.99)
  IN4 w0.086: v1(260.18,41.99) 260.37,41.79 260.37,41.47 260.29,41.39 260.1,41.39 259.85,41.64 259.51,41.64 259.32,41.46 259.32,40.02 259.66,39.69 259.66,39.48 259.51,39.33 258.85,39.33 258.73,39.46 258.73,41.48 258.49,41.72 257.77,41.72 257.44,41.38 256.89,41.38 256.8,41.46 256.8,41.53 256.62,41.72 256.06,41.72 255.88,41.53 255.88,41.46 255.79,41.38 255.4,41.38 255,40.97 255,38.74 254.9,38.64 254.64,38.64 253.82,39.47 253.82,39.61 254.26,40.06 254.26,40.31 253.88,40.69 252.98,40.69 252.79,40.51 252.79,40.21 252.69,40.1 252,40.1 251.48,40.62 250.99,40.62 250.86,40.75 250.86,41.59 250.68,41.77 250.17,41.77 249.98,41.59 249.98,40.86 249.87,40.75 249.46,40.75 249.36,40.85 249.36,41.93 249.16,42.12 248.61,42.12 248.43,41.94 248.43,40.98 248.34,40.89 247.92,40.89 247.84,40.98 247.84,41.26 247.65,41.44 245.7,41.44 245.51,41.26 245.51,40.55 245.21,40.25 240.21,40.25 239.62,40.84 238.04,40.84 237.8,40.6 237.8,40.1 237.63,39.93 237.29,39.93 237.15,40.07 237.15,41.5 236.4,42.25 236.06,42.25 235.6,41.8 235.6,41.64 235.47,41.51 235.1,41.51 234.92,41.69 234.51,41.69 234.33,41.51 228.41,41.51 227.96,41.06 227.24,41.06 227.15,41.15 227.15,42.03 227.21,42.09 227.52,42.09 227.76,42.33 227.76,42.58 227.36,42.98 226.44,42.98 226.01,42.55 226.01,42.15 226.32,41.84 226.32,41.04 226.23,40.96 225.66,40.96 225.58,41.04 225.58,41.59 225.39,41.77 224.68,41.77 224.44,41.54 224.44,41.25 224.55,41.13 224.55,40.86 v1(224.48,40.78)
PCIE_RXN17_TBT_C: length 3.4
  TOP w0.089: 260.36,44.01 260.36,44.03 260.4,44.08 260.4,44.59 260.22,44.77 260.22,45.69 260.04,45.86 260.04,46.26 U7.V22
  TOP w0.14: C215.1 260.36,43.69 260.36,44.01
PCIE_RXN18_TBT: length 64.3
  TOP w0.14: v1(262.37,42) 262.17,42.2 262.17,42.77 C218.2 ; U14.P41 223.31,39.04 v1(223.51,38.85)
  IN4 w0.086: v1(223.51,38.85) 223.39,38.85 223.25,38.99 223.25,39.21 223.06,39.4 222.39,39.4 221.97,39.82 221.97,40.13 222.05,40.21 226.68,40.21 226.8,40.33 228.3,40.33 228.76,40.78 229.33,40.78 229.42,40.7 229.42,39.94 229.6,39.75 230.15,39.75 230.34,39.95 230.34,40.69 230.44,40.78 236.06,40.78 236.4,40.44 236.4,39.92 236.07,39.6 236.07,39.22 236.26,39.04 237.98,39.04 238.53,39.59 238.53,39.97 238.68,40.11 239.03,40.11 239.18,39.97 239.18,39.22 239.36,39.04 239.95,39.04 240.13,39.22 240.13,39.44 240.22,39.53 240.64,39.53 240.72,39.44 240.72,39.22 240.91,39.04 241.47,39.04 241.65,39.22 241.65,39.44 241.74,39.53 242.16,39.53 242.24,39.44 242.24,39.22 242.43,39.04 242.99,39.04 243.17,39.22 243.17,39.44 243.25,39.53 243.68,39.53 243.76,39.44 243.76,39.22 243.95,39.04 244.5,39.04 244.69,39.22 244.69,39.44 244.77,39.53 245.2,39.53 245.28,39.44 245.28,39.22 245.46,39.04 245.99,39.04 246.24,39.28 246.24,40.51 246.42,40.69 247.11,40.69 247.21,40.59 247.21,39.01 247.49,38.73 248.69,38.73 248.88,38.92 248.88,39.35 248.98,39.45 249.18,39.45 249.27,39.37 249.27,38.91 249.45,38.73 249.83,38.73 250.04,38.93 250.04,39.93 250.16,40.06 250.4,40.06 250.53,39.94 250.53,39.85 250.71,39.67 251.32,39.67 251.86,39.13 252.31,39.13 252.56,39.38 252.89,39.38 254.06,38.21 254.06,37.15 254.3,36.91 254.74,36.91 254.92,37.09 254.92,37.81 255.01,37.9 255.29,37.9 255.37,37.81 255.37,37.6 255.58,37.39 257.49,37.39 258.71,38.61 259.81,38.61 260.47,39.27 260.47,40.5 260.68,40.71 261.31,40.71 262.13,41.53 262.13,41.76 v1(262.37,42)
PCIE_RXN18_TBT_C: length 3.4
  TOP w0.089: U7.P22 262.22,46.4 262.34,46.27 262.34,45.85 262.2,45.71 262.2,44.72 262.1,44.62 262.1,44.26 262.15,44.2
  TOP w0.14: 262.15,44.2 262.15,43.69 C218.1
PCIE_RXN19_TBT: length 64.7
  TOP w0.14: v1(224.4,39.16) 224.38,39.18 224.38,39.84 U14.M44 ; v1(263.98,41.99) 263.79,42.17 263.79,42.86 C220.2
  IN4 w0.086: v1(263.98,41.99) 263.73,41.74 263.73,41.3 263.02,40.6 263.02,40.26 262.29,39.53 261.51,39.53 260.04,38.06 258.97,38.06 258.64,37.72 258.64,37.51 259.78,36.37 259.78,36.11 259.01,35.35 258.74,35.35 258.41,35.67 258.41,36.47 258.04,36.84 257.87,36.84 257.29,36.26 256.92,36.26 256.68,36.5 256.68,36.74 256.59,36.83 256.35,36.83 256.21,36.69 256.21,35.86 256.3,35.77 257.06,35.77 257.25,35.59 257.25,35.16 257.06,34.98 256.31,34.98 256.23,34.89 256.23,34.63 255.98,34.39 254.8,34.39 254.61,34.57 254.61,34.9 254.97,35.26 254.97,35.62 254.61,35.98 254.61,36.18 254.44,36.35 253.14,36.35 251.32,38.17 246.54,38.17 246.37,38.01 245.36,38.01 244.88,38.48 244.19,38.48 244.11,38.4 244.11,37.19 243.92,37.01 243.36,37.01 243.18,37.19 243.18,38.4 243.1,38.48 242.67,38.48 242.59,38.4 242.59,37.4 242.4,37.22 241.93,37.22 241.66,37.49 241.66,38.4 241.58,38.48 241.15,38.48 241.07,38.4 241.07,37.56 240.88,37.37 240.33,37.37 240.14,37.56 240.14,38.34 240,38.48 233.88,38.48 232.32,40.05 231.8,40.05 230.95,39.2 226.75,39.2 226.29,39.65 224.5,39.65 224.38,39.53 224.38,39.18 v1(224.4,39.16)
PCIE_RXN19_TBT_C: length 3.5
  TOP w0.089: 263.73,44.24 263.67,44.3 263.67,44.57 264.01,44.91 264.01,45.16 264.01,45.67 264.18,45.84 264.18,46.27 U7.K22
  TOP w0.14: C220.1 263.73,43.64 263.73,44.24
PCIE_RXN20_TBT: length 64.6
  TOP w0.14: v1(220.82,38.4) 220.77,38.4 U14.R35 ; v1(265.41,41.94) 265.22,42.13 265.22,42.84 C222.2
  IN4 w0.086: v1(265.41,41.94) 265.18,41.72 265.18,40.11 265.26,40.04 265.63,40.04 265.9,39.76 265.9,39.09 265.68,38.87 264.33,38.87 264.14,39.05 264.14,39.51 264.06,39.59 263.64,39.59 263.55,39.51 263.55,39.05 263.37,38.87 262.22,38.87 261.45,38.1 261.45,36.99 258.86,34.4 257.1,34.4 256.66,33.96 256.66,32.48 256.36,32.19 255.3,32.19 255.04,32.45 255.04,33.56 254.94,33.65 254.6,33.65 254.51,33.56 254.51,33.14 254.33,32.96 252.88,32.96 252.58,33.26 252.58,35.97 250.93,37.62 246.79,37.62 246.24,37.06 244.84,37.06 243.78,36.01 241.12,36.01 240.77,36.36 240.3,36.36 239.29,37.38 238.45,37.38 238.22,37.61 235.94,37.61 235.6,37.27 233.65,37.27 232.46,38.46 231.4,38.46 230.5,37.56 229.05,37.56 228.61,38 226.47,38 225.9,38.57 224.17,38.57 223.73,38.13 222.99,38.13 222.66,37.8 221.39,37.8 221.1,38.09 221.1,38.12 v1(220.82,38.4)
PCIE_RXN20_TBT_C: length 3.6
  TOP w0.089: 265.09,44.09 265.09,44.14 265.88,44.93 265.88,45.69 266.02,45.83 266.02,46.27 U7.F22
  TOP w0.14: 265.09,44.09 265.09,43.73 C222.1
PCIE_RXN21_SSD: length 65.1
  TOP w0.14: v1(224.37,37.52) 224.37,37.72 224.03,38.05 U14.T43
  IN1 w0.086: v1(185.07,21.39) 185.22,21.39 185.35,21.52 185.35,22.77 186.29,23.71 186.29,24.39 186.69,24.79 190.04,24.79 190.25,25.01 192.34,25.01 192.53,24.83 192.53,24.54 192.61,24.45 193.03,24.45 193.12,24.54 193.12,24.83 193.3,25.01 196.21,25.01 196.55,25.35 196.55,25.66 198.7,27.8 198.7,29.56 200.36,31.22 202.29,31.22 203.31,32.25 203.5,32.25 204.32,33.07 204.32,33.35 204.85,33.88 209.67,33.88 210.21,33.34 211.12,33.34 211.69,33.91 212.96,33.91 214.45,32.43 219.32,32.43 219.55,32.19 220.58,32.19 220.87,32.48 223.59,32.48 223.82,32.25 225.39,32.25 227.03,33.89 227.03,35.14 227.21,35.32 228.99,35.32 229.08,35.41 229.08,35.82 228.98,35.91 227.41,35.91 227.19,36.13 227.19,37.4 226.04,38.55 225.72,38.55 224.92,37.75 224.61,37.75 v1(224.37,37.52)
  BOTTOM w0.14: R1028.1 185.28,20.98 185.28,21.18 v1(185.07,21.39)
PCIE_RXN21_SSD_R: length 5.7
  BOTTOM w0.14: R1028.2 185.06,19.8 185.61,19.24 186.45,19.24 188.24,17.45 CN18.43
PCIE_RXN22_SSD: length 64.6
  TOP w0.14: v1(222.45,37.23) U14.U40
  IN1 w0.086: v1(222.45,37.23) 222.77,37.23 223.13,36.87 224.68,36.87 224.82,37.01 226.31,37.01 226.48,36.85 226.48,34.32 226.26,34.1 220.43,34.1 219.31,32.99 214.72,32.99 213.23,34.48 211.4,34.48 210.88,33.97 210.37,33.97 209.24,35.1 204.99,35.1 203.35,33.46 202.96,33.46 201.28,31.78 200.02,31.78 198.14,29.89 198.14,28.04 196.2,26.1 194.76,26.1 194.22,25.57 186.66,25.57 185.32,24.22 185.08,24.22 184.99,24.31 184.99,24.59 184.71,24.87 184.25,24.87 184.01,24.63 184.01,24.22 183.92,24.13 182.79,24.13 182.52,23.87 182.52,23.5 182.83,23.2 183.41,23.2 183.47,23.14 183.47,22.79 v1(183.2,22.52)
  BOTTOM w0.14: v1(183.2,22.52) 183.43,22.75 183.43,22.93 183.88,23.37 184.88,23.37 R985.1
PCIE_RXN22_SSD_R: length 5.2
  BOTTOM w0.14: R985.2 185.96,23.42 186.1,23.28 186.52,23.28 188.47,21.33 188.47,20.98 188.62,20.84 188.71,20.84 188.82,20.95 CN18.29
PCIE_RXN23_SSD: length 66.5
  TOP w0.14: v1(224.36,36.44) 224.36,36.6 U14.W43
  IN1 w0.086: v1(182.06,24.78) 182.29,25.02 182.29,25.24 182.66,25.61 185.64,25.61 186.45,26.42 187.12,26.42 187.36,26.66 189.05,26.66 189.14,26.74 189.14,27.74 189.32,27.92 189.88,27.92 190.06,27.74 190.06,26.21 190.15,26.12 190.54,26.12 190.64,26.22 190.64,27.79 190.82,27.97 191.33,27.97 191.52,27.79 191.52,26.21 191.6,26.12 192.02,26.12 192.11,26.21 192.11,27.48 192.29,27.66 192.85,27.66 193.04,27.48 193.04,26.21 193.12,26.12 193.53,26.12 193.63,26.22 193.63,27.48 193.81,27.66 196.13,27.66 197.24,28.78 197.24,31.66 197.75,32.17 199.63,32.17 199.79,32.33 201,32.33 202.85,34.18 203.08,34.18 205.04,36.14 206.32,36.14 206.77,35.69 210.47,35.69 210.97,36.19 212.32,36.19 214.92,33.58 219,33.58 219.51,34.1 219.51,34.71 220.22,35.41 223.95,35.41 224.59,36.05 224.59,36.21 v1(224.36,36.44)
  BOTTOM w0.14: v1(182.06,24.78) 182.33,25.05 182.33,25.12 182.57,25.37 183.71,25.37 184.16,25.81 184.91,25.81 R950.1
PCIE_RXN23_SSD_R: length 4.6
  BOTTOM w0.14: CN18.17 188.73,23.95 188.65,23.87 188.43,23.87 186.64,25.66 186.37,25.66 R950.2
PCIE_RXN24_SSD: length 65
  TOP w0.14: v1(222.78,36.01) 222.78,36.31 U14.Y40
  IN1 w0.086: v1(222.78,36.01) 222.85,36.01 222.93,36.09 222.93,36.28 222.73,36.48 222.04,36.48 221.86,36.66 221.86,37.48 221.75,37.59 221.35,37.59 221.27,37.5 221.27,35.99 221.08,35.8 220.57,35.8 220.34,36.04 220.34,37.58 220.26,37.67 219.86,37.67 219.75,37.55 219.75,36.66 219.56,36.48 218.98,36.48 218.62,36.12 218.62,35.6 218.37,35.34 217.02,35.34 216.83,35.53 216.83,35.77 216.75,35.86 216.32,35.86 216.24,35.77 216.24,35.53 216.06,35.34 215.5,35.34 215.31,35.53 215.31,35.95 215.2,36.07 214.81,36.07 214.72,35.98 214.72,35.53 214.54,35.34 213.73,35.34 212.48,36.59 210.48,36.59 210.4,36.51 210.4,36.31 210.17,36.08 209.66,36.08 209.47,36.26 209.47,36.51 209.39,36.59 208.97,36.59 208.88,36.51 208.88,36.3 208.66,36.08 208.14,36.08 207.95,36.26 207.95,36.51 207.87,36.59 207.48,36.59 207.05,37.02 204.13,37.02 203.83,36.71 203.83,35.54 203.27,34.99 201.66,34.99 201.36,34.68 201.36,33.24 201.04,32.93 200.7,32.93 200.45,33.18 200.45,34.9 200.33,35.02 199.97,35.02 199.83,34.89 199.83,33.03 199.51,32.71 199.16,32.71 198.97,32.89 198.97,33.93 198.87,34.04 197.96,34.04 197.78,33.85 197.78,32.75 196.21,31.17 192.7,31.17 192.25,30.73 191.06,30.73 190.98,30.64 190.98,29.99 190.72,29.73 190.27,29.73 190.06,29.94 190.06,31.36 190.24,31.54 190.55,31.54 190.66,31.65 190.66,31.91 190.56,32.01 189.74,32.01 189.51,31.78 189.51,30.06 189.13,29.68 187.98,29.68 187.88,29.58 v1(187.88,29.31)
  BOTTOM w0.14: R933.1 187.35,28.37 187.21,28.51 187.21,29.36 187.5,29.65 187.74,29.65 187.88,29.51 v1(187.88,29.31)
PCIE_RXN24_SSD_R: length 3.4
  BOTTOM w0.14: R933.2 187.37,27.59 187.23,27.45 187.23,27.23 187.71,26.74 188.52,26.74 188.73,26.95 CN18.5
PCIE_RXP9_SSD: length 64.4
  TOP w0.14: v1(220.87,43.81) 220.87,43.44 U14.F36
  IN1 w0.086: v1(220.87,43.81) 220.8,43.74 220.8,43.55 220.89,43.46 221.16,43.46 221.69,43.99 221.69,44.3 221.63,44.35 220.1,44.35 219.92,44.53 219.92,44.91 220.18,45.17 221.59,45.17 221.69,45.27 221.69,45.53 221.57,45.65 221.11,45.65 220.91,45.85 220.91,47.69 221.13,47.91 221.13,48.07 221.04,48.16 220.32,48.16 220.04,48.44 220.04,48.88 220.22,49.07 221.06,49.07 221.15,49.15 221.15,49.54 221,49.69 219.56,49.69 219.38,49.87 219.38,50.38 219.56,50.57 220.09,50.57 220.24,50.71 220.24,51.07 220.09,51.22 219.51,51.22 219.33,51.4 219.33,51.8 218.16,52.97 209.67,52.97 208.76,53.88 207.31,53.88 206.76,53.33 202.6,53.33 202.45,53.18 202.45,52.01 202.23,51.78 201.32,51.78 201.14,51.97 201.14,52.27 201.05,52.36 200.74,52.36 200.65,52.27 200.65,51.86 200.47,51.68 200.04,51.68 199.82,51.89 199.82,52.32 199.63,52.51 197.01,52.51 196.45,51.96 195.73,51.96 195.44,51.67 194.42,51.67 193.8,51.05 192.64,51.05 192.39,50.79 188.7,50.79 188.6,50.89 188.6,50.89 188.51,50.98 188.51,51.35 188.75,51.58 189.54,51.58 189.63,51.67 189.63,52.83 189.35,53.11 189.04,53.11 188.95,53.02 188.95,52.4 188.46,51.92 187.92,51.92 187.74,52.1 187.74,52.2 187.65,52.28 187.36,52.28 187.27,52.2 187.27,52.1 187.09,51.92 186.71,51.92 186.39,52.24 186.19,52.24 185.86,51.92 185.46,51.92 185.38,51.83 v1(185.38,51.59)
  BOTTOM w0.14: R787.1 186.19,51.71 186.05,51.85 185.56,51.85 185.38,51.67 v1(185.38,51.59)
PCIE_RXP9_SSD_R: length 2.8
  BOTTOM w0.14: CN15.7 188.82,51.5 188.68,51.64 187.15,51.64 186.97,51.46 R787.2
PCIE_RXP10_SSD: length 64.3
  TOP w0.14: U14.J37 221.41,42.48 v1(221.23,42.66)
  IN1 w0.086: v1(221.23,42.66) 220.9,42.66 220.81,42.75 220.32,42.75 219.94,43.13 219.48,43.13 219.26,43.34 219.26,44.81 220.52,46.06 220.52,47.39 219.65,48.26 219.65,49.08 219.44,49.29 218.96,49.29 218.86,49.39 218.86,50.42 219.14,50.7 219.14,51.03 218.86,51.31 218.86,51.7 217.98,52.58 209.51,52.58 208.6,53.49 207.47,53.49 206.93,52.94 203.13,52.94 202.85,52.65 202.85,51.67 202.57,51.39 202.14,51.39 201.84,51.09 201.67,51.09 201.37,51.39 201.03,51.39 200.85,51.21 200.85,50.73 200.76,50.65 200.41,50.65 199.43,51.63 198.59,51.63 198.1,52.12 197.17,52.12 196.12,51.07 194.71,51.07 194.29,50.65 193.21,50.65 192.96,50.4 188.53,50.4 188.37,50.56 187.81,50.56 187.7,50.67 187.7,51.34 187.52,51.52 187.13,51.52 186.95,51.34 186.95,49.7 186.87,49.62 186.66,49.62 186.53,49.75 186.53,51.22 186.27,51.48 185.95,51.48 185.7,51.23 185.7,50.06 185.62,49.98 185.35,49.98 185.26,50.06 185.26,50.9 184.97,51.19 184.01,51.19 183.38,50.56 183.38,50.3 183.7,49.99 184.33,49.99 184.44,49.88 184.44,49.52 v1(184.21,49.3)
  BOTTOM w0.14: v1(184.21,49.3) 184.51,49 184.51,48.9 184.82,48.59 185.91,48.59 R801.1
PCIE_RXP10_SSD_R: length 2.8
  BOTTOM w0.14: CN15.19 188.65,48.5 188.51,48.64 187.31,48.64 R801.2
PCIE_RXP11_SSD: length 64.3
  TOP w0.14: v1(222.42,42.76) 222.42,43.14 U14.F39
  IN1 w0.086: v1(185.13,45.63) 185.44,45.94 185.56,45.94 185.86,45.64 186.15,45.64 186.56,46.05 186.74,46.05 186.83,45.97 186.83,45.35 187.02,45.16 187.37,45.16 187.55,45.34 187.55,46.09 187.64,46.17 187.84,46.17 187.94,46.07 187.94,45.49 188.14,45.3 188.48,45.3 188.66,45.48 188.66,45.97 188.75,46.05 188.97,46.05 189.05,45.97 189.05,44.74 189.24,44.56 189.54,44.56 189.78,44.79 189.78,45.97 189.86,46.05 190.18,46.05 190.36,46.24 190.36,47.09 190.45,47.18 192.08,47.18 192.17,47.09 192.17,46.71 192.35,46.52 192.7,46.52 192.89,46.72 192.89,47.07 193,47.18 193.41,47.18 193.68,46.91 194.03,46.91 194.3,47.18 194.52,47.18 194.61,47.09 194.61,46.46 194.8,46.27 195.22,46.27 195.42,46.47 195.42,47.09 195.51,47.18 195.92,47.18 197.35,48.61 207.45,48.61 208.58,49.74 208.58,50.25 208.67,50.34 208.95,50.34 209.07,50.22 209.07,50.06 209.26,49.87 210.18,49.87 210.26,49.79 210.26,49.62 209.9,49.26 209.9,48.99 210.08,48.81 210.97,48.81 212.49,50.33 214.5,50.33 214.88,50.7 215.51,50.7 216.06,50.15 216.06,49.43 217.34,48.15 218.74,48.15 219.54,47.35 219.54,46.1 217.76,44.33 217.76,41.45 218.33,40.89 219.4,40.89 219.57,41.05 219.92,41.05 220.38,41.51 221.22,41.51 222.08,42.37 222.08,42.55 222.28,42.76 v1(222.42,42.76)
  BOTTOM w0.14: v1(185.13,45.63) 185.39,45.89 185.81,45.89 R816.1
PCIE_RXP11_SSD_R: length 2.9
  BOTTOM w0.14: CN15.31 188.75,45.5 188.65,45.6 188.02,45.6 187.72,45.9 187.36,45.9 R816.2
PCIE_RXP12_SSD: length 65.1
  TOP w0.14: v1(223.03,42.55) 223.22,42.36 U14.J41
  IN1 w0.086: v1(185.03,43.36) 185.03,43.14 185.12,43.06 186.11,43.06 186.58,42.58 186.58,41.73 186.4,41.54 185.48,41.54 185.35,41.41 185.35,41.16 185.45,41.06 186.84,41.06 187.02,41.23 187.02,42.09 187.34,42.42 188.88,42.42 189.33,41.96 189.33,41.56 189.03,41.26 188.57,41.26 188.48,41.17 188.48,40.96 188.6,40.84 189.89,40.84 190.02,40.96 190.02,42.04 190.2,42.22 190.59,42.22 190.78,42.03 190.78,40.82 190.88,40.72 191.76,40.72 192.17,41.13 192.17,42.38 192.45,42.65 192.82,42.65 193,42.47 193,42.01 193.09,41.93 193.39,41.93 193.48,42.01 193.48,42.42 193.71,42.65 193.99,42.65 194.4,42.24 196.04,42.24 196.3,42.5 196.3,43.94 196.61,44.25 197.07,44.25 197.4,43.92 197.4,42.43 197.49,42.35 197.92,42.35 198.01,42.43 198.01,43.63 198.27,43.9 201.75,43.9 202.39,44.53 203.12,44.53 203.3,44.34 203.3,43.59 203.39,43.5 203.7,43.5 203.79,43.59 203.79,44.48 204.11,44.8 208.55,44.8 209.64,43.71 210,43.71 210.56,44.27 214.61,44.27 214.84,44.5 215.84,44.5 216.63,43.71 216.63,41.75 217.91,40.48 219.58,40.48 219.75,40.66 220.26,40.66 220.71,41.11 221.38,41.11 222.26,42 222.95,42 223.03,42.08 v1(223.03,42.55)
  BOTTOM w0.14: R819.1 186.19,43.28 186.02,43.1 185.19,43.1 185.03,43.26 v1(185.03,43.36)
PCIE_RXP12_SSD_R: length 2.9
  BOTTOM w0.14: CN15.41 188.56,43 188.45,42.89 187.8,42.89 187.59,43.09 187.35,43.09 R819.2
PCIE_RXP14_LAN: length 267.4
  TOP w0.14: v1(226.35,44.28) 226.26,44.36 U14.C47
  IN1 w0.086: v1(226.35,44.28) 226.19,44.28 226.05,44.42 226.05,44.64 226.21,44.8 226.21,45.5 225.56,46.14 224.76,46.14 221.94,48.96 221.94,50.45 222.4,50.91 222.4,52.02 221.51,52.91 220.51,52.91 219.02,54.4 210.29,54.4 209.04,55.65 206.12,55.65 205.44,54.97 199.66,54.97 199.46,55.16 195.57,55.16 195.13,55.61 191.39,55.61 190.17,56.83 188.97,56.83 188.68,56.54 187.5,56.54 184.72,53.76 184.26,53.76 183.37,52.87 183.37,52.41 182.53,51.58 181.72,51.58 181.08,50.94 181.08,46.38 181.47,45.99 181.47,45.53 181.04,45.1 181.04,39.48 174.72,33.15 152.01,33.15 151.97,33.19 101.42,33.19 100.7,33.91 92.49,33.91 92.21,33.63 90.18,33.63 88.53,35.28 85.1,35.28 84.93,35.45 83.19,35.45 83.09,35.54 75.07,35.54 74.59,36.03 67.51,36.03 66.81,36.72 64.15,36.72 63.8,37.08 62.03,37.08 61.42,36.47 59.65,36.47 59.52,36.59 57.79,36.59 57.18,37.21 54.38,37.21 53.28,38.3 49.72,38.3 48.02,40 44.81,40 44.33,39.51 39.22,39.51 38.9,39.84 37.18,39.84 37.1,39.92 34.63,39.92 33.93,40.62 31.79,40.62 30.33,42.08 28.46,42.08 27.29,40.9 27.29,40.27 25.44,38.42 22.44,38.42 20.34,40.53 20.34,42.82 18.91,44.25 16.07,44.25 15.04,45.28 13.37,45.28 11.96,43.87 11.96,40.55 11.14,39.74 11.14,37.15 9.7,35.71 9.7,32.41 9.99,32.12 10.19,32.12 v1(10.42,31.89)
  BOTTOM w0.14: CN17.37 11.4,32 11.29,32.1 10.61,32.1 10.42,31.92 v1(10.42,31.89)
PCIE_RXP15_WLAN: length 213
  TOP w0.14: v1(225.14,43.21) 225.14,43.65 U14.E45
  IN1 w0.086: v1(55.65,42.7) 55.4,42.95 55.02,42.95 54.92,42.85 54.92,41.54 54.15,40.77 54.15,38.63 54.82,37.96 64.39,37.96 64.94,37.41 68.71,37.41 68.88,37.24 70.98,37.24 71.15,37.07 74.43,37.07 75.33,36.18 83.38,36.18 83.47,36.08 85.19,36.08 85.27,36.08 85.43,35.92 88.81,35.92 90.05,34.67 92.32,34.67 92.79,35.14 94.3,35.14 94.73,34.72 95.57,34.72 96.26,35.41 100.14,35.41 101.72,33.83 151.42,33.83 151.46,33.87 174.46,33.87 180.41,39.82 180.41,51.23 181.53,52.35 182.23,52.35 182.74,52.86 182.74,53.13 183.88,54.28 183.88,54.79 184.51,55.42 185.31,55.42 187.29,57.4 188.59,57.4 188.74,57.54 191.59,57.54 192.89,56.24 195.59,56.24 196.04,55.79 200.06,55.79 200.51,56.24 201.38,56.24 202.01,55.6 205.13,55.6 205.89,56.37 209.41,56.37 210.74,55.03 219.3,55.03 220.75,53.58 221.73,53.58 223.03,52.28 223.03,50.63 222.59,50.19 222.59,49.44 225.05,46.98 225.65,46.98 226.96,45.67 226.96,44.04 226.54,43.62 225.1,43.62 225,43.53 225,43.36 v1(225.14,43.21)
  BOTTOM w0.14: v1(55.65,42.7) 55.86,42.9 56.44,42.9 56.59,42.75 CN16.41
PCIE_RXP17_TBT: length 64
  TOP w0.14: v1(260.82,41.99) 260.59,42.22 260.59,42.86 260.73,43 C216.2 ; U14.K44 224.76,41.53 224.76,41.42 v1(225.01,41.16)
  IN4 w0.086: v1(225.01,41.16) 224.76,41.16 224.61,41.31 224.61,41.47 224.75,41.61 225.32,41.61 225.41,41.52 225.41,40.97 225.59,40.79 226.3,40.79 226.48,40.97 226.48,41.91 226.18,42.22 226.18,42.48 226.51,42.81 227.3,42.81 227.59,42.52 227.59,42.39 227.45,42.25 227.15,42.25 226.99,42.09 226.99,41.09 227.18,40.9 228.03,40.9 228.48,41.34 234.39,41.34 234.58,41.52 234.85,41.52 235.03,41.34 235.54,41.34 235.77,41.57 235.77,41.73 236.12,42.09 236.33,42.09 236.98,41.43 236.98,40 237.22,39.77 237.7,39.77 237.96,40.03 237.96,40.53 238.1,40.67 239.55,40.67 240.14,40.09 245.28,40.09 245.68,40.48 245.68,41.19 245.77,41.28 247.59,41.28 247.67,41.19 247.67,40.91 247.85,40.73 248.41,40.73 248.6,40.91 248.6,41.87 248.68,41.96 249.09,41.96 249.19,41.86 249.19,40.78 249.39,40.58 249.94,40.58 250.15,40.79 250.15,41.52 250.23,41.61 250.61,41.61 250.7,41.52 250.7,40.68 250.93,40.46 251.42,40.46 251.94,39.94 252.76,39.94 252.96,40.14 252.96,40.44 253.05,40.52 253.81,40.52 254.09,40.25 254.09,40.12 253.65,39.68 253.65,39.4 254.58,38.48 254.97,38.48 255.16,38.67 255.16,40.9 255.47,41.21 255.86,41.21 256.04,41.4 256.04,41.46 256.13,41.55 256.55,41.55 256.64,41.46 256.64,41.4 256.82,41.21 257.5,41.21 257.84,41.55 258.42,41.55 258.56,41.41 258.56,39.39 258.78,39.17 259.58,39.17 259.83,39.41 259.83,39.75 259.49,40.09 259.49,41.39 259.57,41.48 259.78,41.48 260.03,41.22 260.36,41.22 260.54,41.4 260.54,41.82 260.7,41.99 v1(260.82,41.99)
