# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCIO on TOP (solid shape): 188.72,54.11 188.72,52.44 188.21,51.93 188.21,51.57 188.18,51.49 188.11,51.46 187.72,51.07 188.11,50.68 188.18,50.65 188.21,50.57 188.21,50.41 188.18,50.33 188.1,50.3 187.71,49.91 188.1,49.52 188.18,49.49 188.21,49.41 188.21,48.68 188,48.48 186.64,48.48 186.61,48.49 186.59,48.53 186.59,48.9 186.55,49 186.45,49.04 186.3,49.04 186.26,49.05 186.25,49.09 186.25,49.98 185.64,50.58 185.64,51.28 185.65,51.3 185.66,51.31 185.77,51.59 185.66,51.87 185.65,51.89 185.64,51.9 185.64,52 185.65,52.02 185.74,52.16 185.77,52.31 185.77,52.37 185.75,52.43 185.76,52.5 185.81,52.56 185.98,52.7 186.05,52.9 186.05,52.92 186.15,53.03 186.15,53.72 186.17,53.77 186.17,53.8 186.17,53.96 186.68,54.47 188.36,54.47
+VCCIO on TOP (solid shape): outline of 121 points within 123.29,114.54 126.45,124.4
+VCCIO on BOTTOM (solid shape): 125.75,120.65 125.75,115.14 125.45,114.85 125.24,114.85 125.01,114.61 125.01,114.44 124.93,114.37 124.5,114.37 124.4,114.48 124.4,116.44 124.65,116.69 124.65,119.58 124.71,119.65 124.71,120.74 124.78,120.82 125.58,120.82
+VCCIO on IN3 (solid shape): outline of 988 points within 175.78,51.02 189.05,86.76
+VCCIO on IN4 (solid shape): outline of 8212 points within 119.3,81.45 183.79,124.28
+VCCPGPPA on BOTTOM (solid shape): 218.94,30.95 218.94,30.41 219.2,30.16 219.61,30.16 219.88,30.44 220.24,30.44 220.34,30.34 220.34,30.03 220.19,29.88 220.19,29.36 219.29,28.46 218.47,28.46 218.26,28.67 218.26,29.35 218.41,29.5 218.41,29.98 218.08,30.31 218.08,30.95 218.18,31.05 218.84,31.05
+VCCPLL on BOTTOM (solid shape): 124.38,124.33 125.2,124.33 125.55,123.99 125.55,123.42 125.54,123.39 125.53,123.38 125.45,123.3 125.4,123.21 125.38,123.19 125.35,123.18 124.62,123.18 124.49,123.31 124.49,123.55 124.2,123.84 124.12,123.84 123.99,123.97 123.27,123.97 123.21,124.02 123.21,124.63 123.45,124.87 123.84,124.87
+VCCPLL_OC on BOTTOM (solid shape): 156.38,114.19 156.38,113.32 156.03,112.97 156.03,112.31 155.85,112.13 154.5,112.13 154.37,112.26 154.37,112.56 155.45,113.64 155.45,114.23 155.54,114.32 156.25,114.32
+VCCPLL_OC on BOTTOM (solid shape): outline of 81 points within 122.89,111.7 124.5,113.55
+VCCPRIM_MPHY on BOTTOM (solid shape): 221.61,37.76 221.61,37.18 221.65,37.14 222.04,37.14 222.07,37.11 222.07,37.1 222.17,36.95 222.32,36.85 222.33,36.85 222.38,36.8 222.38,36.48 222.22,36.32 222.2,36.33 222.15,36.34 222.09,36.34 221.82,36.23 221.7,35.96 221.7,35.91 220.82,35.91 220.77,35.95 220.77,35.96 220.77,36.77 220.73,36.87 220.63,36.91 220.52,36.91 220.44,37 219.5,37 219.38,36.88 218.93,36.88 218.78,37.03 218.78,37.37 219.22,37.81 219.58,37.81 219.72,37.95 221.42,37.95
+VCCST on TOP (solid shape): 166.87,119.25 166.87,119.24 166.91,119.18 166.97,119.15 166.98,119.14 167.31,118.81 167.31,118.51 167.15,118.36 165.96,118.36 165.51,118.8 165.51,119.43 165.63,119.55 166.57,119.55
+VCCST on TOP (solid shape): 114.11,131.77 114.11,131.43 113.67,130.99 113.65,130.99 113.49,130.93 113.41,130.78 113.41,130.76 113.38,130.74 112.54,130.74 112.5,130.78 112.5,131.16 112.66,131.32 112.84,131.32 113.49,131.96 113.92,131.96
+VCCST on TOP (solid shape): 107.99,131.57 107.99,130.79 107.75,130.55 107.75,129.79 107.73,129.77 107.73,128.61 107.29,128.17 107.29,127.89 107.01,127.61 107.01,126.13 107.91,125.22 107.91,109.93 106.79,108.8 106.61,108.8 104.22,106.41 104.22,106.23 103.94,105.96 103.94,104.36 104.22,104.08 104.22,104.01 104.3,103.84 104.46,103.77 104.54,103.77 104.91,103.4 104.91,103.01 104.72,102.82 104.45,102.82 103.78,103.5 103.7,103.5 103.67,103.52 103.62,103.54 103,104.17 103,106 106.51,109.51 106.51,124.57 105.94,125.14 105.94,127.9 106.76,128.72 106.92,128.72 107.02,128.76 107.06,128.86 107.06,129.57 107.05,129.61 107.03,129.65 107.02,129.67 107.02,131.34 107.43,131.74 107.82,131.74
+VCCST on BOTTOM (solid shape): 182.27,173.46 182.27,172.68 182.2,172.68 181.82,172.68 181.81,172.68 181.77,172.69 181.75,172.72 181.62,172.97 181.37,173.07 181.35,173.07 181.15,173.27 181.15,173.74 181.22,173.81 181.92,173.81
+VCCSTG on BOTTOM (solid shape): 123.71,127.29 123.72,127.26 123.71,127.2 123.7,127.16 123.71,127.08 123.74,126.99 123.74,126.83 124.09,126.48 124.09,126.09 124.5,125.69 124.5,125.65 124.52,125.55 124.59,125.45 124.59,125.43 124.59,124.91 124.59,124.88 124.6,124.84 124.6,124.76 124.47,124.64 124.31,124.64 124.15,124.8 124.15,125.33 123.68,125.8 123.67,125.83 123.67,125.86 123.72,125.99 123.74,126.13 123.7,126.35 123.57,126.54 123.08,127.04 123.08,127.31 123.2,127.44 123.22,127.44 123.26,127.44 123.35,127.45 123.44,127.49 123.45,127.5 123.5,127.5
+VDD12 on TOP (solid shape): 61.11,30.04 61.11,29.66 60.77,29.33 59.85,29.33 59.74,29.44 59.74,29.78 60.29,30.33 60.82,30.33
+VDD12 on TOP (solid shape): 56.31,22.27 56.31,21.96 56.11,21.76 55.44,21.76 55.34,21.66 55.13,21.66 55,21.53 54.88,21.53 54.77,21.64 54.77,21.85 55.24,22.32 56.26,22.32
+VDD12 on TOP (solid shape): 60.83,22.17 61.19,22.17 61.34,22.02 61.76,22.02 61.99,21.78 61.99,21.45 61.84,21.3 61.39,21.3 61.11,21.58 60.75,21.58 60.74,21.59 60.14,21.59 59.79,21.94 59.79,22.24 59.86,22.32 60.68,22.32
+VDD12 on TOP (solid shape): 54.94,25.94 55.54,25.94 55.56,25.92 56.29,25.92 56.32,25.89 56.32,25.76 56.29,25.73 55.55,25.73 55.46,25.63 54.81,25.63 54.73,25.55 54.39,25.55 54.33,25.61 54.33,25.92 54.48,26.08 54.8,26.08
+VDD12 on TOP (solid shape): 55.61,28.32 56.29,28.32 56.34,28.27 56.34,28.17 56.32,28.14 56.29,28.12 55.61,28.12 55.61,27.92 56.29,27.92 56.32,27.91 56.34,27.87 56.34,27.77 56.32,27.74 56.29,27.72 55.61,27.72 55.61,27.52 56.29,27.52 56.32,27.51 56.34,27.47 56.34,27.36 56.3,27.32 55.61,27.32 55.59,27.31 55.34,27.31 54.97,27.67 54.97,28.25 55.07,28.34 55.59,28.34
+VDD12 on TOP (solid shape): 55.61,24.72 56.28,24.72 56.36,24.64 56.36,24.57 56.35,24.54 56.31,24.52 55.61,24.52 55.61,24.32 56.31,24.32 56.35,24.31 56.36,24.27 56.36,24.17 56.35,24.14 56.31,24.12 55.61,24.12 55.61,23.92 56.31,23.92 56.35,23.91 56.36,23.87 56.36,23.8 56.29,23.72 55.61,23.72 55.58,23.7 55.5,23.7 55.42,23.61 54.85,23.61 54.63,23.83 54.63,24.21 55.16,24.74 55.61,24.74
+VDD12 on BOTTOM (solid shape): outline of 196 points within 54.3,20.59 61.97,30.39
+VDD33 on TOP (solid shape): 56.32,30.5 56.32,29.65 56.32,29.62 56.31,29.6 56.31,29.37 56.26,29.33 55.6,29.33 55.51,29.41 55.51,29.68 54.95,30.24 53.66,30.24 53.49,30.42 53.49,31.03 53.63,31.17 53.63,31.28 53.71,31.37 55.45,31.37
+VDD33 on TOP (solid shape): 58.67,15.31 59.51,15.31 59.53,15.28 59.53,15.03 59.51,15 58.74,15 58.31,14.57 57.73,14.57 57.55,14.75 57.55,14.95 57.65,15.05 57.77,15.05 57.8,15.09 57.82,15.09 58.08,15.36 58.62,15.36
+VDD33 on TOP (solid shape): 58.9,35.25 59.92,35.25 60.01,35.16 60.02,35.12 60.08,34.9 60.25,34.76 60.26,34.76 60.29,34.72 60.29,34.54 60.17,34.42 58.57,34.42 58.22,34.76 58.21,34.76 58.01,34.97 56.71,34.97 56.35,34.61 56.35,34.38 56.2,34.23 55.92,34.23 55.79,34.36 55.79,34.61 55.79,34.63 55.9,34.78 55.94,34.94 55.93,35 55.92,35.05 55.92,35.08 55.93,35.1 56.48,35.65 58.49,35.65
+VDD33 on TOP (solid shape): outline of 285 points within 56.48,15 62.1,22.18
+VDD_DCI on BOTTOM (solid shape): 272.67,13.09 272.67,12.84 272.69,12.82 272.69,12.79 272.94,12.54 273.12,12.54 273.33,12.54 273.5,12.37 273.5,11.93 273.17,11.6 271.68,11.6 271.53,11.75 271.53,11.92 272.08,12.48 272.21,12.48 272.21,13.08 272.26,13.12 272.64,13.12
+VDDIO on BOTTOM (solid shape): 62.3,29.86 62.3,29.38 62.78,28.89 62.78,28.55 62.66,28.42 62.66,27.88 62.38,27.61 61.77,27.61 61.54,27.37 60.98,27.37 60.85,27.5 60.85,27.87 61.2,28.22 61.72,28.22 62.07,28.57 62.07,28.97 61.87,29.18 61.35,29.18 61.23,29.29 61.23,30 61.25,30.01 62.15,30.01
+VDDQ on TOP (solid shape): 160.8,26.76 160.8,25.72 160.62,25.54 160.09,25.54 159.94,25.7 159.94,26.61 160.17,26.84 160.72,26.84
+VIN on TOP (solid shape): 152.42,173.47 152.42,168.32 151.66,167.56 147.28,167.56 146.7,168.14 146.7,173.73 147.19,174.21 151.68,174.21
+VIN on TOP (solid shape): 115.39,151.32 115.39,144.8 115.28,144.69 109.99,144.69 109.26,145.42 109.26,147.87 109.59,148.2 112.46,148.2 113.23,148.96 113.23,149.88 113.35,150 114.12,150 114.22,150.11 114.22,151.45 114.39,151.63 115.08,151.63
+VIN on TOP (solid shape): 130.81,164.42 131.19,164.42 131.64,163.97 131.64,163.26 131.84,163.06 133.09,163.06 133.19,162.96 133.19,162.07 133.01,161.89 127.93,161.89 127.68,162.14 127.68,164.44 128.03,164.8 130.44,164.8
+VIN on TOP (solid shape): 159.68,164.84 162.05,164.84 162.83,164.05 162.83,163.26 162.96,163.14 164.15,163.14 164.41,162.88 164.41,162.14 164.13,161.87 159.05,161.87 158.64,162.27 158.64,164.81 158.97,165.14 159.38,165.14
+VIN on TOP (solid shape): 142.09,164.09 142.09,163.28 142.16,163.21 143.38,163.21 143.63,162.96 143.63,162.12 143.5,161.99 138.37,161.99 138.21,162.16 138.21,162.54 138.19,162.55 138.19,164.58 138.3,164.68 141.5,164.68
+VIN on TOP (solid shape): 33.5,52.44 33.5,49.68 33.47,49.61 33.47,49.54 33.47,49.47 33.5,49.39 33.5,48.58 33.17,48.25 29.89,48.25 29.85,48.27 29.84,48.3 29.84,52.8 30.02,52.98 32.96,52.98
+VIN on TOP (solid shape): 75.01,44.19 77.84,44.19 78.81,43.22 82.16,43.22 82.36,43.02 82.36,42.36 81.93,41.94 81.93,40.94 81.55,40.55 76.42,40.55 75.94,40.07 75.2,40.07 75.1,40.17 75.1,40.82 74.78,41.14 74.78,42.64 74.35,43.08 74.35,43.36 74.12,43.59 74.12,44.21 74.37,44.46 74.73,44.46
+VIN on TOP (solid shape): 148.81,164.94 150.11,164.94 150.79,164.25 151.78,164.25 152.06,163.97 152.06,163.24 152.16,163.14 153.43,163.14 153.64,162.93 153.64,162.27 153.31,161.94 148.47,161.94 148.38,161.98 148.37,162.07 148.35,162.36 148.13,162.56 148.11,162.58 148.1,162.61 148.1,164.3 147.97,164.43 147.97,165.27 148.1,165.4 148.35,165.4
+VIN on TOP (solid shape): 63,44.77 63,44.15 63.37,43.78 69.72,43.78 69.94,43.55 69.94,42.43 69.79,42.28 69.79,41.53 69.61,41.35 68.57,41.35 67.99,40.77 67.99,38.95 67.75,38.71 66.71,38.71 66.6,38.6 63.54,38.6 63.37,38.78 63.37,41.03 63.11,41.29 59.71,41.29 59.54,41.12 59.11,41.12 59.02,41.21 59.02,43.62 59.04,43.65 59.06,43.65 59.31,43.83 59.36,44.12 59.36,44.15 59.37,44.17 59.48,44.28 60.88,44.28 61.17,44.58 61.17,45.22 61.37,45.42 62.34,45.42
+VIN on TOP (solid shape): 158.96,20.65 159.63,20.65 159.73,20.55 159.73,18.83 159.98,18.58 161.68,18.58 162.51,17.76 162.51,17.37 162.83,17.04 164.1,17.04 164.17,16.98 164.17,16.1 164.49,15.78 165.27,15.78 165.6,15.45 165.6,15.15 165.55,15.09 161.12,15.09 161.12,15.1 160.9,15.1 160.86,15.13 160.86,15.51 160.52,15.85 158.78,15.85 158.21,15.28 158.21,14.62 158.4,14.43 158.57,14.43 159.23,13.77 159.23,11.3 159.12,11.2 158.72,11.2 158.56,11.36 158.56,12.81 158.45,12.92 157,12.92 157,12.92 156.13,12.92 156.12,12.92 155.7,12.92 155.4,12.63 155.4,9.49 155.22,9.3 154.28,9.3 154.02,9.56 154.02,10.39 153.62,10.8 149.91,10.8 149.7,11.01 149.7,11.95 149.3,12.35 148.5,12.35 148.42,12.43 148.42,12.72 148.49,12.79 153.6,12.79 153.97,13.16 153.97,14.01 154.9,14.94 154.9,18.13 156.49,19.72 156.49,20.36 156.49,20.38 156.5,20.4 156.83,20.72 158.89,20.72
+VIN on TOP (solid shape): 114.88,166.03 114.88,164.15 114.62,163.9 111.04,163.9 110.74,163.59 110.74,161.81 110.64,161.71 106.29,161.71 106.22,161.79 103.93,161.79 103.85,161.71 103.85,161.18 104.21,160.82 104.21,159.96 104.17,159.89 104.09,159.86 104.03,159.87 103.63,159.47 104.03,159.08 104.09,159.09 104.17,159.06 104.21,158.98 104.21,157.34 104.06,157.19 103.5,157.19 103.18,156.87 103.18,156.06 101.69,154.58 101.47,154.58 101.46,154.58 101.46,159.74 101.19,160.01 100.42,160.01 100.04,160.39 100.04,161.77 99.66,162.15 99.66,165.57 99.79,165.7 106.22,165.7 106.75,166.23 114.67,166.23
+VIN on TOP (solid shape): outline of 121 points within 109.5,13.98 129.58,27.58
+VIN on BOTTOM (solid shape): 130.17,164.35 130.17,162.12 129.99,161.94 127.93,161.94 127.58,162.3 127.58,164.23 127.98,164.63 129.89,164.63
+VIN on BOTTOM (solid shape): 115.77,150.97 115.77,146.47 115.14,145.84 109.67,145.84 109.46,146.05 109.46,147.85 112.94,151.32 115.41,151.32
+VIN on BOTTOM (solid shape): 159.91,164.74 161.06,164.74 161.46,164.33 163.85,164.33 164.2,163.97 164.2,161.94 164.05,161.79 159.25,161.79 158.84,162.2 158.84,164.96 159.02,165.14 159.51,165.14
+VIN on BOTTOM (solid shape): 138.76,164.68 142.88,164.68 143.6,163.95 143.6,162.55 143.27,162.22 139.29,162.22 139.01,161.94 138.32,161.94 137.89,162.37 137.89,164.53 138.17,164.81 138.63,164.81
+VIN on BOTTOM (solid shape): 102.79,166.13 103.56,165.95 104.35,165.88 105.14,165.95 105.91,166.13 114.58,166.13 114.97,165.74 114.97,161.93 114.29,161.25 104.39,161.25 103.75,160.62 102.3,160.62 101.99,160.93 101.99,161.86 100.95,162.9 100.95,165.52 101.1,165.68 101.12,165.68 101.57,166.13
+VIN on BOTTOM (solid shape): 149.2,164.63 152.78,164.63 153.38,164.02 153.38,162.32 152.95,161.89 148.48,161.89 148.36,162.01 148.36,162.04 148.38,162.12 148.39,162.19 148.28,162.46 147.99,162.6 147.97,162.64 147.97,165.42 148.08,165.52 148.3,165.52
+VIN on BOTTOM (solid shape): outline of 538 points within 109.04,11.95 159.58,26.18
+VIN on IN1 (solid shape): outline of 271 points within 100.26,145.33 111.39,165.65
+VIN on IN2 (solid shape): outline of 102 points within 147.01,161.79 153.49,171.68
+VIN on SVCC (solid shape): outline of 992 points within 29.48,41.32 114.83,165.9
+VIN on SVCC1 (solid shape): outline of 1319 points within 58.95,20.49 164.36,170.73
+VIN on IN3 (solid shape): outline of 910 points within 137.18,161.52 164.91,172.28
+VIN_GPU_TOTAL on TOP (solid shape): 29.48,52.75 29.48,48.45 29.28,48.25 28.54,48.25 28.51,48.27 28.51,48.28 28.36,48.47 28.14,48.54 27.92,48.48 27.77,48.3 27.77,48.28 27.72,48.25 27.43,48.25 27.1,48.58 25.85,48.58 25.82,48.61 25.04,48.61 24.94,48.71 24.94,52.85 25.04,52.95 29.28,52.95
+VIN_GPU_TOTAL on TOP (solid shape): outline of 150 points within 6.75,159.27 22.35,173.14
+VIN_GPU_TOTAL on BOTTOM (solid shape): 24.09,173.78 24.09,172.5 23.98,172.39 22.4,172.39 22.12,172.1 22.12,164.94 21.86,164.68 21.35,164.68 21.1,164.94 21.1,173.78 21.23,173.9 23.97,173.9
+VIN_GPU_TOTAL on BOTTOM (solid shape): 10.43,162.73 12.82,162.73 13.18,162.37 14.4,162.37 15.59,161.18 15.59,160.29 15.33,160.04 9.72,160.04 9.49,160.27 7.18,160.27 7,160.44 7,161.87 12.12,161.87 12.12,161.81 12.14,161.75 12.16,161.7 12.18,161.64 12.22,161.59 12.26,161.55 12.3,161.51 12.35,161.48 12.41,161.45 12.46,161.44 12.52,161.43 12.58,161.43 12.64,161.43 12.7,161.45 12.75,161.47 12.81,161.5 12.85,161.53 12.9,161.57 12.93,161.62 12.96,161.67 12.99,161.72 13,161.78 13.01,161.84 13.01,161.9 13,161.96 12.99,162.02 12.96,162.07 12.93,162.12 12.9,162.17 12.85,162.21 12.81,162.25 12.75,162.28 12.7,162.3 12.64,162.31 12.58,162.32 12.52,162.31 12.46,162.3 12.41,162.29 12.35,162.26 12.3,162.23 12.26,162.19 12.22,162.15 12.18,162.1 12.16,162.04 12.14,161.99 12.12,161.93 12.12,161.87 7,161.87 7,163.62 7.13,163.74 9.42,163.74
+VIN_GPU_TOTAL on SVCC (solid shape): outline of 583 points within 6.19,47.79 28.47,175.67
+VIN_GPU_TOTAL on SVCC1 (solid shape): outline of 431 points within 6.53,60.62 22.37,175.67
+VIN_PANEL_R on BOTTOM (solid shape): 174.64,138.98 174.64,135.17 174.39,134.92 174.39,134.91 174.08,134.6 174.08,133.06 175.04,132.11 175.32,132.11 175.48,131.94 175.48,131.21 175.38,131.11 174.08,131.11 172.41,132.78 172.41,135.17 173.04,135.8 173.04,137.31 173.33,137.6 173.33,139.16 173.48,139.31 174.31,139.31
+VIN_VGACORE on TOP (solid shape): 24.78,52.77 24.78,50.42 24.78,50.39 24.78,48.19 24.73,48.11 24.69,48.02 24.69,48 24.48,47.79 22.32,47.79 22.3,47.8 22.28,47.81 21.89,48.2 21.89,52.06 22.75,52.92 24.63,52.92
+VIN_VGACORE on TOP (solid shape): 34.82,58.97 37.61,58.97 37.69,58.89 37.69,56.96 37.53,56.81 36.16,56.81 36.11,56.76 36.11,55.97 35.82,55.67 35.59,55.67 35.26,55.34 33.24,55.34 33.01,55.57 33.01,57.42 33.09,57.5 34.03,57.5 34.16,57.62 34.16,59.02 34.28,59.15 34.64,59.15
+VIN_VGACORE on TOP (solid shape): 25.16,58.97 27.96,58.97 28.03,58.89 28.03,56.96 27.88,56.81 26.51,56.81 26.46,56.76 26.46,55.82 25.55,54.91 24.05,54.91 23.82,55.13 23.82,55.34 23.36,55.79 23.36,57.42 23.44,57.5 24.38,57.5 24.5,57.62 24.5,59.02 24.63,59.15 24.99,59.15
+VIN_VGACORE on TOP (solid shape): 44.47,58.97 47.26,58.97 47.34,58.89 47.34,56.96 47.19,56.81 45.81,56.81 45.76,56.76 45.76,55.82 45.56,55.62 45.56,55.29 45.21,54.93 44.57,54.93 44.16,55.34 42.89,55.34 42.67,55.57 42.67,57.42 42.74,57.5 43.68,57.5 43.81,57.62 43.81,59.02 43.94,59.15 44.29,59.15
+VIN_VGACORE on TOP (solid shape): 54.12,58.97 56.91,58.97 56.99,58.89 56.99,56.96 56.84,56.81 55.47,56.81 55.42,56.76 55.42,55.82 55.21,55.62 55.21,55.29 54.86,54.93 54.22,54.93 53.82,55.34 52.95,55.34 52.32,55.97 52.32,57.42 52.39,57.5 53.33,57.5 53.46,57.62 53.46,59.02 53.59,59.15 53.94,59.15
+VIN_VGACORE on TOP (solid shape): 63.77,58.97 66.57,58.97 66.64,58.89 66.64,56.96 66.49,56.81 65.12,56.81 65.07,56.76 65.07,55.82 64.86,55.62 64.86,55.29 64.51,54.93 63.87,54.93 63.47,55.34 62.2,55.34 61.97,55.57 61.97,57.42 62.05,57.5 62.99,57.5 63.11,57.62 63.11,59.02 63.24,59.15 63.59,59.15
+VIN_VGACORE on TOP (solid shape): 73.42,58.97 76.22,58.97 76.29,58.89 76.29,56.96 76.14,56.81 74.77,56.81 74.72,56.76 74.72,55.82 74.52,55.62 74.52,55.29 74.16,54.93 73.53,54.93 73.12,55.34 71.85,55.34 71.62,55.57 71.62,57.42 71.7,57.5 72.64,57.5 72.76,57.62 72.76,59.02 72.89,59.15 73.25,59.15
+VIN_VGACORE on TOP (solid shape): 83.08,58.97 85.87,58.97 85.95,58.89 85.95,56.96 85.79,56.81 84.42,56.81 84.37,56.76 84.37,55.82 84.17,55.62 84.17,55.29 83.81,54.93 83.18,54.93 82.77,55.34 81.5,55.34 81.27,55.57 81.27,57.42 81.35,57.5 82.29,57.5 82.42,57.62 82.42,59.02 82.54,59.15 82.9,59.15
+VIN_VGACORE on TOP (solid shape): 15.73,61.38 15.73,59.29 16.05,58.97 18.31,58.97 18.38,58.89 18.38,56.96 18.23,56.81 16.86,56.81 16.81,56.76 16.81,55.97 16.7,55.87 16.42,55.87 15.84,55.29 12.34,55.29 12.08,55.54 12.08,58.29 12.3,58.51 12.82,58.51 13.13,58.82 13.13,61.09 13.22,61.19 13.68,61.19 14.02,60.85 14.55,60.85 14.58,60.88 14.67,60.88 14.79,61 14.79,61.64 14.92,61.76 15.35,61.76
+VIN_VGACORE on TOP (solid shape): 58.79,53.1 59.11,53.1 59.14,53.09 59.3,52.87 59.53,52.79 59.7,52.83 59.84,52.94 59.91,52.98 59.99,52.95 60.36,52.58 60.36,51.29 60.28,51.21 60.26,51.2 60.24,51.2 60.19,51.21 60.15,51.21 60.08,51.2 60.01,51.18 59.94,51.18 59.88,51.23 59.74,51.38 59.54,51.43 59.26,51.32 59.13,51.01 59.09,50.99 58.95,50.99 58.24,50.28 57.6,50.28 57.17,50.71 57.17,53.23 57.58,53.64 58.26,53.64
+VIN_VGACORE on BOTTOM (solid shape): 85.95,58.89 85.95,57.62 85.67,57.34 84.73,57.34 83.42,56.04 83.42,55.66 83.41,55.64 83.41,55.08 83.25,54.93 81.6,54.93 81.27,55.26 81.27,56.99 80.94,57.32 80.94,58.31 81.23,58.59 83.13,58.59 83.51,58.97 85.87,58.97
+VIN_VGACORE on BOTTOM (solid shape): 28.03,58.89 28.03,56.96 27.88,56.81 26.51,56.81 26.46,56.76 26.46,55.82 26.26,55.62 26.26,55.49 26.09,55.33 24.87,55.33 24.86,55.34 23.59,55.34 23.36,55.57 23.36,56.73 24.25,57.62 24.25,58.79 24.43,58.97 27.96,58.97
+VIN_VGACORE on BOTTOM (solid shape): 54.12,58.97 56.91,58.97 56.99,58.89 56.99,56.96 56.84,56.81 55.47,56.81 55.42,56.76 55.42,55.82 55.21,55.62 55.21,55.29 54.86,54.93 54.22,54.93 53.82,55.34 52.95,55.34 52.32,55.97 52.32,58.71 52.59,58.98 54.11,58.98
+VIN_VGACORE on BOTTOM (solid shape): 66.64,58.89 66.64,56.96 66.49,56.81 65.12,56.81 65.07,56.76 65.07,55.82 64.86,55.62 64.86,55.29 64.51,54.93 63.87,54.93 63.47,55.34 62.2,55.34 61.97,55.57 61.97,58.51 62.23,58.77 64.05,58.77 64.25,58.97 66.57,58.97
+VIN_VGACORE on BOTTOM (solid shape): 76.29,58.89 76.29,56.96 76.14,56.81 74.77,56.81 74.72,56.76 74.72,56.24 74.18,55.7 74.18,55.14 73.97,54.93 73.53,54.93 73.12,55.34 71.85,55.34 71.62,55.57 71.62,58.12 72.22,58.72 73.75,58.72 74,58.97 76.22,58.97
+VIN_VGACORE on BOTTOM (solid shape): 32.63,60.62 32.63,59.29 32.94,58.98 33.3,58.98 33.46,59.15 34.64,59.15 34.82,58.97 37.61,58.97 37.69,58.89 37.69,56.96 37.53,56.81 36.16,56.81 36.11,56.76 36.11,55.82 35.91,55.62 35.91,55.29 35.55,54.93 34.92,54.93 34.51,55.34 33.24,55.34 33.01,55.57 33.01,56.83 32.24,57.6 32.24,58.62 31.64,59.21 31.38,59.21 31.16,59.44 31.16,60.61 31.24,60.7 32.56,60.7
+VIN_VGACORE on BOTTOM (solid shape): 42.28,60.52 42.28,59.19 42.53,58.95 43.54,58.95 43.75,59.15 44.29,59.15 44.47,58.97 47.26,58.97 47.34,58.89 47.34,56.96 47.19,56.81 45.81,56.81 45.76,56.76 45.76,55.82 45.56,55.62 45.56,55.29 45.21,54.93 44.57,54.93 44.16,55.34 42.89,55.34 42.67,55.57 42.67,57.82 41.41,59.08 40.95,59.08 40.82,59.22 40.82,60.53 40.87,60.59 42.21,60.59
+VIN_VGACORE on SVCC1 (solid shape): outline of 308 points within 11.7,47.79 90.7,69.64
+VIN_VGACORE on IN3 (solid shape): outline of 1904 points within 23.03,55.41 85.85,59.71
AVDD09 on TOP (solid shape): 264.84,31.84 264.84,31.82 264.95,31.58 265.19,31.49 265.32,31.51 265.43,31.58 265.45,31.59 265.53,31.59 265.55,31.58 265.7,31.43 265.88,31.39 265.96,31.39 265.98,31.39 266.41,30.95 267.56,30.95 267.73,30.78 267.73,29.86 267.63,29.76 264.41,29.76 264.28,29.89 264.28,30.34 263.95,30.67 263.95,31.39 263.72,31.61 263.72,31.82 263.74,31.86 263.77,31.87 264.8,31.87
AVDD09 on IN1 (solid shape): 266.18,31.12 266.18,30.55 266.11,30.48 264.79,30.48 264.53,30.22 263.95,30.22 263.94,30.23 263.86,30.26 263.77,30.27 263.69,30.26 263.6,30.23 263.59,30.22 263.11,30.22 262.82,29.93 262.75,29.9 262.67,29.94 262.55,30.03 262.4,30.07 262.15,29.96 262.04,29.71 262.05,29.63 262.08,29.55 262.08,29.5 262.04,29.48 262.02,29.47 261.71,29.47 261.69,29.48 261.67,29.49 261.63,29.53 261.58,29.57 261.45,29.7 261.45,30.6 262.02,31.18 263.87,31.18 264.04,31.34 265.96,31.34
GND on TOP (solid shape): 30.75,158.15 30.75,157.62 30.68,157.55 23.15,157.55 23.15,158.85 30.05,158.85
GND on TOP (solid shape): 45.36,35.6 45.36,33.57 45.1,33.32 42.94,33.32 42.82,33.44 42.82,35.73 45.23,35.73
GND on TOP (solid shape): 12.49,46.37 12.49,45.74 12.29,45.53 10.61,45.53 10.38,45.76 10.38,46.19 10.64,46.45 12.41,46.45
GND on TOP (solid shape): 14.55,169.92 14.55,168.42 14.45,168.32 12.92,168.32 12.9,168.34 12.9,169.94 12.92,169.97 14.5,169.97
GND on TOP (solid shape): 19.2,50.46 19.2,48.81 19.14,48.76 17.49,48.76 17.42,48.84 17.42,50.46 17.47,50.51 19.14,50.51
GND on TOP (solid shape): 33.36,31.98 33.36,27.53 33.22,27.39 28.79,27.39 28.58,27.6 28.58,32.02 28.73,32.17 33.17,32.17
GND on TOP (solid shape): 46.5,21.38 46.5,20.26 46.37,20.13 43.88,20.13 43.73,20.29 43.73,21.45 43.86,21.58 46.3,21.58
GND on TOP (solid shape): 64.36,54.62 64.36,54.21 64.16,54.01 62.64,54.01 62.58,54.08 62.58,54.72 62.64,54.78 64.2,54.78
GND on TOP (solid shape): 87.17,86.53 87.17,83.61 86.73,83.18 63.7,83.18 62.96,83.91 62.96,86.42 63.46,86.92 86.78,86.92
GND on TOP (solid shape): 110.79,46.78 110.79,46.55 110.72,46.48 108.32,46.48 108.17,46.63 108.17,47.34 108.34,47.52 110.05,47.52
GND on TOP (solid shape): 145.56,174.39 145.56,170.35 145.05,169.84 141.98,169.84 141.6,170.22 141.6,174.26 142.18,174.84 145.1,174.84
GND on TOP (solid shape): 150.46,166.77 150.46,165.37 150.23,165.14 149.35,165.14 149.14,165.35 149.14,166.82 149.27,166.95 150.29,166.95
GND on TOP (solid shape): 161.11,166.56 161.11,165.24 161,165.14 159.76,165.14 159.66,165.24 159.66,166.62 159.73,166.69 160.98,166.69
GND on TOP (solid shape): 165.3,118.53 165.3,116.85 164.59,116.15 164.2,116.15 164.03,116.32 164.03,118.71 164.15,118.84 164.99,118.84
GND on TOP (solid shape): 168.75,141.44 168.75,138.75 166.87,136.87 160.47,136.87 158.62,138.73 158.62,143.32 159.02,143.73 166.46,143.73
GND on TOP (solid shape): 177.67,134.91 177.67,134.38 177.58,134.29 174.77,134.29 174.69,134.38 174.69,134.84 174.82,134.98 177.59,134.98
GND on TOP (solid shape): 194.37,51.57 194.37,48.87 194.25,48.76 193.62,48.76 193.44,48.94 193.44,51.38 193.67,51.6 194.33,51.6
GND on TOP (solid shape): 244.62,49.72 244.62,45.1 244.54,45.03 241.9,45.03 241.83,45.1 241.83,49.75 241.9,49.83 244.52,49.83
GND on TOP (solid shape): 252.14,23 252.14,20.31 252.04,20.21 249.35,20.21 249.27,20.29 249.27,22.93 249.4,23.05 252.09,23.05
GND on TOP (solid shape): 265.55,20.84 265.55,16.78 265.5,16.73 261.56,16.73 261.41,16.88 261.41,20.77 261.54,20.9 265.5,20.9
GND on TOP (solid shape): 277.52,35.35 277.52,31.64 277.39,31.51 273.6,31.51 273.5,31.6 273.5,35.35 273.7,35.55 277.32,35.55
GND on TOP (solid shape): 24.87,19.35 24.87,18.48 24.39,18 23.93,18 23.81,17.87 22.16,17.87 21.95,18.08 21.95,19.47 22.08,19.6 24.62,19.6
GND on TOP (solid shape): 29.31,16.83 29.31,14.97 29.22,14.89 28.81,14.89 28.18,15.51 28.18,16.64 28.54,17 29.14,17
GND on TOP (solid shape): 35.66,14.91 35.66,14.23 35.56,14.13 30.36,14.13 30.27,14.22 30.27,14.85 30.37,14.95 34.52,14.95 34.59,15.03 35.54,15.03
GND on TOP (solid shape): 91.51,94.58 92.88,94.58 93.01,94.45 93.01,94.02 92.86,93.87 89.66,93.87 89.38,94.15 89.38,94.71 89.6,94.94 91.15,94.94
GND on TOP (solid shape): 140.56,166.54 140.56,165.07 140.43,164.94 138.75,164.94 138.55,165.14 138.55,165.78 139.49,166.72 140.38,166.72
GND on TOP (solid shape): 174.72,160.27 174.72,159.5 174.06,158.84 173.3,158.84 173.15,159 173.15,159.53 172.66,160.01 172.66,160.37 172.71,160.42 174.57,160.42
GND on TOP (solid shape): 177.42,13.34 177.42,9.4 177.3,9.29 173.41,9.29 173.07,9.62 173.07,13.3 173.29,13.52 177.24,13.52
GND on TOP (solid shape): 285.59,19.93 285.59,16.45 285.29,16.15 284.22,16.15 284.12,16.25 284.12,16.88 284.24,17.01 284.24,19.88 284.42,20.06 285.46,20.06
GND on TOP (solid shape): 41.95,47.36 41.95,43.96 41.88,43.88 38.4,43.88 38.35,43.93 38.35,47.39 38.42,47.46 41.85,47.46
GND on TOP (solid shape): 89.27,162.12 89.78,162.12 90.11,161.79 90.11,161.36 90.04,161.28 89.73,161.28 89.66,161.36 88.69,161.36 88.69,162.09 88.79,162.2 89.2,162.2
GND on TOP (solid shape): 106.98,94.82 106.98,94.57 106.32,93.91 102.19,93.91 102.07,94.03 102.07,94.45 102.3,94.68 106.31,94.68 106.62,94.99 106.82,94.99
GND on TOP (solid shape): 12.21,42.16 12.21,39.77 12.06,39.62 11.47,39.62 11.15,39.94 11.15,40.86 11.22,40.93 11.22,42.15 11.37,42.31 12.06,42.31
GND on TOP (solid shape): 16.43,18.11 16.71,18.11 16.77,18.05 16.77,17.48 16.15,16.86 16.15,14.55 16.05,14.44 15.54,14.44 15.41,14.57 15.41,17.95 15.72,18.26 16.04,18.26
GND on TOP (solid shape): 24.07,172.99 24.07,172.38 24.38,172.08 24.99,172.08 25.11,171.95 25.11,168.67 25.01,168.57 22.7,168.57 22.57,168.7 22.57,173.04 22.68,173.14 23.92,173.14
GND on TOP (solid shape): 24.07,167.55 24.07,166.69 24.22,166.54 25.04,166.54 25.16,166.41 25.16,163.21 25.01,163.06 22.65,163.06 22.5,163.21 22.5,167.53 22.65,167.68 23.95,167.68
GND on TOP (solid shape): 41.29,173.98 41.29,168.95 40.96,168.62 37.46,168.62 37.26,168.82 37.26,172.01 38.12,172.86 38.12,173.63 38.22,173.73 38.78,173.73 39.44,174.39 40.89,174.39
GND on TOP (solid shape): 44.67,27.18 44.67,24.73 44.58,24.63 43.03,24.63 42.97,24.7 42.97,27.25 43,27.28 44.57,27.28
GND on TOP (solid shape): 144.39,143.42 144.39,142.82 144.54,142.66 145.08,142.66 145.38,142.36 145.38,139.69 145.15,139.46 143.5,139.46 143.05,139.92 143.05,143.42 143.27,143.65 144.16,143.65
GND on TOP (solid shape): 152.88,143.35 152.88,140.15 152.67,139.95 150.67,139.95 150.01,140.61 150.01,142.82 150.18,142.99 150.74,142.99 151.25,143.5 152.72,143.5
GND on TOP (solid shape): 174.52,23.28 174.52,22.06 174.5,22.03 174.47,22.01 172.23,22.01 172.1,22.14 172.1,23.28 172.23,23.41 174.39,23.41
GND on TOP (solid shape): 192.04,25.82 192.04,22.72 191.89,22.57 190.48,22.57 190.45,22.59 190.43,22.62 190.43,26.09 190.65,26.31 191.56,26.31
GND on TOP (solid shape): 21.38,61.26 21.38,60.11 21.28,60.01 19.65,60.01 19.63,59.99 19.63,59.48 19.45,59.3 15.99,59.3 15.97,59.32 15.97,61.28 16.05,61.36 21.28,61.36
GND on TOP (solid shape): 92.4,162.17 92.4,161.74 92.5,161.64 92.5,161.36 91.66,161.36 91.61,161.31 90.98,161.31 90.95,161.33 90.95,161.99 91.05,162.09 91.89,162.09 91.99,162.2 92.37,162.2
GND on TOP (solid shape): 94.74,162.04 94.74,161.36 94.71,161.33 93.31,161.33 93.29,161.36 93.29,161.54 93.39,161.64 93.39,162.2 93.49,162.3 94.48,162.3
GND on TOP (solid shape): 127.04,147.18 127.04,144.39 126.69,144.03 126.69,143.02 126.59,142.92 126.28,142.92 126.05,143.15 126.05,143.45 125.27,144.24 125.27,147.39 125.42,147.54 126.69,147.54
GND on TOP (solid shape): 11.68,75.35 11.68,72.97 11.86,72.78 12.9,72.78 12.91,72.77 12.91,72.6 12.9,72.58 11.88,72.58 11.8,72.66 9.04,72.66 8.93,72.76 8.93,75.35 9.06,75.48 11.55,75.48
GND on TOP (solid shape): 51.58,14.67 52.42,14.67 52.65,14.44 52.65,14.09 52.63,14.05 52.6,14.04 49.7,14.04 49.24,14.49 49.24,15.41 49.4,15.56 50.69,15.56
GND on TOP (solid shape): 53.22,107.95 53.22,107.72 52.8,107.31 52.62,107.31 52.19,107.74 52.19,107.94 52.19,107.96 52.21,107.98 52.23,108 52.25,108.03 52.62,108.4 52.77,108.4
GND on TOP (solid shape): 54.53,103.9 54.56,103.85 54.59,103.82 54.6,103.8 54.6,103.78 54.6,103.53 54.2,103.13 54.06,103.13 53.61,103.57 53.61,103.78 54.02,104.18 54.25,104.18
GND on TOP (solid shape): 62.77,53.16 66.54,53.16 66.76,53.38 71.65,53.38 72.42,52.61 72.42,51.83 72.37,51.78 61.74,51.78 61.41,52.11 61.41,53.1 61.69,53.38 62.54,53.38
GND on TOP (solid shape): 98.85,19.47 100.12,19.47 100.35,19.24 100.35,18.3 99.05,17.01 98.29,17.01 98.29,17.72 98.04,17.97 97.43,17.97 97.32,18.08 97.32,18.37 97,18.69 97,19.58 97.05,19.63 98.7,19.63
GND on TOP (solid shape): 11.45,167.76 11.45,167.3 11.22,167.07 11.22,165.78 11.09,165.65 10.86,165.65 10.76,165.75 10.13,165.75 10,165.88 10,166.1 10.17,166.26 10.38,166.26 10.51,166.39 10.51,167.58 10.74,167.81 11.4,167.81
GND on TOP (solid shape): 23.17,36.64 23.17,34.32 22.75,33.9 22.43,33.9 22.4,33.92 22.39,33.93 22.12,34.41 21.8,34.85 21.79,34.87 21.79,36.49 22.13,36.82 22.99,36.82
GND on TOP (solid shape): 69.64,61.26 69.64,60.11 69.54,60.01 67.91,60.01 67.89,59.99 67.89,59.48 67.71,59.3 64.13,59.3 63.95,59.48 62.58,59.48 62.48,59.58 62.48,61.05 62.78,61.36 69.54,61.36
GND on TOP (solid shape): 247.86,32.03 247.89,32.02 247.91,31.98 247.91,31.16 247.85,31.09 246.96,31.09 246.41,30.54 245.74,30.54 245.62,30.66 245.62,31.06 246.6,32.03
GND on TOP (solid shape): 12.97,61.05 12.97,58.94 12.95,58.9 12.93,58.86 12.75,58.68 12.65,58.68 12.61,58.67 12.37,58.67 12.21,58.83 12.21,60.87 12.5,61.16 12.86,61.16
GND on TOP (solid shape): 23.77,143.08 21.85,143.08 21.85,143.05 19.7,143.05 19.5,143.25 17.21,143.25 17.01,143.05 14.95,143.05 14.95,144.35 19.51,144.35 19.65,144.49 19.65,146.17 19.78,146.3 22.47,146.3 22.55,146.37 22.55,149.8 23.77,149.8
GND on TOP (solid shape): 49.8,165.4 49.8,165.14 50.18,164.76 50.82,164.76 51.2,165.14 51.2,165.52 54.5,165.52 54.88,165.14 54.88,162.09 53.38,160.6 49.5,160.6 49.42,160.67 49.42,164.48 49.12,164.79 49.12,165.45 49.19,165.52 49.68,165.52
GND on TOP (solid shape): 176.75,25.56 176.75,23.95 176.39,23.59 176.1,23.59 175.97,23.72 175.97,23.96 176.18,24.17 176.18,24.87 176.4,25.1 176.41,25.18 176.41,25.53 176.5,25.62 176.69,25.62
GND on TOP (solid shape): 29.81,36.35 30.59,36.35 30.77,36.17 30.77,36.01 30.24,35.49 30.24,34.93 30.09,34.78 29.79,34.78 29.64,34.93 29.64,35.21 29.56,35.28 28.98,35.28 28.92,35.34 28.92,35.63 28.77,35.78 28.77,36.16 29.03,36.43 29.73,36.43
GND on TOP (solid shape): 48.72,120.18 48.97,120.18 49.09,120.29 49.24,120.29 49.26,120.29 49.27,120.28 49.7,119.85 49.7,119.66 49.67,119.63 48.08,119.63 48.04,119.67 48.03,119.68 48.03,119.7 48.03,119.87 48.46,120.29 48.61,120.29
GND on TOP (solid shape): 55.31,107.95 55.31,107.8 54.96,107.45 54.96,107.38 54.87,107.28 54.68,107.28 54.37,107.6 53.7,107.6 53.58,107.72 53.58,107.93 53.66,108.01 53.83,108.01 53.9,107.93 54.31,107.93 54.59,108.21 54.59,108.28 54.73,108.42 54.85,108.42
GND on TOP (solid shape): 56.48,33.57 56.48,33.27 55.87,32.66 55.87,31.84 55.59,31.56 53.66,31.56 53.6,31.63 53.6,32.72 53.68,32.79 55.3,32.79 55.3,32.8 55.38,32.8 55.82,33.23 55.82,33.67 55.94,33.79 56.26,33.79
GND on TOP (solid shape): 96.76,56.08 96.76,53.51 96.6,53.35 94.19,53.35 94,53.53 94,55.65 93.81,55.84 93.8,55.84 93.8,55.88 93.02,55.88 92.98,55.89 92.96,55.93 92.96,56.08 93.08,56.19 96.64,56.19
GND on TOP (solid shape): 129.3,30.76 129.3,27.8 128.06,26.57 124.6,26.57 124.52,26.65 124.48,26.71 124.44,26.75 124.43,26.77 124.43,26.78 124.43,28.62 125.86,30.05 126.84,30.05 127.65,30.86 129.19,30.86
GND on TOP (solid shape): 132.1,143.27 132.1,140 131.87,139.77 131.87,139.08 131.64,138.85 129.44,138.85 129.28,139 129.28,139.15 129.66,139.53 129.66,142.49 129.84,142.66 130.55,142.66 130.75,142.87 130.75,143.27 130.96,143.48 131.9,143.48
GND on TOP (solid shape): 139.07,126.45 139.07,124.47 138.87,124.26 136.08,124.26 135.9,124.44 135.9,125.08 136.13,125.31 136.13,126.3 136.28,126.45 136.52,126.45 136.79,126.18 136.79,125.31 136.91,125.18 138.31,125.18 138.44,125.31 138.44,126.45 138.56,126.58 138.95,126.58
GND on TOP (solid shape): 272.92,40.31 273.28,40.31 273.46,40.33 277.46,40.33 277.74,40.05 277.74,39.06 277.67,38.98 271.62,38.98 271.32,39.28 271.32,40.22 271.42,40.33 272.74,40.33
GND on TOP (solid shape): 26.81,107 26.81,106.7 26.66,106.55 26.66,104.74 26.46,104.54 25.67,104.54 25.49,104.36 25.27,104.36 25.09,104.54 24.35,104.54 24.17,104.72 24.17,105.63 25.74,107.2 26.62,107.2
GND on TOP (solid shape): 88.33,19.26 88.37,19.27 88.4,19.26 88.59,19.07 88.68,19.07 88.99,18.76 88.99,18.23 88.81,18.05 87.91,18.05 87.65,18.31 87.65,18.43 87.32,18.76 86.96,18.76 86.86,18.86 86.86,19.05 87.06,19.25 88.32,19.25
GND on TOP (solid shape): 243.73,53.64 244.67,53.64 244.68,53.63 245.14,53.54 245.61,53.49 245.63,53.49 245.79,53.33 245.79,52.67 245.71,52.59 242.79,52.59 242.66,52.72 242.66,53.43 242.67,53.44 242.67,53.79 242.91,54.02 243.34,54.02
GND on TOP (solid shape): 42.55,61.29 42.55,60.94 42.48,60.87 40.78,60.87 40.68,60.77 40.68,60.11 40.58,60.01 38.96,60.01 38.93,59.99 38.93,59.48 38.75,59.3 35.17,59.3 34.99,59.48 33.62,59.48 33.52,59.58 33.52,61.05 33.83,61.36 42.48,61.36
GND on TOP (solid shape): 57.08,109.76 57.25,109.7 57.42,109.76 57.65,109.76 58.1,109.31 58.1,109.13 58.06,109.09 56.48,109.09 56.42,109.14 56.42,109.33 56.84,109.74 56.85,109.75 56.87,109.76
GND on TOP (solid shape): 61.86,61.29 61.86,60.96 61.79,60.89 60.09,60.89 59.99,60.79 59.99,60.11 59.89,60.01 58.26,60.01 58.24,59.99 58.24,59.48 58.06,59.3 54.48,59.3 54.3,59.48 52.93,59.48 52.83,59.58 52.83,61.05 53.13,61.36 61.8,61.36
GND on TOP (solid shape): 50.24,61.35 52.13,61.35 52.25,61.24 52.25,60.84 52.15,60.74 50.45,60.74 50.34,60.62 50.34,60.11 50.23,60.01 48.61,60.01 48.58,59.99 48.58,59.48 48.41,59.3 44.82,59.3 44.65,59.48 43.27,59.48 43.17,59.58 43.17,61.05 43.48,61.36 50.23,61.36
GND on TOP (solid shape): 101.16,152.56 101.16,149.58 100.43,148.85 99.56,148.85 99.13,149.28 99.13,150.49 99.26,150.61 99.88,150.61 100.45,151.18 100.45,151.78 100.95,151.78 100.95,152.49 100.71,152.49 100.71,151.78 100.45,151.78 100.45,152.56 100.53,152.64 101.08,152.64
GND on TOP (solid shape): 105.73,142.03 105.73,141.14 105.45,140.86 105.45,140.1 105.33,139.97 104.34,139.97 104.04,140.27 104.04,140.51 103.96,141.06 103.73,141.57 103.73,141.59 103.73,142.08 104.06,142.41 105.35,142.41
GND on TOP (solid shape): 244.93,16.54 244.93,16.38 244.62,16.08 244.62,14.34 244.57,14.29 244.5,14.24 244.44,14.18 244.42,14.17 244.4,14.16 244.03,14.16 243.88,14.31 243.88,15.18 243.76,15.31 243.76,15.72 243.69,15.78 243.69,16.49 243.89,16.69 244.77,16.69
GND on TOP (solid shape): 10.86,82.28 11.96,82.28 12.09,82.15 12.09,81.72 11.94,81.56 10.12,81.56 9.91,81.35 7.26,81.35 7.24,81.37 7.24,81.5 7.17,81.57 7.21,81.66 7.22,81.75 7.21,81.86 7.17,81.95 7.17,82.9 7.23,82.97 10.18,82.97
GND on TOP (solid shape): 53.59,109.75 53.75,109.7 53.91,109.75 54.16,109.75 54.6,109.31 54.6,109.15 54.6,109.13 54.59,109.11 54.57,109.09 52.98,109.09 52.94,109.13 52.93,109.14 52.93,109.16 52.93,109.33 53.35,109.75
GND on TOP (solid shape): 58.52,120.18 58.77,120.18 58.86,120.27 59.07,120.27 59.5,119.84 59.51,119.82 59.51,119.8 59.51,119.64 59.48,119.6 57.89,119.6 57.8,119.69 57.8,119.82 57.8,119.84 57.82,119.86 57.86,119.9 57.89,119.94 58.1,120.15 58.1,120.19 58.21,120.3 58.39,120.3
GND on TOP (solid shape): 62.68,118.86 62.85,118.8 63.02,118.86 63.25,118.86 63.7,118.42 63.7,118.23 63.66,118.2 62.07,118.2 62.04,118.24 62.03,118.25 62.02,118.27 62.02,118.41 62.03,118.43 62.04,118.45 62.45,118.86
GND on TOP (solid shape): 81.29,61.41 81.29,61.04 81.1,60.86 79.43,60.86 79.29,60.72 79.29,60.11 79.19,60.01 77.56,60.01 77.54,59.99 77.54,59.48 77.36,59.3 73.78,59.3 73.6,59.48 72.23,59.48 72.13,59.58 72.13,61.05 72.43,61.36 79.19,61.36 79.19,61.35 80.61,61.35 80.74,61.48 81.21,61.48
GND on TOP (solid shape): 145.48,163.01 145.48,161.92 145.21,161.64 144.98,161.64 144.81,161.47 144.81,161.01 144.98,160.85 145.18,160.85 145.41,160.62 145.41,159.88 145.18,159.66 141.4,159.66 140.81,159.07 140.81,157.29 140.68,157.17 138.83,157.17 138.58,157.42 138.58,161.38 138.91,161.71 143.55,161.71 143.99,162.14 143.99,163.06 144.14,163.21 145.28,163.21
GND on TOP (solid shape): 25.39,61.36 32.85,61.36 32.93,61.28 32.93,60.95 32.83,60.85 31.13,60.85 31.03,60.75 31.03,60.11 30.93,60.01 29.3,60.01 29.28,59.99 29.28,59.48 29.1,59.3 25.52,59.3 25.34,59.48 23.97,59.48 23.87,59.58 23.87,60.54 23.97,60.65 23.97,61.26 24.58,61.87 24.89,61.87
GND on TOP (solid shape): 90.73,62.12 90.73,61.68 91.01,61.4 91.01,61.21 90.67,60.86 89.06,60.86 88.94,60.75 88.94,60.11 88.84,60.01 87.22,60.01 87.19,59.99 87.19,59.48 87.01,59.3 83.43,59.3 83.25,59.48 81.88,59.48 81.78,59.58 81.78,61.05 82.09,61.36 89.49,61.36 90.3,62.17 90.68,62.17
GND on TOP (solid shape): 105.2,130.22 105.2,108.55 103.68,107.03 103.12,107.03 102.86,107.28 102.86,119.27 102.41,119.73 102.13,119.73 102.04,119.82 102.04,119.82 102.04,120.94 102.15,121.05 102.28,121.05 102.71,121.48 102.71,122.47 102.38,122.8 102.1,122.8 102.03,122.88 102.03,124.07 102.08,124.12 102.61,124.12 102.86,124.37 102.86,130.17 103.27,130.57 104.84,130.57
GND on TOP (solid shape): 164.74,23.54 164.74,22.39 164.61,22.27 162.32,22.27 161.69,21.63 161.69,19.47 161.56,19.35 160.29,19.35 160.04,19.6 160.04,21.91 160.04,21.93 160.05,21.94 160.12,22.03 160.16,22.12 160.16,22.14 160.42,22.39 161.44,22.39 161.94,22.9 161.94,23.41 162.2,23.66 164.61,23.66
GND on TOP (solid shape): 226.95,23.71 227.28,23.71 227.36,23.63 227.36,23.46 227.1,23.21 227.1,22.82 227.29,22.63 227.51,22.63 227.61,22.53 227.61,22.21 227.5,22.11 227.2,22.11 226.72,22.59 226.72,23.45 226.59,23.58 226.59,23.74 226.67,23.82 226.84,23.82
GND on TOP (solid shape): 56.45,108.28 56.66,108.28 56.79,108.4 57.01,108.4 57.2,108.21 57.2,108.12 57.39,107.93 57.39,107.72 57.36,107.69 56.48,107.69 56.37,107.8 56.05,107.8 55.94,107.69 55.77,107.69 55.67,107.79 55.67,107.92 55.68,107.94 55.69,107.96 55.74,108.01 55.78,108.08 56.11,108.41 56.32,108.41
GND on TOP (solid shape): 84.85,51.22 84.85,48.45 84.78,48.38 84.78,48.12 83.84,47.18 83.84,46.45 83.71,46.32 82.9,46.32 82.85,46.37 82.85,46.85 82.04,47.67 80.16,47.67 80.16,48.3 80.03,48.43 79.59,48.43 79.49,48.53 79.27,48.53 79.04,48.76 79.04,50.03 79.04,50.04 79.04,51.13 79.41,51.49 79.41,51.49 79.41,51.87 79.65,52.11 83.97,52.11
GND on TOP (solid shape): 229.51,20.15 229.51,19.67 229.52,19.65 229.52,19.38 230.01,18.9 230,18.85 230,18.57 230.04,18.43 230.15,18.35 230.19,18.3 230.63,18.3 230.73,18.2 230.73,17.72 230.67,17.66 228.98,17.66 228.88,17.76 228.88,20.23 228.93,20.28 229.39,20.28
GND on TOP (solid shape): 10.08,78.2 10.08,77.84 9.89,77.65 9.87,77.65 9.65,77.54 9.53,77.31 9.37,77.14 8.43,77.14 8.38,77.1 8.14,77.1 7.99,77.25 7.99,77.48 8.39,77.88 8.39,78.21 8.43,78.25 10.03,78.25
GND on TOP (solid shape): 101.24,159.55 101.24,156.27 101.11,156.15 100.19,156.15 99.95,156.39 98.86,156.39 98.82,156.43 98.82,156.61 98.88,156.66 99.21,156.66 99.26,156.71 99.26,157.32 99.03,157.55 98.42,157.55 98.24,157.37 98.24,157.04 98.19,156.99 97.94,156.99 97.88,157.04 97.88,159.53 98.06,159.71 101.09,159.71
GND on TOP (solid shape): 115.44,153.23 115.44,152.92 115.92,152.44 116.53,152.44 116.63,152.54 116.63,153.18 116.81,153.36 117.6,153.36 117.72,153.23 117.72,147.84 118.56,147.01 119.22,147.01 119.62,147.41 120.31,147.41 120.62,147.11 120.62,144.09 120.41,143.88 117.09,143.88 115.69,145.28 115.69,151.65 115.46,151.88 114.32,151.88 114.22,151.98 114.22,153.28 114.34,153.41 115.26,153.41
GND on TOP (solid shape): 166.16,162.93 166.16,161.92 165.32,161.08 165.32,160.93 165.47,160.77 165.86,160.77 166.16,160.47 166.16,159.71 165.96,159.5 162.32,159.5 162.25,159.43 162.25,156.35 162.17,156.28 159.89,156.28 159.3,156.86 159.3,158.46 159.28,158.49 159.28,161.1 159.76,161.59 164.23,161.59 164.79,162.14 164.79,162.83 164.94,162.98 166.11,162.98
GND on TOP (solid shape): 239.62,60.21 239.62,58.46 239.46,58.31 239.01,58.31 238.38,57.68 237.55,57.68 237.55,57.67 237.43,57.67 237.33,57.57 237.33,54.3 237.13,54.09 236.52,54.09 236.39,54.22 236.39,55.08 236.22,55.26 236.22,55.27 235.65,55.83 235.65,57.96 238.39,57.96 238.39,58.18 237.55,58.18 237.55,57.96 235.65,57.96 235.65,60.16 235.93,60.44 239.39,60.44
GND on TOP (solid shape): 248.33,15.82 248.45,15.82 248.52,15.79 248.59,15.77 248.61,15.77 248.66,15.71 248.66,13.63 248.41,13.38 247.29,13.38 247.11,13.55 247.11,13.83 247.41,14.14 247.41,15.13 247.31,15.23 247.28,15.23 247.25,15.26 247.25,15.27 246.9,15.27 246.87,15.26 246.75,15.38 246.75,16.02 246.98,16.25 247.31,16.25 247.47,16.4 247.74,16.4
GND on TOP (solid shape): 252.52,27.12 252.52,26.18 252.42,26.08 250.91,26.08 250.89,26.08 250.88,26.09 250.59,26.22 250.3,26.09 250.29,26.08 250.27,26.08 248.76,26.08 248.66,26.18 248.66,26.92 249.07,27.32 252.32,27.32
GND on TOP (solid shape): 7.41,165.37 7.41,165.07 7.51,164.96 7.54,164.96 7.6,164.94 7.66,164.93 7.94,164.93 8,164.94 8.06,164.96 8.27,164.96 8.4,164.84 8.4,164.68 8.5,164.58 8.88,164.58 9.04,164.43 9.04,164.13 8.6,163.69 6.85,163.69 6.6,163.95 6.6,165.55 6.72,165.68 7.1,165.68
GND on TOP (solid shape): 31.9,108.42 31.9,106.48 31.88,106.43 31.87,106.39 31.86,106.29 31.86,106.24 31.86,105.9 31.33,105.37 30.76,105.37 30.54,105.15 30.54,104.7 30.45,104.61 29.74,104.61 29.68,104.68 29.56,104.79 29.56,108.5 29.74,108.68 31.64,108.68
GND on TOP (solid shape): 40.05,58.87 40.14,58.87 40.14,58.85 40.79,58.85 40.79,58.64 40.74,58.6 40.14,58.6 40.14,58.59 40.02,58.59 39.87,58.44 39.87,57.57 39.95,57.5 40.76,57.5 40.79,57.47 40.79,57.25 40.14,57.25 40.14,57.24 40.05,57.24 39.92,57.12 39.92,56.99 39.82,56.89 38.09,56.89 38.02,56.96 38.02,58.87 38.04,58.89 39.08,58.89 39.19,59 39.92,59
GND on TOP (solid shape): 58.76,30.17 58.76,29.42 58.85,29.33 59.45,29.33 59.61,29.18 59.61,22.44 59.56,22.39 57.75,22.39 57.55,22.18 57.55,21.47 57.54,21.45 57.37,21.45 57.36,21.47 57.36,22.2 57.17,22.39 56.58,22.39 56.53,22.44 56.53,29.33 58.45,29.33 58.56,29.44 58.56,30.17 58.58,30.19 58.74,30.19
GND on TOP (solid shape): 88.21,58.87 88.4,58.87 88.4,58.85 89.05,58.85 89.05,58.6 88.4,58.6 88.4,58.59 88.33,58.59 88.13,58.39 88.13,57.75 88.36,57.52 88.4,57.52 88.4,57.5 89.05,57.5 89.05,57.25 88.4,57.25 88.4,57.24 88.28,57.24 88.18,57.14 88.18,56.96 88.06,56.84 86.4,56.84 86.28,56.96 86.28,58.87 86.3,58.89 87.34,58.89 87.45,59 88.08,59
GND on TOP (solid shape): 280.2,20.69 280.24,20.68 280.25,20.64 280.25,19.65 280.28,19.62 280.28,19.55 280.41,19.42 280.66,19.42 280.71,19.37 280.71,17.72 280.64,17.64 279.04,17.64 278.96,17.72 278.96,19.4 279.01,19.45 279.8,19.45 279.93,19.57 279.93,19.63 279.95,19.65 279.95,20.66 279.97,20.68 280,20.69
GND on TOP (solid shape): 30.32,58.87 30.49,58.87 30.49,58.85 31.11,58.85 31.11,58.61 31.09,58.6 30.49,58.6 30.49,58.59 30.35,58.59 30.19,58.44 30.19,57.57 30.27,57.5 31.03,57.5 31.11,57.42 31.11,57.27 31.09,57.25 30.49,57.25 30.49,57.24 30.32,57.24 30.19,57.12 30.19,56.94 30.14,56.89 28.44,56.89 28.37,56.96 28.37,58.87 28.39,58.89 29.43,58.89 29.53,59 30.19,59
GND on TOP (solid shape): 62.17,115.72 62.19,115.72 62.21,115.71 62.36,115.56 62.64,115.56 62.77,115.69 62.93,115.69 63.04,115.58 63.36,115.58 63.48,115.7 63.64,115.7 63.74,115.6 63.74,115.46 63.31,115.03 63.26,114.98 63.11,114.98 62.96,115.13 62.73,115.13 62.59,114.99 62.41,114.99 61.95,115.45 61.95,115.61 62.06,115.71 62.07,115.72 62.09,115.72
GND on TOP (solid shape): 68.9,58.87 69.09,58.87 69.09,58.85 69.74,58.85 69.74,58.6 69.09,58.6 69.09,58.59 68.93,58.59 68.83,58.49 68.83,57.62 68.93,57.52 69.09,57.52 69.09,57.5 69.74,57.5 69.74,57.29 69.69,57.25 69.09,57.25 69.09,57.24 68.98,57.24 68.85,57.12 68.85,56.91 68.78,56.84 67.05,56.84 66.97,56.91 66.97,58.87 67,58.89 68.04,58.89 68.14,59 68.78,59
GND on TOP (solid shape): 155.42,162.93 155.42,161.97 154.83,161.38 154.83,160.72 154.91,160.65 155.29,160.65 155.47,160.47 155.47,159.71 155.21,159.45 151.48,159.45 151.3,159.27 151.3,156.58 151.15,156.43 149.07,156.43 148.58,156.91 148.58,160.82 148.71,160.95 148.71,161.23 149.07,161.59 153.69,161.59 153.99,161.89 153.99,162.93 154.1,163.03 155.31,163.03
GND on TOP (solid shape): 49.5,58.89 49.79,58.89 49.79,58.85 50.4,58.85 50.42,58.86 50.46,58.82 50.46,58.6 49.79,58.6 49.79,58.56 49.68,58.56 49.52,58.41 49.52,57.7 49.7,57.52 49.79,57.52 49.79,57.5 50.44,57.5 50.44,57.25 49.79,57.25 49.79,57.24 49.7,57.24 49.6,57.14 49.6,56.99 49.45,56.84 47.75,56.84 47.67,56.91 47.67,58.87 47.69,58.89 48.74,58.89 48.84,59 49.4,59
GND on TOP (solid shape): 124.59,13.53 124.59,11.88 124.64,11.83 127.86,11.83 128.07,11.62 128.07,10.6 128.23,10.44 128.51,10.44 128.58,10.38 128.58,9.51 128.26,9.2 113.07,9.2 112.87,9.39 112.87,11.13 113.08,11.33 116.24,11.33 116.28,11.31 116.29,11.28 116.29,10.69 116.61,10.38 118.26,10.38 118.6,10.72 118.6,11.4 118.07,11.93 118.07,13.58 118.29,13.8 124.33,13.8
GND on TOP (solid shape): 134.99,162.91 134.99,161.89 134.46,161.36 134.46,160.87 134.64,160.7 134.82,160.7 135.05,160.47 135.05,159.66 134.87,159.48 131.34,159.48 129.81,157.95 129.81,157.09 129.48,156.76 127.6,156.76 127.09,157.27 127.09,158.56 127.87,159.34 127.87,161.19 128.26,161.59 133.19,161.59 133.62,162.02 133.62,162.91 133.75,163.03 134.87,163.03
GND on TOP (solid shape): 271.93,55.21 275.48,55.21 275.76,55.49 275.76,55.85 275.89,55.97 279.67,55.97 279.98,55.67 279.98,54.65 279.72,54.4 276.88,54.4 276.61,54.13 272.37,54.13 272.34,54.16 272.34,54.17 271.56,54.95 270.94,54.95 270,55.89 267.91,55.89 267.81,55.79 267.81,55.65 267.74,55.58 267.72,55.57 267.7,55.56 267.54,55.56 267.45,55.65 267.45,56.18 267.71,56.44 270.7,56.44
GND on TOP (solid shape): 20.79,58.85 21.45,58.85 21.46,58.84 21.46,58.61 21.44,58.6 20.73,58.6 20.62,58.49 20.62,57.62 20.74,57.5 21.45,57.5 21.48,57.46 21.48,57.28 21.45,57.25 20.7,57.25 20.62,57.17 20.62,56.96 20.52,56.86 18.69,56.86 18.61,56.94 18.61,58.94 18.66,59 20.64,59
GND on TOP (solid shape): 59.23,58.87 59.44,58.87 59.44,58.85 60.03,58.85 60.14,58.74 60.14,58.67 60.07,58.6 59.44,58.6 59.44,58.59 59.38,58.59 59.23,58.44 59.23,57.55 59.25,57.52 59.44,57.52 59.44,57.5 60.04,57.5 60.09,57.45 60.09,57.25 59.44,57.25 59.44,57.22 59.28,57.22 59.2,57.14 59.2,56.94 59.1,56.84 57.42,56.84 57.32,56.94 57.32,58.87 57.35,58.89 58.39,58.89 58.49,59 59.1,59
GND on TOP (solid shape): 60.61,109.74 60.75,109.7 60.89,109.74 60.9,109.74 61.3,109.74 61.31,109.74 61.45,109.7 61.59,109.74 61.6,109.74 61.9,109.74 62.34,109.3 62.34,109.11 62.32,109.09 62.31,109.08 62.29,109.08 59.97,109.08 59.92,109.13 59.92,109.32 60.34,109.74 60.6,109.74
GND on TOP (solid shape): 78.49,58.91 78.52,58.91 78.56,58.87 78.75,58.87 78.75,58.85 79.42,58.85 79.42,58.64 79.38,58.6 78.75,58.6 78.75,58.56 78.56,58.56 78.48,58.49 78.48,57.55 78.5,57.52 78.75,57.52 78.75,57.5 79.39,57.5 79.39,57.25 78.75,57.25 78.75,57.24 78.58,57.24 78.5,57.17 78.5,56.91 78.4,56.81 76.73,56.81 76.63,56.91 76.63,58.87 76.65,58.89 77.69,58.89 77.79,59 78.4,59
GND on TOP (solid shape): 28.78,100.75 28.78,99.46 28.68,99.37 27.95,99.37 27.83,99.5 26.83,99.5 26.69,99.36 25.7,99.36 25.7,99.36 23.49,99.36 23.29,99.56 23.29,100.4 23.48,100.55 23.55,100.78 23.55,100.85 23.53,100.92 23.54,100.94 23.57,100.96 28.57,100.96
GND on TOP (solid shape): 46.57,106.85 46.91,106.85 47,106.94 47.18,106.94 47.69,106.43 47.91,106.43 48.06,106.58 48.08,106.59 48.09,106.6 48.25,106.6 48.31,106.53 48.31,106.38 47.85,105.91 47.67,105.91 47.65,105.91 47.63,105.92 47.59,105.96 47.54,105.99 47.14,106.39 46.94,106.39 46.49,105.93 46.3,105.93 45.89,106.34 45.89,106.54 46.28,106.93 46.3,106.94 46.32,106.94 46.48,106.94
GND on TOP (solid shape): 62.88,37.85 62.9,37.84 62.96,37.79 63,37.77 63.11,37.71 63.22,37.69 63.45,37.69 64.03,37.11 64.45,37.11 64.47,37.1 64.49,37.09 64.59,36.99 64.59,36.67 64.42,36.51 63.96,36.51 63.19,37.27 62.77,37.27 62.77,37.28 62.12,37.28 61.95,37.45 61.95,37.67 62.13,37.85
GND on TOP (solid shape): 73.04,164.53 73.04,164.22 72.98,164.16 72.57,164.16 72.16,163.75 70.93,163.75 70.77,163.75 70.54,163.51 70.54,162.83 70.44,162.73 69.95,162.73 69.74,162.93 69.74,163.08 69.4,163.42 69.4,163.47 69.17,163.7 68.02,163.7 67.77,163.95 67.44,163.95 67.31,164.07 67.31,164.35 67.43,164.47 71.28,164.47 71.4,164.58 72.98,164.58
GND on TOP (solid shape): 205.23,47.69 205.23,46.75 205.53,46.44 205.53,45.63 205.77,45.39 205.78,45.37 205.77,45.3 205.79,45.23 205.79,44.84 205.51,44.56 205.38,44.56 205.12,44.82 204.95,44.82 204.87,44.9 204.87,45.03 205,45.15 205,45.55 204.9,45.65 203.83,45.65 203.78,45.71 203.78,45.94 203.83,45.99 204.16,45.99 204.41,46.24 204.41,47.51 204.64,47.74 205.17,47.74
GND on TOP (solid shape): 251.96,37.71 251.96,34.56 251.99,34.54 252.14,34.54 252.17,34.52 252.19,34.48 252.19,34.47 252.9,34.47 252.95,34.41 252.95,34.34 252.96,34.33 252.96,34.31 252.93,34.27 252.91,34.27 252.19,34.27 252.19,34.26 251.96,34.26 251.94,34.28 246.42,34.28 246.37,34.33 246.37,37.76 246.39,37.8 246.42,37.81 251.86,37.81
GND on TOP (solid shape): 158.22,23.22 158.22,22.78 158.47,22.53 158.94,22.53 159.12,22.46 159.31,22.48 159.33,22.48 159.36,22.46 159.41,22.41 159.42,22.38 159.41,22.37 159.39,22.3 159.38,22.23 159.39,22.15 159.42,22.06 159.42,21.95 159.39,21.92 158.45,21.92 157.21,23.16 157.21,23.31 157.27,23.37 158.07,23.37
GND on TOP (solid shape): 45.39,41.72 45.93,41.19 45.93,41 46.16,40.77 46.16,39.87 45.79,39.5 45.79,39.09 45.52,38.82 44.4,38.82 44.35,38.88 44.35,39.31 44.57,39.53 44.73,39.53 44.84,39.64 44.85,39.65 44.95,39.71 45.01,39.8 45.01,39.81 45.05,39.86 45.05,41.79 45.08,41.81 45.3,41.81
