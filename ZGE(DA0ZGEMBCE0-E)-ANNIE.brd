# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ38: length 84.4
  TOP w0.089: U3.AA2 133.51,105.54 v1(133.16,105.2)
  TOP w0.102: v1(124.22,40.41) 124.58,40.18 124.76,40.06 125.03,39.77 125.4,39.29 125.48,39.16 125.72,38.68 125.82,38.38 JDIM2.182
  IN2 w0.079: 131.6,98.31 132.45,99.16 132.45,99.7 133.31,100.57 133.31,101.19 134.01,101.89 134.01,104.58 133.39,105.2 v1(133.16,105.2)
  IN2 w0.127: v1(124.22,40.41) 123.17,41.47 123.17,43.86 121.23,45.8 121.23,46.21 116.45,50.99 116.45,57.12 116.97,57.63 116.97,58.45 117.42,58.9 117.42,61.52 117.92,62.02 117.92,63.06 118.05,63.18 118.2,63.18 118.33,63.31 118.33,63.55 118.19,63.69 118.05,63.69 117.92,63.82 117.92,64.04 118.62,64.74 118.62,66.75 122.33,70.46 122.33,87.47 128.48,93.63 128.48,95.19 131.6,98.31
  BOTTOM w0.102: JDIM4.187 122.67,38.31 122.88,38.51 122.88,38.71 123.48,39.61 v1(124.22,40.41)
M_A_DQ39: length 81.9
  TOP w0.089: v1(133.16,104.56) 133.49,104.89 U3.AA1
  TOP w0.102: JDIM2.186 124.82,38.96 124.62,39.17 v1(124.4,39.17)
  IN2 w0.079: 131.35,98.48 132.12,99.26 132.12,99.74 133.03,100.65 133.03,101.23 133.77,101.97 133.77,104.45 133.67,104.56 v1(133.16,104.56)
  IN2 w0.127: v1(124.4,39.17) 124.3,39.17 122.81,40.66 122.81,43.71 120.87,45.65 120.87,46.06 116.1,50.84 116.1,57.26 116.61,57.78 116.61,58.6 117.06,59.05 117.06,61.67 117.56,62.17 117.56,64.19 118.26,64.89 118.26,66.89 121.98,70.61 121.98,87.62 128.13,93.77 128.13,95.26 131.35,98.48
  BOTTOM w0.102: JDIM4.183 123.67,38.68 124.16,39.17 v1(124.4,39.17)
M_A_DQ40: length 87.9
  TOP w0.079: v1(133.09,102.56) 132.27,103.38 132.27,106.39 132.13,106.54 131.71,106.54 131.45,106.79 131.45,107.11 U3.V5
  TOP w0.102: JDIM2.191 123.57,43.58 122.5,42.5 v1(122.32,42.5)
  IN2 w0.079: 130.44,98.53 131.47,99.56 131.47,99.74 132.5,100.77 132.5,101.33 133.09,101.92 v1(133.09,102.56)
  IN2 w0.127: v1(122.32,42.5) 121.91,42.9 121.91,43.49 120.09,45.32 120.09,45.74 119.94,45.88 119.76,45.88 119.49,45.6 119.31,45.6 119.13,45.78 119.13,45.96 119.4,46.24 119.4,46.42 119.22,46.6 119.04,46.6 118.74,46.29 118.58,46.29 118.4,46.47 118.4,46.67 118.68,46.96 118.68,47.14 116.33,49.49 116.15,49.49 115.82,49.15 115.64,49.15 115.46,49.33 115.46,49.51 115.8,49.85 115.8,50.03 115.62,50.21 115.44,50.21 115.22,49.99 115.04,49.99 114.86,50.17 114.86,50.35 115.08,50.57 115.08,50.75 114.81,51.01 114.81,58.39 116.28,59.86 116.28,62.68 116.78,63.18 116.78,66.52 121.19,70.94 121.19,87.95 127.34,94.1 127.34,95.43 128.34,96.43 130.44,98.53
  BOTTOM w0.102: JDIM4.194 120.92,43.89 v1(122.32,42.5)
M_A_DQ41: length 86.6
  TOP w0.079: v1(132.16,101.66) 131.96,101.86 131.96,104.55 132.11,104.7 132.11,105.25 U3.V2
  TOP w0.102: v1(122.18,40.72) 122.51,40.72 123.5,39.73 123.5,38.87 123.82,38.55 JDIM2.190
  IN2 w0.079: 130.4,99.03 130.45,99.03 132.16,100.74 v1(132.16,101.66)
  IN2 w0.127: 130.4,99.03 126.98,95.61 126.98,94.25 120.83,88.09 120.83,71.08 116.42,66.67 116.42,63.33 115.92,62.83 115.92,60.01 114.63,58.72 114.4,58.72 114.14,58.46 114.14,57.85 114.46,57.54 114.46,54.47 114.33,54.34 114.06,54.34 113.94,54.21 113.94,53.96 114.06,53.83 114.33,53.83 114.46,53.71 114.46,49.76 116.7,47.52 116.88,47.52 117.03,47.67 117.21,47.67 117.39,47.49 117.39,47.31 117.24,47.16 117.24,46.98 119.11,45.11 119.8,45.11 121.56,43.35 121.56,42.34 121.94,41.96 121.94,40.97 v1(122.18,40.72)
  BOTTOM w0.102: JDIM4.195 120.67,39.66 121.85,40.83 122.07,40.83 v1(122.18,40.72)
M_A_DQ42: length 83.5
  TOP w0.089: v1(130.64,104.43) 130.64,104.43 U3.U1
  TOP w0.102: JDIM2.208 119.32,38.11 119.7,38.49 119.7,39.15 119.51,39.34 v1(119.25,39.34)
  IN2 w0.079: 126.61,98.23 126.85,98.48 127.01,98.48 131.08,102.55 131.08,104 v1(130.64,104.43)
  IN2 w0.127: v1(119.25,39.34) 118.57,39.34 118.44,39.47 118.44,41.1 117.62,41.92 117.62,42.55 117.09,43.08 117.09,43.46 110.91,49.64 110.91,60.71 113.05,62.85 113.05,66.99 118.27,72.2 118.27,89.12 124.34,95.19 124.34,95.97 126.61,98.23
  BOTTOM w0.102: JDIM4.203 118.67,38.3 118.45,38.52 118.45,38.92 118.88,39.34 v1(119.25,39.34)
M_A_DQ43: length 85.7
  TOP w0.089: U3.U2 131.09,105.53 v1(130.64,105.12)
  TOP w0.102: JDIM2.204 120.32,39.39 119.73,40.17 119.3,40.61 v1(119.17,40.61)
  IN2 w0.079: v1(130.64,105.12) 130.82,105.31 131.26,105.31 131.4,105.16 131.4,104.89 131.28,104.77 131.28,104.43 131.4,104.31 131.4,102.56 127.04,98.21 126.95,98.21 126.56,97.82
  IN2 w0.127: v1(119.17,40.61) 119.17,40.87 117.97,42.07 117.97,42.69 117.44,43.23 117.44,43.61 111.27,49.78 111.27,58.95 111.97,59.65 111.97,61.26 113.41,62.7 113.41,66.84 118.63,72.06 118.63,88.97 124.7,95.04 124.7,95.95 126.56,97.82
  BOTTOM w0.102: v1(119.17,40.61) 117.67,39.12 JDIM4.207
M_A_DQ44: length 83.9
  TOP w0.079: v1(131.71,101.19) 131.71,101.19 131.71,104.77 U3.V1
  TOP w0.102: JDIM2.194 122.82,39.09 122.51,39.41 v1(122.29,39.41)
  IN2 w0.079: v1(131.71,101.19) 131.71,100.62 130.26,99.17 130.14,99.17
  IN2 w0.127: 130.14,99.17 126.63,95.66 126.63,94.39 120.48,88.24 120.48,71.23 116.07,66.82 116.07,63.47 115.57,62.97 115.57,60.67 115.31,60.41 115.31,60.23 115.38,60.15 115.38,59.97 115.21,59.79 115.03,59.79 114.95,59.87 114.77,59.87 114.59,59.69 114.59,59.51 114.67,59.43 114.67,59.26 114.49,59.08 114.31,59.08 114.23,59.15 114.05,59.15 113.57,58.68 113.57,57.92 114.1,57.39 114.1,54.88 113.57,54.35 113.57,53.81 114.1,53.28 114.1,49.61 118.96,44.75 119.65,44.75 121.2,43.2 121.2,42.19 121.58,41.81 121.58,39.56 121.73,39.41 v1(122.29,39.41)
  BOTTOM w0.102: v1(122.29,39.41) 121.96,39.41 121.67,39.13 JDIM4.191
M_A_DQ45: length 86.3
  TOP w0.079: U3.V4 132.12,106.84 132.43,106.53 132.43,104.07 132.57,103.92 132.57,103.79 v1(133.16,103.2)
  TOP w0.102: v1(122.33,43.13) 122.74,43.13 123.06,43.45 123.06,43.98 122.57,44.47 JDIM2.195
  IN2 w0.079: v1(133.16,103.2) 133.16,103.36 133.39,103.59 133.5,103.59 133.57,103.52 133.57,102.14 132.75,101.32 132.75,100.72 131.79,99.76 131.79,99.43 130.7,98.34
  IN2 w0.127: 130.7,98.34 127.7,95.34 127.7,93.95 121.54,87.8 121.54,70.79 117.13,66.38 117.13,65.04 117.36,64.82 117.36,64.59 117.13,64.37 117.13,62.52 117,62.39 116.8,62.39 116.63,62.22 116.63,59.23 116.4,59 115.92,59 115.79,58.87 115.79,58.61 115.89,58.51 116.04,58.51 116.18,58.37 116.18,58.06 116.06,57.93 115.69,57.93 115.44,58.18 115.29,58.18 115.17,58.06 115.17,57.26 115.29,57.13 115.54,57.13 115.66,57 115.66,56.75 115.54,56.62 115.29,56.62 115.17,56.49 115.17,56.24 115.29,56.11 115.54,56.11 115.66,55.99 115.66,55.73 115.54,55.61 115.29,55.61 115.17,55.48 115.17,55.22 115.29,55.1 115.54,55.1 115.66,54.97 115.66,53.64 115.45,53.43 115.45,53.26 115.66,53.05 115.66,51.76 115.56,51.65 115.3,51.65 115.17,51.53 115.17,51.2 115.3,51.07 115.59,51.07 115.66,50.99 115.66,50.66 120.44,45.88 120.44,45.47 122.33,43.58 v1(122.33,43.13)
  BOTTOM w0.102: JDIM4.190 121.92,44.47 121.54,44.08 121.54,43.6 122,43.13 v1(122.33,43.13)
M_A_DQ46: length 87.5
  TOP w0.089: v1(130.64,107.11) 131.02,107.49 U3.U5
  TOP w0.102: v1(118.27,43.65) 118.27,43.46 118.69,43.03 119.29,43.03 119.57,43.32 JDIM2.207
  IN2 w0.079: 127.28,97.85 132.1,102.67 132.1,105.64 v1(130.64,107.11)
  IN2 w0.127: 127.28,97.85 125.46,96.03 125.46,94.79 119.34,88.67 119.34,71.76 114.86,67.29 114.86,67.11 114.94,67.04 114.94,66.78 114.81,66.66 114.25,66.66 114.12,66.53 114.12,66.28 114.25,66.15 114.81,66.15 114.94,66.02 114.94,65.77 114.81,65.64 114.25,65.64 114.12,65.51 114.12,65.26 114.25,65.13 114.81,65.13 114.94,65.01 114.94,64.75 114.81,64.63 114.25,64.63 114.12,64.5 114.12,64.2 114.25,64.07 114.54,64.07 114.67,63.93 114.67,63.67 114.46,63.46 114.46,61.13 113.66,60.33 113.48,60.33 113.27,60.54 113.07,60.54 112.91,60.38 112.91,60.18 113.12,59.97 113.12,59.79 112.46,59.13 112.46,49.6 118.27,43.79 v1(118.27,43.65)
  BOTTOM w0.102: JDIM4.204 118.42,44.67 118.18,44.42 117.59,44.42 117.52,44.35 117.52,44.1 117.72,43.89 117.85,43.89 118.02,44.07 118.18,44.07 118.28,44.17 118.42,44.17 118.5,44.1 118.5,43.88 v1(118.27,43.65)
M_A_DQ47: length 86.7
  TOP w0.089: v1(130.65,106.46) 131.03,106.84 U3.U4
  TOP w0.102: JDIM2.203 120.57,43.66 119.43,42.52 v1(118.94,42.52)
  IN2 w0.079: 127.07,97.93 131.61,102.47 131.61,105.84 130.99,106.46 v1(130.65,106.46)
  IN2 w0.127: v1(118.94,42.52) 119.13,42.52 119.38,42.27 119.38,41.97 119.13,41.72 118.82,41.72 118.33,42.22 118.33,42.84 117.8,43.37 117.8,43.76 111.69,49.87 111.69,50.09 111.98,50.38 111.98,50.6 111.84,50.74 111.76,50.74 111.62,50.87 111.62,58.8 112.32,59.5 112.32,61.11 113.76,62.55 113.76,66.69 118.98,71.91 118.98,88.82 125.11,94.95 125.11,95.97 127.07,97.93
  BOTTOM w0.102: v1(118.94,42.52) 118.7,42.52 117.31,43.9 117.31,44.47 117.42,44.59 JDIM4.208
M_A_DQ48: length 86.4
  TOP w0.079: U3.R2 129.6,105.25 129.6,104.07 128.8,103.27 v1(128.8,102.08)
  TOP w0.102: JDIM2.225 115.07,43.71 113.61,42.25 v1(113.56,42.25)
  IN2 w0.079: 119.97,94.52 120.2,94.75 120.48,94.75 124.68,98.95 124.68,99.4 127.36,102.08 v1(128.8,102.08)
  IN2 w0.127: 119.97,94.52 115.66,90.21 115.66,74.22 110.79,69.35 110.79,68.54 109.85,67.59 109.85,65.71 109.72,65.59 109.35,65.59 109.22,65.46 109.22,65.21 109.35,65.08 109.72,65.08 109.85,64.95 109.85,64.7 109.72,64.57 109.35,64.57 109.22,64.44 109.22,64.19 109.35,64.06 109.72,64.06 109.85,63.94 109.85,63.62 109.74,63.52 109.35,63.52 109.22,63.39 109.22,63 107.54,61.32 107.54,58.99 107.41,58.86 107.41,49.35 113.72,43.04 113.72,42.84 113.95,42.61 113.95,42.38 113.82,42.25 v1(113.56,42.25)
  BOTTOM w0.102: JDIM4.228 112.42,43.17 112.65,42.83 112.78,42.71 113.07,42.42 v1(113.56,42.25)
M_A_DQ49: length 86.5
  TOP w0.079: U3.P5 128.91,107.49 129.2,107.2 129.64,107.2 129.76,107.07 129.76,102.95 v1(129.75,102.96)
  TOP w0.102: JDIM2.229 114.07,43.92 113.43,43.28 v1(112.84,43.28)
  IN2 w0.079: 119.7,94.75 119.93,94.99 120.36,94.99 124.28,98.9 124.28,99.44 127.89,103.05 129.66,103.05 v1(129.75,102.96)
  IN2 w0.127: 119.7,94.75 115.31,90.36 115.31,74.37 110.41,69.48 110.41,68.67 110.15,68.4 109.97,68.4 109.74,68.62 109.56,68.62 109.38,68.44 109.38,68.27 109.61,68.04 109.61,67.86 109.36,67.61 108.98,67.61 108.87,67.49 108.87,67.13 108.99,67 109.36,67 109.49,66.87 109.49,66.21 109.36,66.08 108.99,66.08 108.87,65.96 108.87,63.26 107.19,61.58 107.19,59.14 107.05,59.01 107.05,49.2 112.84,43.41 v1(112.84,43.28)
  BOTTOM w0.102: v1(112.84,43.28) 112.92,43.28 113.2,43.56 113.2,43.69 113.05,43.84 112.89,43.84 112.79,43.94 112.79,44.14 112.89,44.24 113.17,44.24 113.42,44.49 JDIM4.224
M_A_DQ50: length 86.6
  TOP w0.089: U3.R4 129.2,106.84 128.88,107.16 v1(128.13,107.16)
  TOP w0.102: v1(116.66,43.26) 116.99,43.26 117.57,43.84 JDIM2.215
  IN2 w0.079: 126.56,98.51 126.72,98.67 126.87,98.67 130.85,102.66 130.85,103.68 130.02,104.51 130.02,106.73 129.6,107.16 v1(128.13,107.16)
  IN2 w0.127: 126.56,98.51 123.91,95.86 123.91,95.37 117.84,89.3 117.84,72.38 112.62,67.17 112.62,64.93 112.02,64.32 112.02,62.69 110.48,61.15 110.48,59.52 110.09,59.12 110.09,58.93 110.21,58.81 110.3,58.81 110.43,58.68 110.43,58.43 110.3,58.3 110.21,58.3 110.09,58.17 110.09,57.82 110.21,57.69 110.35,57.69 110.48,57.56 110.48,57.31 110.35,57.18 110.2,57.18 110.08,57.06 110.08,56.8 110.2,56.67 110.35,56.67 110.48,56.55 110.48,56.29 110.35,56.17 110.2,56.17 110.08,56.04 110.08,53.55 110.2,53.43 110.35,53.43 110.48,53.3 110.48,53.05 110.35,52.92 110.2,52.92 110.08,52.79 110.08,51.04 110.2,50.91 110.35,50.91 110.48,50.78 110.48,50.54 110.35,50.4 110.2,50.4 110.08,50.28 110.08,49.86 116.24,43.7 116.24,43.55 116.54,43.26 v1(116.66,43.26)
  BOTTOM w0.102: JDIM4.212 116.42,44.3 116.16,44.04 116.16,43.47 116.37,43.26 v1(116.66,43.26)
M_A_DQ51: length 86.1
  TOP w0.089: U3.P4 128.46,106.84 v1(128.13,106.51)
  TOP w0.102: v1(117.21,39.32) 117.21,39.31 117.57,38.95 117.57,38.41 117.32,38.17 JDIM2.216
  IN2 w0.079: v1(128.13,106.51) 129.32,105.32 129.32,103.93 130.34,102.91 130.34,102.75 126.69,99.1 126.21,99.1 126.09,98.98
  IN2 w0.127: v1(117.21,39.32) 117.71,39.83 117.71,40.93 116.61,42.03 116.47,42.03 115.53,42.97 115.53,43.4 109.36,49.57 109.36,59.84 109.46,59.94 109.46,61.13 111.31,62.98 111.31,66.95 117.13,72.77 117.13,89.59 122.58,95.05 122.58,95.34 126.09,98.85 126.09,98.98
  BOTTOM w0.102: JDIM4.211 116.67,38.88 117.12,39.32 v1(117.21,39.32)
M_A_DQ52: length 89.4
  TOP w0.079: U3.R5 129.58,107.49 129.91,107.15 129.91,104.47 130.46,103.92 v1(130.46,103.54)
  TOP w0.102: JDIM2.211 118.57,44.41 118.3,44.14 118.18,44.14 118.1,44.06 118.1,44.06 117.86,43.82 117.86,43.49 118.19,43.16 118.19,42.83 118,42.64 v1(116.74,42.64)
  IN2 w0.079: 126.28,98.68 126.48,98.88 126.75,98.88 130.7,102.83 130.7,103.06 130.63,103.12 130.41,103.12 130.28,103.25 130.28,103.36 v1(130.46,103.54)
  IN2 w0.127: 126.28,98.68 123.48,95.88 123.48,95.44 117.48,89.44 117.48,72.53 112.27,67.31 112.27,67.06 112.14,66.93 111.79,66.93 111.66,66.8 111.66,66.55 111.79,66.42 112.14,66.42 112.27,66.29 112.27,66.04 112.14,65.91 111.79,65.91 111.66,65.79 111.66,65.54 111.79,65.41 112.08,65.41 112.21,65.28 112.21,65.02 111.99,64.8 111.8,64.8 111.66,64.66 111.66,62.83 110.13,61.3 110.13,60.69 110.05,60.62 109.89,60.62 109.81,60.53 109.81,60.23 109.9,60.15 110.03,60.15 110.13,60.05 110.13,59.67 109.97,59.51 109.84,59.51 109.72,59.39 109.72,49.72 115.88,43.55 115.88,43.12 116.36,42.64 v1(116.74,42.64)
  BOTTOM w0.102: v1(116.74,42.64) 116.22,42.11 115.87,42.11 115.63,42.36 115.63,44.02 115.42,44.23 JDIM4.216
M_A_DQ53: length 84.2
  TOP w0.089: v1(128.13,105.15) 128.51,105.54 U3.P2
  TOP w0.102: v1(113.81,39.38) 113.83,39.38 114.32,38.88 JDIM2.228
  IN2 w0.079: v1(128.13,105.15) 127.46,104.12 127.25,103.69 126.8,103.11 125.56,101.51 123.56,99.52 123.56,98.91 120.02,95.37 119.58,95.37 119.36,95.15 119.17,95.15
  IN2 w0.127: 119.17,95.15 119.09,95.15 114.56,90.61 114.56,74.63 108.16,68.23 108.16,63.56 105.83,61.23 105.83,55.67 106.34,55.16 106.34,48.91 106.84,48.41 106.84,47.36 107.8,46.41 108.84,46.41 111.78,43.47 112.05,42.74 112.55,42.06 112.7,41.72 113.23,39.96 v1(113.81,39.38)
  BOTTOM w0.102: v1(113.81,39.38) 113.37,38.94 113.37,38.55 113.17,38.36 JDIM4.225
M_A_DQ54: length 86.4
  TOP w0.089: U3.R1 129.31,104.19 128.34,103.22 v1(128.34,101.62)
  TOP w0.102: v1(117.22,40.6) 117.28,40.54 117.4,40.54 118.32,39.61 JDIM2.212
  IN2 w0.079: v1(128.34,101.62) 128.47,101.75 128.6,101.75 128.78,101.57 128.78,101.49 126.6,99.3 126.09,99.3 122.14,95.36 122.14,95.11
  IN2 w0.127: 122.14,95.11 116.77,89.74 116.77,72.92 110.95,67.1 110.95,63.13 109.1,61.28 109.1,60.08 108.65,59.63 108.65,58.54 108.51,58.4 108.51,51.09 108.64,50.97 108.88,50.97 109.01,50.84 109.01,50.59 108.88,50.46 108.64,50.46 108.51,50.33 108.51,49.92 115.17,43.26 115.17,42.83 116.12,41.88 116.12,41.2 116.72,40.6 v1(117.22,40.6)
  BOTTOM w0.102: JDIM4.215 115.67,39.19 117.09,40.6 v1(117.22,40.6)
M_A_DQ55: length 85.7
  TOP w0.089: v1(128.11,104.21) 128.58,104.66 U3.P1
  TOP w0.102: v1(113.83,40.01) 114.43,40.01 115.52,38.92 115.52,38.51 115.32,38.32 JDIM2.224
  IN2 w0.079: v1(128.11,104.21) 127.76,103.85 127.76,103.31 123.93,99.48 123.93,98.9 120.19,95.16 119.61,95.16 119.38,94.93
  IN2 w0.127: 119.38,94.93 114.95,90.5 114.95,74.52 108.51,68.08 108.51,63.41 106.76,61.66 106.76,59.74 106.7,59.68 106.7,49.05 107.19,48.56 107.19,47.51 107.94,46.76 108.99,46.76 112.42,43.33 112.42,43 112.86,42.56 112.86,42.24 113.83,41.26 v1(113.83,40.01)
  BOTTOM w0.102: JDIM4.229 112.17,38.45 112.28,38.56 112.28,39.4 112.9,40.01 v1(113.83,40.01)
M_A_DQ56: length 99
  TOP w0.079: U3.M4 127.24,106.39 127.24,104.65 127.23,104.64 127.23,103.48 125.58,101.83 v1(125.18,101.83)
  TOP w0.102: JDIM2.237 112.07,43.98 v1(111.34,43.25)
  IN2 w0.079: v1(125.18,101.83) 125.18,101.44 123.9,100.15 122.71,100.15 122.27,100.59
  IN2 w0.127: v1(111.34,43.25) 111.34,43.29 108.67,45.97 107.62,45.97 106.41,47.18 106.41,47.89 104.64,49.65 104.64,51.72 104.39,51.98 103.81,51.98 102.42,53.37 102.42,55.13 102.94,55.65 104.19,55.65 105.4,56.87 105.4,61.41 106.55,62.56 106.55,64.29 106.71,64.45 106.92,64.45 107.06,64.31 107.06,63.71 107.22,63.54 107.48,63.54 107.72,63.79 107.72,68.41 114.1,74.79 114.1,90.77 114.32,90.99 114.32,93.21 114.45,93.34 114.99,93.34 115.15,93.49 115.15,93.72 115.02,93.85 114.45,93.85 114.32,93.97 114.32,94.23 114.45,94.35 114.99,94.35 115.15,94.51 115.15,94.74 115.02,94.86 114.45,94.86 114.32,94.99 114.32,95.24 114.45,95.37 114.99,95.37 115.13,95.51 115.13,95.75 115,95.88 114.45,95.88 114.32,96.01 114.32,100.61 116.59,102.88 119.99,102.88 122.27,100.59
  BOTTOM w0.102: v1(111.34,43.25) 110.91,43.69 110.91,44.12 111.42,44.64 JDIM4.232
M_A_DQ57: length 96.1
  TOP w0.089: v1(126.69,103.81) 126.8,103.91 U3.M1
  TOP w0.102: JDIM2.232 113.32,38.31 113.29,38.34 113.29,39.02 112.11,40.21 v1(111.83,40.21)
  IN2 w0.079: v1(126.69,103.81) 125.64,103.81 123.97,102.15 123.35,102.15
  IN2 w0.127: 123.35,102.15 122.32,102.15 120.52,103.94 116,103.94 113.26,101.2 113.26,91.43 113.04,91.21 113.04,75.23 106.66,68.85 106.66,67.31 105.48,66.14 105.48,63 104.73,62.25 104.09,62.25 103.48,61.64 103.48,61.03 103.61,60.9 103.61,57.84 102.51,56.73 101.35,55.57 101.35,52.93 103.57,50.7 103.57,49.21 104.23,48.55 104.23,47.61 106.97,44.87 108.26,44.87 110.16,42.97 110.16,42.29 111.83,40.62 v1(111.83,40.21)
  BOTTOM w0.102: JDIM4.237 110.17,38.93 110.47,39.23 111.04,39.67 v1(111.83,40.21)
M_A_DQ58: length 102
  TOP w0.089: U3.L4 125.74,106.51 v1(125.61,106.51)
  TOP w0.102: v1(108.6,40.06) 108.92,39.74 108.92,39.57 109.15,39.35 109.6,39.35 109.9,39.05 109.9,38.76 109.69,38.56 109.69,38.41 109.82,38.28 JDIM2.246
  IN2 w0.127: v1(108.6,40.06) 107.18,41.48 107.18,42.62 106.8,42.99 105.24,42.99 104.2,44.03 104.2,45.07 100.76,48.52 100.76,50.92 99.52,52.15 99.52,56.32 100.33,57.13 100.33,57.98 100.46,58.11 101.04,58.11 101.16,58.24 101.16,58.49 101.04,58.62 100.46,58.62 100.33,58.74 100.33,59 100.46,59.13 101.04,59.13 101.16,59.25 101.16,59.51 101.04,59.63 100.46,59.63 100.33,59.76 100.33,60.01 100.46,60.14 101.04,60.14 101.16,60.27 101.16,60.52 101.04,60.65 100.46,60.65 100.33,60.78 100.33,61.03 100.46,61.16 101.04,61.16 101.16,61.28 101.16,61.54 101.04,61.67 100.46,61.67 100.33,61.79 100.33,65.41 107.84,72.91 107.84,74.68 111.14,77.99 111.14,91.89 111.44,92.19 111.44,102.89 114.32,105.77 122.31,105.77 122.75,105.32 124.1,105.32 125.29,106.51 v1(125.61,106.51)
  BOTTOM w0.102: v1(108.6,40.06) 108.08,40.06 107.17,39.16 JDIM4.249
M_A_DQ59: length 98.8
  TOP w0.089: v1(125.61,105.21) 125.74,105.21 U3.L2
  TOP w0.102: JDIM2.245 110.07,44.05 109.5,43.48 109.5,42.34 109.24,42.08 108.91,42.08 v1(108.52,42.47)
  IN2 w0.127: v1(108.52,42.47) 107.86,42.47 106.98,43.35 106.43,43.35 101.11,48.66 101.11,51.06 99.88,52.3 99.88,56.17 101.61,57.9 101.61,62.16 101.49,62.29 100.82,62.29 100.69,62.41 100.69,62.67 100.82,62.8 101.49,62.8 101.61,62.92 101.61,63.18 101.49,63.3 100.82,63.3 100.69,63.43 100.69,63.68 100.82,63.81 101.49,63.81 101.61,63.94 101.61,64.19 101.49,64.32 100.82,64.32 100.69,64.45 100.69,64.7 101.13,65.14 101.31,65.14 101.63,64.83 101.79,64.83 102.13,65.17 102.13,65.5 101.64,65.98 101.64,66.17 108.19,72.73 108.19,74.54 111.5,77.84 111.5,91.74 111.8,92.04 111.8,101.8 115.41,105.42 122.09,105.42 122.6,104.9 124.24,104.9 124.68,105.34 125.49,105.34 v1(125.61,105.21)
  BOTTOM w0.102: JDIM4.250 106.92,43.81 108.27,42.47 v1(108.52,42.47)
M_A_DQ60: length 102.8
  TOP w0.079: U3.M5 127.4,106.88 127.4,103.32 125.23,101.15 v1(124.27,101.15)
  TOP w0.102: JDIM2.233 113.07,44.09 111.63,42.65 v1(111.55,42.65)
  IN2 w0.127: v1(111.55,42.65) 111.36,42.65 110.91,43.1 110.91,43.22 108.52,45.62 107.47,45.62 106.05,47.04 106.05,47.74 104.29,49.5 104.29,51 102.06,53.23 102.06,55.28 102.79,56.01 104.04,56.01 104.33,56.3 104.33,56.48 104.02,56.79 104.02,57.1 104.16,57.25 104.92,57.25 105.05,57.37 105.05,57.73 104.92,57.85 104.48,57.85 104.35,57.98 104.35,58.24 104.48,58.36 104.92,58.36 105.05,58.49 105.05,58.74 104.92,58.87 104.46,58.87 104.33,59 104.33,59.25 104.46,59.38 104.92,59.38 105.05,59.51 105.05,59.76 104.92,59.89 104.45,59.89 104.32,60.01 104.32,60.19 104.52,60.39 104.92,60.39 105.05,60.52 105.05,61.56 106.19,62.71 106.19,65.85 106.38,66.04 106.64,66.04 106.78,65.9 106.78,64.94 106.9,64.81 107.24,64.81 107.37,64.94 107.37,68.55 113.75,74.93 113.75,90.92 113.97,91.14 113.97,100.76 116.44,103.23 120.23,103.23 121.97,101.48 123.94,101.48 v1(124.27,101.15)
  BOTTOM w0.102: v1(111.55,42.65) 111.32,42.65 110.42,43.54 JDIM4.236
M_A_DQ61: length 96.7
  TOP w0.079: U3.M2 127.08,105.25 127.08,104.74 127.06,104.72 127.06,103.62 126.29,102.85 v1(125.82,102.85)
  TOP w0.102: JDIM2.236 112.32,39.13 111.98,39.47 v1(111.83,39.47)
  IN2 w0.127: v1(111.83,39.47) 112.05,39.25 112.39,39.25 112.59,39.45 112.59,40.36 110.54,42.4 110.54,43.09 108.37,45.26 107.08,45.26 104.59,47.75 104.59,48.69 103.93,49.35 103.93,50.85 101.7,53.08 101.7,55.42 103.97,57.69 103.97,59.86 103.97,59.87 103.97,60.34 103.97,60.35 103.97,60.58 104.18,60.8 104.18,60.99 103.98,61.19 103.98,61.37 104.16,61.55 104.34,61.55 104.35,61.54 104.53,61.54 105.84,62.86 105.84,65.99 106.27,66.43 106.89,66.43 107.01,66.55 107.01,68.7 113.39,75.08 113.39,91.06 113.61,91.29 113.61,101.05 116.15,103.59 120.37,103.59 122.12,101.84 124.05,101.84 125.25,103.04 125.62,103.04 v1(125.82,102.85)
  BOTTOM w0.102: v1(111.83,39.47) 111.17,38.82 JDIM4.233
M_A_DQ62: length 100.4
  TOP w0.089: v1(125.61,107.16) 125.74,107.16 U3.L5
  TOP w0.102: JDIM2.250 108.82,38.2 109.01,38.38 109.01,38.92 v1(108.58,39.35)
  IN2 w0.127: v1(125.61,107.16) 124.66,107.16 124.45,106.95 124.45,106.18 124.32,106.04 123.66,106.04 123.38,106.33 123.02,106.33 122.9,106.45 122.9,107.39 122.77,107.52 122.58,107.52 122.39,107.33 122.39,106.45 122.1,106.16 121.71,106.16 121.18,106.7 120.44,106.7 120.31,106.82 120.31,107.28 120.14,107.46 119.81,107.46 119.65,107.31 119.65,106.25 119.53,106.13 116.11,106.13 115.98,106.25 115.98,106.52 115.86,106.65 115.6,106.65 115.48,106.52 115.48,106.25 115.35,106.13 115.1,106.13 114.97,106.25 114.97,106.52 114.84,106.65 114.59,106.65 114.46,106.52 114.46,106.25 114.33,106.13 114.17,106.13 111.09,103.04 111.09,92.33 110.79,92.04 110.79,78.14 107.48,74.83 107.48,73.06 99.97,65.55 99.97,57.26 99.17,56.46 99.17,52 100.4,50.77 100.4,48.37 103.84,44.93 103.84,43.88 105.09,42.64 105.43,42.64 107.38,40.68 107.38,40.54 v1(108.58,39.35)
  BOTTOM w0.102: JDIM4.245 108.17,38.33 108.07,38.43 108.07,38.85 v1(108.58,39.35)
M_A_DQ63: length 97.4
  TOP w0.089: U3.L1 125.74,104.56 v1(125.61,104.56)
  TOP w0.102: JDIM2.249 109.07,43.34 108.81,43.07 v1(108.32,43.07)
  IN2 w0.127: v1(108.32,43.07) 107.77,43.07 107.06,43.77 106.51,43.77 102.97,47.31 102.97,47.31 101.47,48.81 101.47,51.21 100.23,52.44 100.23,56.02 101.97,57.76 101.97,64.19 103.03,65.25 103.03,65.43 102.31,66.16 102.31,66.34 102.49,66.52 102.67,66.52 103.39,65.79 103.57,65.79 103.75,65.97 103.75,66.15 103.03,66.87 103.03,67.05 103.21,67.23 103.38,67.23 104.11,66.51 104.29,66.51 104.47,66.69 104.47,66.87 103.74,67.59 103.74,67.77 103.92,67.95 104.1,67.95 104.83,67.23 105.01,67.23 105.19,67.41 105.19,67.59 104.46,68.31 104.46,68.49 104.64,68.67 104.9,68.67 105.08,68.49 105.26,68.49 105.43,68.66 105.43,68.84 105.21,69.06 105.21,69.24 108.55,72.58 108.55,74.39 111.88,77.72 111.88,91.62 112.15,91.89 112.15,101.66 115.56,105.06 121.8,105.06 122.34,104.52 124.38,104.52 124.73,104.86 125.31,104.86 v1(125.61,104.56)
  BOTTOM w0.102: JDIM4.246 107.92,44.47 108.63,43.76 108.63,43.37 v1(108.32,43.07)
M_A_DQSN0: length 100.3
  TOP w0.079: U3.BR5 159.49,106.97 159.31,106.97 159.22,107.06 159.22,107.22 159.41,107.41 159.73,107.41 159.92,107.22 161.04,107.22 161.11,107.15
  TOP w0.089: 161.11,107.15 161.11,107.15 161.17,107.1 161.51,107.1 161.8,106.81 161.8,106.52 161.67,106.4 161.55,106.4 v1(161.43,106.52)
  TOP w0.102: JDIM2.11 170.57,44.4 170.48,44.3 170.48,41.44 170.01,40.97 169.32,40.97 169.2,40.85 v1(169.2,40.79)
  IN2 w0.079: v1(161.43,106.52) 162.04,106.52 162.39,106.17 162.89,106.17 163.83,107.12 166.13,107.12 166.17,107.16
  IN2 w0.127: v1(169.2,40.79) 169.37,40.97 169.77,40.97 170.29,41.48 170.29,42.75 170.7,43.16 170.7,43.74 173.76,46.8 173.76,50.52 176.42,53.18 176.42,55.29 171.25,60.45 171.25,67.58 170.75,68.09 169.77,68.09 169.51,68.35 169.51,69.33 167.54,71.3 167.54,90.5 172.78,95.75 172.78,102.25 167.87,107.16 166.17,107.16
  BOTTOM w0.102: JDIM4.11 168.67,38.15 168.54,38.28 168.54,40.69 168.35,40.87 168.35,41.15 168.46,41.25 169.16,41.25 169.27,41.13 169.27,40.87 v1(169.2,40.79)
M_A_DQSN1: length 93.3
  TOP w0.089: v1(157.77,103.13) 157.72,103.18 157.72,103.48 157.8,103.56 157.8,103.89 157.51,104.18 156.54,104.18 156.32,104.4 156.32,105.01 156.69,105.38 156.69,105.9 U3.BL3
  TOP w0.102: JDIM2.32 165.32,38.3 165.29,38.33 165.29,40.57 165.44,40.72 165.44,41.3 165.11,41.63 164.81,41.63 164.59,41.85 v1(164.59,41.91)
  IN2 w0.079: v1(157.77,103.13) 157.63,103.27 157.63,103.44 157.63,103.44 157.63,103.45 157.87,103.69 159.72,103.69 160.11,103.3 166.24,103.3 166.58,102.95 166.58,102.89 166.6,102.88
  IN2 w0.127: v1(164.59,41.91) 164.42,41.91 164.29,41.79 164.29,41.61 164.42,41.48 164.96,41.48 165.24,41.76 165.24,42.29 165.05,42.48 165.05,44.4 167.09,46.43 167.09,56.9 165,58.98 165,59.69 163.99,60.7 163.99,66.74 163.49,67.24 163.49,92.01 168.87,97.4 168.87,100.6 166.6,102.88
  BOTTOM w0.102: JDIM4.32 163.42,44.61 163.21,44.4 163.21,44.1 163.31,44 163.31,42.27 164.08,41.5 164.48,41.5 164.59,41.6 v1(164.59,41.91)
M_A_DQSN2: length 82.9
  TOP w0.079: U3.BG3 154.36,106.28 154.2,106.28 154.09,106.18 154.09,105.85 154.17,105.77 154.17,104.68 154.14,104.64
  TOP w0.089: 154.14,104.64 153.91,104.41 153.91,103.7 157.3,100.32 157.46,100.32 157.58,100.43 157.58,100.58 v1(157.47,100.69)
  TOP w0.102: v1(159.46,41) 159.65,41.18 159.88,41.18 159.96,41.1 160.31,41.1 160.56,41.35 160.56,41.67 160.16,42.07 160.16,43.59 159.98,43.77 159.98,44.33 160.07,44.42 JDIM2.53
  IN2 w0.127: v1(159.46,41) 159.29,41.18 159.07,41.18 158.81,41.44 158.81,43.27 159.1,43.56 159.1,44.4 158.81,44.69 158.81,45.79 161.62,48.6 161.62,57.13 159.78,58.98 159.78,68.3 158.62,69.45 158.62,95.27 157.34,96.56 157.34,100.32 157.47,100.45 v1(157.47,100.69)
  BOTTOM w0.102: JDIM4.53 158.17,38.2 158.01,38.36 158.01,40.19 159.27,41.46 159.45,41.46 159.55,41.35 159.55,41.09 v1(159.46,41)
M_A_DQSN3: length 81.7
  TOP w0.079: U3.BD3 151.84,106.29 151.63,106.29 151.54,106.19 151.54,106.09 151.65,105.97 151.65,104.59 151.35,104.28 151.35,102.78 152.6,101.53 152.72,101.53 152.81,101.62 v1(152.81,102.01)
  TOP w0.102: JDIM2.74 154.82,38.31 154.79,38.35 154.79,39.06 154.65,39.2 154.65,39.49 154.79,39.63 154.79,40.49 154.96,40.67 154.96,41.28 154.75,41.49 154.45,41.49 154.36,41.41 154.17,41.41 154.05,41.52 v1(154.05,41.62)
  IN2 w0.079: 153.07,97.89 153.06,97.91 153.06,97.97 152.87,98.15 152.87,100.64 152.7,100.82 152.7,101.47 152.81,101.58 v1(152.81,102.01)
  IN2 w0.127: v1(154.05,41.62) 154.05,41.3 154.18,41.17 154.39,41.17 154.68,41.46 154.68,41.75 154.47,41.96 154.47,42.5 153.41,43.56 153.41,50.73 154.54,51.85 154.54,54.74 154.17,55.11 154.17,57.19 154.95,57.97 154.95,93.72 153.23,95.44 153.23,97.73 153.07,97.89
  BOTTOM w0.102: v1(154.05,41.62) 154.05,41.24 153.94,41.13 153.59,41.13 153.19,41.52 153.19,42.8 152.79,43.19 152.79,44.48 152.92,44.61 JDIM4.74
M_A_DQSN4: length 86.6
  TOP w0.079: U3.AA3 133.89,105.9 133.89,104.76 133.66,104.52 133.66,100.35 133.93,100.08 133.93,99.85 v1(133.81,99.73)
  TOP w0.102: JDIM2.177 127.07,44.35 126.98,44.25 126.98,41.43 126.76,41.22 126.21,41.22 v1(125.98,40.99)
  IN2 w0.079: 132.89,98.09 132.91,98.09 133.47,98.65 133.64,98.65 134.14,99.15 134.14,99.7 134.07,99.77 133.85,99.77 v1(133.81,99.73)
  IN2 w0.127: 132.89,98.09 129.73,94.92 129.73,94.26 129.69,94.23 129.69,93.22 123.47,87 123.47,69.96 119.79,66.27 119.79,59.65 118.11,57.97 118.11,51.13 122.46,46.78 122.46,46.22 125.18,43.51 125.18,41.54 125.51,41.22 125.76,41.22 v1(125.98,40.99)
  BOTTOM w0.102: v1(125.98,40.99) 125.98,41.33 125.85,41.46 125.46,41.46 125.01,41.01 125.01,38.43 125.17,38.26 JDIM4.177
M_A_DQSN5: length 87.5
  TOP w0.079: v1(130.17,99.61) 130.32,99.76 130.32,99.99 130.22,100.09 130.22,102.71 131.38,103.87 131.38,105.9 U3.U3
  TOP w0.102: v1(120.75,41.73) 120.7,41.73 120.51,41.55 120.51,41.13 121.73,39.92 121.73,38.39 121.82,38.3 JDIM2.198
  IN2 w0.079: v1(130.17,99.61) 130.43,99.86 130.43,100.07 130.33,100.17 130.11,100.17 129.71,99.77 129.71,99.19 126.14,95.62 126.14,94.59 125.85,94.29 125.85,94.23
  IN2 w0.127: 125.85,94.23 120.01,88.39 120.01,71.48 115.61,67.08 115.61,63.63 115.13,63.15 115.13,60.85 113.14,58.85 113.14,51.05 113.26,50.93 113.26,49.84 118.78,44.31 119.05,44.31 120.51,42.85 120.51,41.86 120.64,41.73 v1(120.75,41.73)
  BOTTOM w0.102: JDIM4.198 119.92,44.6 119.76,44.44 119.76,43.69 119.48,43.41 119.48,43.07 119.57,42.98 119.72,42.98 119.95,43.21 120.32,43.21 120.54,42.99 120.54,41.94 v1(120.75,41.73)
M_A_DQSN6: length 89
  TOP w0.079: U3.P3 128.85,105.92 128.85,104.34 126.59,102.09 126.59,100.99 126.95,100.63 v1(126.95,100.25)
  TOP w0.102: v1(115.83,40.87) 115.71,41 115.71,41.62 116.25,42.16 116.25,42.59 116.14,42.69 116.14,43.84 116.34,44.03 116.34,44.26 116.57,44.5 JDIM2.219
  IN2 w0.079: v1(126.95,100.25) 127.08,100.25 127.15,100.33 127.15,100.45 127.04,100.56 127.04,100.61 126.93,100.72 126.77,100.72 125.22,99.18 125.22,98.88 120.6,94.26 120.6,94.23
  IN2 w0.127: 120.6,94.23 120.6,94.2 116.33,89.93 116.33,73.13 110.52,67.32 110.52,63.34 108.22,61.04 108.22,58.72 108.08,58.58 108.08,49.66 114.74,43.01 114.74,42.64 115.59,41.79 115.59,41 115.72,40.87 v1(115.83,40.87)
  BOTTOM w0.102: JDIM4.219 114.67,38.19 114.51,38.36 114.51,38.72 114.75,38.96 114.75,39.25 114.52,39.47 114.52,39.61 114.62,39.7 114.88,39.7 115.01,39.57 115.4,39.57 115.62,39.79 115.62,40.77 115.72,40.87 v1(115.83,40.87)
M_A_DQSN7: length 102.2
  TOP w0.079: v1(124.59,103.89) 124.47,103.76 124.47,103.57 124.62,103.42 125.27,103.42 126.35,104.51 126.35,105.84 126.47,105.96 126.47,106.08 126.34,106.22 126.09,106.22 U3.L3
  TOP w0.102: JDIM2.240 111.32,38.29 111.37,38.34 111.37,39.5 111.12,39.76 111.12,40.07 111.37,40.33 111.37,40.92 111.12,41.18 110.75,41.18 110.43,40.85 109.95,40.85 109.85,40.95 v1(109.85,41.08)
  IN2 w0.079: v1(124.59,103.89) 124.53,103.89 124.46,103.83 124.46,103.55 124.58,103.43 124.58,103.11 123.91,102.44 123.33,102.44 122.79,102.97 122.74,102.97 122.72,102.98
  IN2 w0.127: v1(109.85,41.08) 109.91,41.02 109.91,40.84 109.76,40.69 109.56,40.69 109.25,40.99 109.25,43.2 108.01,44.44 106.79,44.44 102.86,48.37 102.86,50.77 100.91,52.72 100.91,55.74 102.64,57.48 102.64,63.91 106.23,67.49 106.23,69.03 112.55,75.35 112.55,91.34 112.83,91.61 112.83,101.38 115.82,104.37 121.33,104.37 122.72,102.98
  BOTTOM w0.102: v1(109.85,41.08) 109.91,41.02 109.91,40.83 109.74,40.67 109.49,40.67 109.24,40.92 109.24,44.38 109.42,44.57 JDIM4.240
M_A_DQSN8: length 83.4
  TOP w0.079: v1(150.48,99.17) 150.55,99.17 150.68,99.04 150.68,98.87 150.5,98.68 150.2,98.68 149.15,99.73 149.15,104.36 149.14,104.37 149.14,106.11 149.22,106.19 U3.BA3
  TOP w0.102: JDIM2.95 149.57,44.41 149.5,44.34 149.5,41.35 149.17,41.02 148.95,41.02 v1(148.58,40.66)
  IN3 w0.127: v1(150.48,99.17) 151.48,99.17 153.06,97.58 153.06,77.59 154.88,75.78 154.88,60.01 154.68,59.81 154.68,55.06 154.81,54.93 154.81,52.15 151.47,48.81 151.47,46.35 149.5,44.38 149.5,41.46 148.89,40.85 148.77,40.85 v1(148.58,40.66)
  BOTTOM w0.102: JDIM4.95 147.67,38.26 147.54,38.4 147.54,38.88 147.61,38.96 147.61,40.96 147.84,41.19 148.44,41.19 148.58,41.05 v1(148.58,40.66)
M_A_DQSP0: length 100.3
  TOP w0.079: 161.18,107.33 161.13,107.38 159.99,107.38 159.8,107.57 159.34,107.57 159.03,107.26 U3.BP5
  TOP w0.089: v1(161.93,106.09) 161.93,106.4 161.97,106.45 161.97,106.88 161.58,107.27 161.24,107.27 161.18,107.33
  TOP w0.102: JDIM2.13 170.07,44.5 170.27,44.3 170.27,41.52 169.93,41.18 169.32,41.18 169.18,41.32 169.18,41.55 v1(169.27,41.64)
  IN2 w0.079: v1(161.93,106.09) 162.25,106.09 162.33,106.02 162.95,106.02 163.9,106.97 166.15,106.97 166.19,106.92
  IN2 w0.127: 166.19,106.92 167.77,106.92 172.54,102.15 172.54,95.85 167.3,90.6 167.3,71.2 169.27,69.23 169.27,68.25 169.67,67.85 170.65,67.85 171.01,67.48 171.01,60.35 176.18,55.19 176.18,53.28 173.52,50.62 173.52,46.9 170.46,43.84 170.46,43.26 170.05,42.85 170.05,41.58 169.67,41.21 168.75,41.21 168.64,41.32 168.64,41.51 168.77,41.64 v1(169.27,41.64)
  BOTTOM w0.102: v1(169.27,41.64) 169.27,41.56 169.17,41.46 168.38,41.46 168.15,41.23 168.15,40.79 168.34,40.6 168.34,38.36 168.17,38.2 JDIM4.13
M_A_DQSP1: length 93.4
  TOP w0.089: v1(157.28,103.56) 157.34,103.49 157.47,103.49 157.62,103.65 157.62,103.82 157.44,104 156.47,104 156.14,104.33 156.14,105.09 156.51,105.46 156.51,106.04 156.37,106.19 U3.BK3
  TOP w0.102: v1(164.5,41.05) 164.5,41.29 164.64,41.43 165.03,41.43 165.24,41.21 165.24,40.81 165.09,40.66 165.09,38.37 164.99,38.27 164.93,38.27 164.82,38.17 JDIM2.34
  IN2 w0.079: v1(157.28,103.56) 157.52,103.56 157.81,103.85 159.79,103.85 160.18,103.46 166.3,103.46 166.69,103.06 166.75,103.06 166.77,103.05
  IN2 w0.127: 166.77,103.05 169.11,100.7 169.11,97.3 163.73,91.91 163.73,67.34 164.23,66.84 164.23,60.8 165.24,59.79 165.24,59.08 167.33,57 167.33,46.33 165.3,44.3 165.3,42.58 165.48,42.39 165.48,41.66 165.06,41.24 164.68,41.24 v1(164.5,41.05)
  BOTTOM w0.102: JDIM4.34 162.92,44.58 163.01,44.49 163.01,44.02 163.11,43.92 163.11,42.19 164,41.3 164.4,41.3 164.5,41.2 v1(164.5,41.05)
M_A_DQSP2: length 83
  TOP w0.079: U3.BF3 153.92,105.99 153.94,105.97 153.94,105.78 154.02,105.7 154.02,104.77 153.96,104.72
  TOP w0.089: v1(157.94,100.22) 157.62,100.22 157.54,100.14 157.22,100.14 153.73,103.63 153.73,104.49 153.96,104.72
  TOP w0.102: v1(159.55,41.9) 159.55,41.5 159.66,41.39 159.99,41.39 160.08,41.3 160.23,41.3 160.36,41.43 160.36,41.59 159.96,41.99 159.96,43.51 159.78,43.68 159.78,44.28 159.57,44.49 JDIM2.55
  IN2 w0.127: v1(157.94,100.22) 157.85,100.31 157.67,100.31 157.58,100.22 157.58,96.66 158.87,95.37 158.87,69.55 160.02,68.4 160.02,59.08 161.86,57.23 161.86,48.5 159.05,45.69 159.05,44.79 159.34,44.5 159.34,43.46 159.05,43.17 159.05,41.54 159.17,41.42 159.44,41.42 159.63,41.61 159.63,41.82 v1(159.55,41.9)
  BOTTOM w0.102: v1(159.55,41.9) 159.55,41.83 159.38,41.66 159.19,41.66 157.81,40.28 157.81,38.34 157.67,38.21 JDIM4.55
M_A_DQSP3: length 81.7
  TOP w0.079: v1(153.27,101.55) 153.21,101.61 153.03,101.61 152.78,101.37 152.53,101.37 151.18,102.72 151.18,104.35 151.5,104.67 151.5,105.89 151.21,106.18 U3.BC3
  TOP w0.102: JDIM2.76 154.32,38.21 154.59,38.47 154.59,38.98 154.45,39.12 154.45,39.58 154.59,39.72 154.59,40.58 154.76,40.75 154.76,41.19 154.67,41.29 154.53,41.29 154.45,41.2 154.19,41.2 154.05,41.06 v1(154.05,40.72)
  IN2 w0.079: v1(153.27,101.55) 153,101.55 152.85,101.4 152.85,100.88 153.03,100.71 153.03,98.21 153.17,98.08 153.23,98.08 153.24,98.06
  IN2 w0.127: 153.24,98.06 153.48,97.83 153.48,95.54 155.2,93.82 155.2,57.87 154.41,57.09 154.41,55.21 154.78,54.84 154.78,51.75 153.65,50.63 153.65,43.66 154.71,42.6 154.71,42.06 154.92,41.85 154.92,41.36 154.48,40.93 154.26,40.93 v1(154.05,40.72)
  BOTTOM w0.102: v1(154.05,40.72) 153.85,40.92 153.5,40.92 152.99,41.44 152.99,42.71 152.59,43.11 152.59,44.44 152.42,44.6 JDIM4.76
M_A_DQSP4: length 86.6
  TOP w0.079: U3.AB3 134.29,106.24 134.09,106.24 134,106.16 134,106.01 134.05,105.96 134.05,104.69 133.82,104.46 133.82,100.41 134.07,100.16 v1(134.29,100.16)
  TOP w0.102: JDIM2.179 126.57,44.41 126.77,44.22 126.77,41.52 126.68,41.42 126.2,41.42 125.96,41.66 v1(125.96,41.93)
  IN2 w0.079: 133.04,97.95 133.04,97.95 133.04,97.99 133.54,98.49 133.7,98.49 134.3,99.08 134.3,99.77 134.21,99.86 134.21,100.08 v1(134.29,100.16)
  IN2 w0.127: 133.04,97.95 129.93,94.84 129.93,93.12 123.72,86.9 123.72,69.86 120.03,66.17 120.03,59.55 118.35,57.87 118.35,51.23 122.7,46.88 122.7,46.32 125.42,43.61 125.42,41.64 125.61,41.46 125.83,41.46 125.99,41.61 125.99,41.91 v1(125.96,41.93)
  BOTTOM w0.102: v1(125.96,41.93) 125.69,41.66 125.37,41.66 124.8,41.1 124.8,38.38 124.67,38.25 JDIM4.179
M_A_DQSP5: length 87.6
  TOP w0.079: v1(130.78,100.27) 130.57,100.07 130.47,100.07 130.38,100.16 130.38,102.65 131.53,103.8 131.53,106.11 131.61,106.19 U3.V3
  TOP w0.102: JDIM2.200 121.32,38.2 121.52,38.39 121.52,39.84 120.31,41.05 120.31,41.58 120.16,41.73 v1(120.1,41.73)
  IN2 w0.079: 125.65,94.37 125.7,94.37 125.98,94.65 125.98,95.68 129.56,99.26 129.56,99.84 130.04,100.32 130.4,100.32 130.45,100.27 v1(130.78,100.27)
  IN2 w0.127: 125.65,94.37 119.77,88.49 119.77,71.58 115.37,67.18 115.37,63.73 114.89,63.25 114.89,60.95 112.89,58.95 112.89,50.95 113.01,50.83 113.01,49.74 118.68,44.07 118.95,44.07 120.27,42.75 120.27,41.9 v1(120.1,41.73)
  BOTTOM w0.102: v1(120.1,41.73) 120.17,41.73 120.34,41.9 120.34,42.9 120.23,43.01 120.03,43.01 119.8,42.78 119.49,42.78 119.28,42.99 119.28,43.5 119.56,43.78 119.56,44.48 119.42,44.61 JDIM4.200
M_A_DQSP6: length 89
  TOP w0.079: v1(127.41,100.72) 127.08,100.72 126.75,101.05 126.75,102.02 129,104.28 129,106.11 129.08,106.19 U3.R3
  TOP w0.102: v1(115.19,40.87) 115.5,41.19 115.5,41.7 116.04,42.25 116.04,42.5 115.94,42.61 115.94,43.92 116.13,44.11 116.13,44.34 116.07,44.4 JDIM2.221
  IN2 w0.079: v1(127.41,100.72) 127.15,100.72 126.99,100.88 126.71,100.88 125.07,99.24 125.07,98.94 120.53,94.41 120.47,94.41 120.43,94.37
  IN2 w0.127: v1(115.19,40.87) 115.35,41.04 115.35,41.69 114.5,42.54 114.5,42.91 107.84,49.56 107.84,58.68 107.97,58.82 107.97,61.14 110.28,63.44 110.28,67.42 116.09,73.23 116.09,90.03 120.43,94.37
  BOTTOM w0.102: JDIM4.221 114.17,38.21 114.3,38.33 114.3,38.8 114.54,39.04 114.54,39.16 114.32,39.38 114.32,39.69 114.53,39.91 114.96,39.91 115.1,39.77 115.31,39.77 115.41,39.87 115.41,40.77 115.31,40.87 v1(115.19,40.87)
M_A_DQSP7: length 102.2
  TOP w0.079: U3.M3 126.63,106.02 126.63,105.89 126.51,105.78 126.51,104.43 125.34,103.25 124.55,103.25 124.34,103.46 v1(124.1,103.46)
  TOP w0.102: v1(109.85,40.23) 109.79,40.28 109.79,40.49 109.95,40.65 110.51,40.65 110.84,40.97 111.04,40.97 111.17,40.84 111.17,40.41 110.91,40.15 110.91,39.68 111.17,39.42 111.17,38.44 110.82,38.1 JDIM2.242
  IN2 w0.079: v1(124.1,103.46) 124.32,103.46 124.42,103.36 124.42,103.17 123.85,102.6 123.39,102.6 122.9,103.09 122.9,103.15 122.89,103.15
  IN2 w0.127: 122.89,103.15 121.43,104.62 115.72,104.62 112.58,101.48 112.58,91.71 112.31,91.44 112.31,75.45 105.98,69.13 105.98,67.59 102.4,64.01 102.4,57.58 100.67,55.84 100.67,52.62 102.62,50.67 102.62,48.27 106.69,44.2 107.91,44.2 109.01,43.1 109.01,40.89 109.46,40.45 109.63,40.45 v1(109.85,40.23)
  BOTTOM w0.102: JDIM4.242 108.92,44.51 109.03,44.4 109.03,40.84 109.41,40.46 109.69,40.46 109.85,40.31 v1(109.85,40.23)
M_A_DQSP8: length 83.5
  TOP w0.079: U3.AY3 148.98,105.9 148.98,99.68 150.13,98.53 150.56,98.53 150.66,98.62 v1(151.02,98.62)
  TOP w0.102: v1(148.58,41.69) 148.55,41.67 148.55,41.37 148.69,41.23 149.09,41.23 149.3,41.44 149.3,44.28 149.07,44.5 JDIM2.97
  IN3 w0.127: v1(148.58,41.69) 148.41,41.69 148.17,41.45 148.17,41.22 148.3,41.09 148.79,41.09 149.26,41.56 149.26,44.48 151.23,46.45 151.23,48.91 154.57,52.25 154.57,54.83 154.44,54.96 154.44,59.91 154.64,60.11 154.64,75.68 152.82,77.49 152.82,97.48 151.38,98.93 151.15,98.93 151.02,98.8 v1(151.02,98.62)
  BOTTOM w0.102: v1(148.58,41.69) 148.28,41.39 147.76,41.39 147.41,41.05 147.41,39.04 147.34,38.97 147.34,38.32 147.17,38.16 JDIM4.97
M_A_ODT0: length 77.7
  TOP w0.079: v1(137.77,99) 137.43,98.66 136.74,98.66 v1(135.73,99.67) 135.73,103.9 135.62,104.01 135.62,105.75 136.06,106.19 U3.AD3
  TOP w0.102: JDIM2.155 132.57,46.43 131.57,47.43 130.89,47.43 130.52,47.79 129.1,47.79 v1(128.96,47.65)
  IN2 w0.079: 137.39,97.09 137.39,98.23 137.88,98.71 137.88,98.9 v1(137.77,99)
  IN2 w0.14: 137.39,97.09 135.12,94.81 135.12,90.99 128.94,84.81 128.94,65.16 128.46,64.68 128.46,63.86 128.3,63.71 128.05,63.71 127.87,63.52 127.87,63.28 128.12,63.03 128.31,63.03 128.46,62.88 128.46,60.65 128.15,60.35 128.15,60.13 128.46,59.82 128.46,59.29 128.34,59.17 128.14,59.17 127.66,59.64 127.45,59.64 127.22,59.41 127.22,59.19 127.82,58.59 127.82,58.48 127.59,58.25 127.39,58.25 126.99,58.65 126.79,58.65 126.65,58.51 126.65,58.19 126.99,57.85 126.99,57.65 126.65,57.31 126.65,54.54 126.37,54.26 126.37,53.72 126.65,53.44 126.65,53 126.35,52.7 126.35,52.48 126.65,52.18 126.65,52.03 126.51,51.89 125.81,51.89 125.68,51.75 125.68,51.5 125.84,51.33 126.44,51.33 128.48,49.29 128.48,48.13 v1(128.96,47.65)
M_A_ODT1: length 78.4
  TOP w0.079: v1(137.74,102.42) 137.05,103.11 137.05,104.65 137.17,104.77 137.17,106.38 136.86,106.7 U3.AE4
  TOP w0.102: JDIM2.161 131.07,46.38 130.5,46.96 128.74,46.96 128.47,47.22 128.18,47.22 127.86,47.54 127.86,47.87 127.58,48.15 126.37,48.15 v1(125.8,47.58)
  IN2 w0.079: v1(137.74,102.42) 137.34,102.03 137.28,102.03 137.22,102.08 137.22,103.77 137.14,103.85 136.98,103.85 136.9,103.77 136.9,101.14 135.9,100.13 135.9,97.96 135.73,97.8
  IN2 w0.14: v1(125.8,47.58) 125.63,47.74 125.63,48.09 122.77,50.95 122.77,58.17 124.33,59.73 124.33,63.86 126.6,66.13 126.6,85.78 132.78,91.96 132.78,94.85 135.73,97.8
M_A_ODT2: length 78.5
  TOP w0.089: v1(137.75,101.77) 137.36,101.77 136.86,102.27 U3.AE1
  IN2 w0.079: v1(137.75,101.77) 137.72,101.81 137.25,101.81 137.11,101.66 137.11,101.05 136.11,100.05 136.11,97.88
  IN2 w0.14: v1(130.22,39.55) 129.89,39.55 129.75,39.68 129.75,41.38 129.57,41.57 129.57,42.71 129.15,43.13 129.15,44.79 128.04,45.9 127.13,45.9 126.5,46.52 126.5,47.84 123.21,51.14 123.21,57.98 124.77,59.54 124.77,63.68 127.04,65.95 127.04,85.59 133.23,91.77 133.23,94.89 136.11,97.77 136.11,97.88
  BOTTOM w0.102: v1(130.22,39.55) 130.77,38.99 130.77,38.51 130.67,38.41 JDIM4.155
M_A_ODT3: length 81.9
  TOP w0.089: v1(135.68,106.51) 136,106.84 U3.AD4
  IN2 w0.079: v1(135.68,106.51) 135.96,106.23 135.96,105.83 136.42,105.38 136.42,101.32 135.5,100.4 135.5,98.32
  IN2 w0.14: v1(129.1,41.25) 128.79,40.94 128.47,40.94 128.26,41.15 128.26,44.42 127.67,45.01 126.76,45.01 124.72,47.05 124.72,47.65 121.35,51.02 121.35,58.01 123.44,60.1 123.44,64.23 124.8,65.59 124.8,65.79 124.6,65.99 124.6,66.18 124.78,66.36 125.02,66.36 125.2,66.18 125.39,66.18 125.71,66.5 125.71,86.14 131.89,92.33 131.89,94.71 135.5,98.32
  BOTTOM w0.102: v1(129.1,41.25) 128.9,41.05 128.9,38.59 129.17,38.31 JDIM4.161
M_B_A0: length 73.3
  TOP w0.089: U3.AJ9 140.53,110.2 140.89,110.56 140.89,110.95 v1(140.99,111.04)
  TOP w0.102: JDIM1.144 137.32,51.19 137.05,51.46 136.13,51.46 135.48,52.12 135.48,54.14 v1(134.87,54.76)
  IN1 w0.079: 137.54,94.66 137.54,94.75 138.53,95.73 138.53,97.34 139.02,97.83 139.02,105.54 139.42,105.93 139.42,108.01 140.24,108.84 140.24,110.06 140.99,110.8 v1(140.99,111.04)
  IN1 w0.152: v1(134.87,54.76) 134.59,55.04 134.59,59.55 133.5,60.64 133.5,60.94 133.74,61.18 133.74,66.96 136.16,69.38 136.16,71.92 136.68,72.44 136.68,73.76 137.54,74.61 137.54,94.66
  BOTTOM w0.102: v1(134.87,54.76) 134.87,55.29 134.97,55.39 135.37,55.39 135.48,55.5 135.48,55.68 135.37,55.78 135.01,55.78 134.88,55.92 134.88,56.06 134.99,56.17 135.49,56.17 135.59,56.27 135.59,56.49 135.53,56.55 134.98,56.55 134.89,56.64 134.89,56.85 135.42,57.39 JDIM3.144
M_B_A1: length 73.9
  TOP w0.089: v1(140.7,107.84) 141,108.14 U3.AK6
  TOP w0.102: JDIM1.133 140.07,57.58 138.46,55.97 138.46,55.35 138.09,54.98 v1(137.29,54.98)
  IN1 w0.079: 139.5,96.18 139.5,96.63 139.76,96.9 139.76,99.92 139.69,100 139.69,104.66 140.09,105.05 140.09,107.22 v1(140.7,107.84)
  IN1 w0.152: v1(137.29,54.98) 137.29,55.08 136.83,55.55 136.83,55.6 136.58,55.85 136.58,56.87 136.8,57.09 136.8,60.54 135.68,61.65 135.68,66.15 136.04,66.5 136.25,66.5 136.5,66.25 136.71,66.25 136.96,66.51 136.96,66.72 136.72,66.97 136.72,67.18 136.97,67.44 137.18,67.44 137.43,67.19 137.65,67.19 137.9,67.44 137.9,67.66 137.65,67.9 137.65,68.12 138.44,68.91 138.44,69.13 138.18,69.38 138.18,69.6 138.42,69.84 138.67,69.84 138.99,69.51 139.26,69.51 139.5,69.75 139.5,70.45 139.34,70.6 138.46,70.6 138.31,70.76 138.31,71.11 138.46,71.26 139.34,71.26 139.5,71.42 139.5,71.78 139.34,71.94 138.85,71.94 138.7,72.09 138.7,72.44 138.85,72.59 139.34,72.59 139.5,72.74 139.5,72.97 139.23,73.24 139.23,73.56 139.5,73.82 139.5,86.46 140.58,87.54 140.58,88.89 139.5,89.98 139.5,96.18
  BOTTOM w0.102: v1(137.29,54.98) 137.68,54.59 137.68,51.64 138.17,51.15 JDIM3.133
M_B_A2: length 79.9
  TOP w0.089: U3.AK5 140.97,107.49 v1(140.68,107.19)
  TOP w0.102: JDIM1.132 140.32,51.55 139.65,52.22 139.27,52.22 136.88,54.62 136.88,55.37 v1(137.29,55.78)
  IN1 w0.079: 139.99,96.62 140.24,96.86 140.24,98.19 139.96,98.46 139.96,100.04 139.86,100.14 139.86,104.57 140.25,104.97 140.25,106.77 v1(140.68,107.19)
  IN1 w0.152: v1(137.29,55.78) 137.29,55.79 137.29,55.84 137.08,56.06 137.08,56.67 137.29,56.88 137.29,60.74 136.18,61.86 136.18,65.02 138.99,67.84 138.99,68.05 138.75,68.3 138.75,68.51 138.96,68.73 139.18,68.73 139.43,68.48 139.64,68.48 139.99,68.83 139.99,69.25 140.14,69.4 140.26,69.4 140.41,69.56 140.41,69.86 140.26,70.01 140.14,70.01 139.99,70.17 139.99,70.47 140.14,70.62 140.26,70.62 140.41,70.78 140.41,71.08 140.26,71.23 140.14,71.23 139.99,71.39 139.99,71.69 140.14,71.84 140.26,71.84 140.41,71.99 140.41,72.3 140.26,72.45 140.14,72.45 139.99,72.6 139.99,72.91 140.14,73.06 140.26,73.06 140.41,73.21 140.41,73.52 140.26,73.67 140.14,73.67 139.99,73.82 139.99,74.13 140.14,74.28 140.26,74.28 140.41,74.43 140.41,74.74 140.26,74.89 140.14,74.89 139.99,75.04 139.99,75.35 140.14,75.5 140.26,75.5 140.41,75.65 140.41,75.96 140.26,76.11 140.14,76.11 139.99,76.26 139.99,76.57 140.14,76.72 140.26,76.72 140.41,76.87 140.41,77.18 140.26,77.33 140.14,77.33 139.99,77.48 139.99,77.79 140.14,77.94 140.26,77.94 140.41,78.09 140.41,78.4 140.26,78.55 140.14,78.55 139.99,78.7 139.99,79.01 140.14,79.16 140.26,79.16 140.41,79.31 140.41,79.61 140.26,79.77 140.14,79.77 139.99,79.92 139.99,80.22 140.14,80.38 140.26,80.38 140.41,80.53 140.41,80.83 140.26,80.99 140.14,80.99 139.99,81.14 139.99,81.44 140.14,81.6 140.26,81.6 140.41,81.75 140.41,82.05 140.26,82.21 140.14,82.21 139.99,82.36 139.99,82.66 140.14,82.82 140.26,82.82 140.41,82.97 140.41,83.27 140.26,83.42 140.14,83.42 139.99,83.58 139.99,83.88 140.14,84.03 140.26,84.03 140.41,84.19 140.41,84.54 140.28,84.66 140.1,84.66 139.99,84.77 139.99,85.06 140.17,85.24 140.68,85.24 140.99,85.56 140.99,85.78 140.84,85.93 140.25,85.93 140.1,86.09 140.1,86.36 140.28,86.54 140.72,86.54 141.08,86.9 141.08,89.1 140.39,89.79 140.39,90.29 140.24,90.44 140.14,90.44 139.99,90.6 139.99,90.97 140.14,91.12 140.24,91.12 140.41,91.29 140.41,91.59 140.26,91.75 140.16,91.75 139.99,91.91 139.99,96.62
  BOTTOM w0.102: v1(137.29,55.78) 137.66,55.78 137.76,55.68 137.76,54.8 137.91,54.65 138.58,54.65 138.72,54.78 138.72,55.11 138.62,55.21 138.43,55.21 138.33,55.32 138.33,55.52 138.43,55.62 138.62,55.62 138.72,55.72 138.72,55.93 138.6,56.04 138.42,56.04 138.31,56.14 138.31,56.34 138.42,56.45 138.62,56.45 138.72,56.55 138.72,56.81 138.42,57.1 JDIM3.132
M_B_A3: length 76.9
  TOP w0.089: U3.AL5 142.15,107.22 v1(142.35,107.22)
  TOP w0.102: v1(139.05,53.8) 138.52,53.8 138.25,54.07 138.25,54.61 138.83,55.2 138.83,55.84 140.57,57.58 JDIM1.131
  IN1 w0.079: 141.77,96.22 141.67,96.33 141.67,104.65 142.35,105.33 v1(142.35,107.22)
  IN1 w0.152: 141.77,96.22 143.27,94.72 143.27,91.53 143.8,91 143.8,90.22 143.96,90.06 144.54,90.06 144.68,89.93 144.68,84.67 144.53,84.51 143.95,84.51 143.8,84.36 143.8,80.42 143.65,80.27 143.39,80.27 143.27,80.15 143.27,79.65 143.42,79.5 143.65,79.5 143.8,79.35 143.8,78.99 143.65,78.84 143.42,78.84 143.27,78.69 143.27,78.33 143.42,78.18 143.65,78.18 143.8,78.03 143.8,77.67 143.65,77.52 143.42,77.52 143.27,77.37 143.27,77.01 143.42,76.86 143.65,76.86 143.8,76.71 143.8,76.35 143.65,76.2 143.42,76.2 143.27,76.05 143.27,75.69 143.42,75.54 143.65,75.54 143.8,75.39 143.8,75.03 143.65,74.88 143.42,74.88 143.27,74.73 143.27,74.37 143.42,74.22 143.65,74.22 143.8,74.07 143.8,73.71 143.65,73.56 143.42,73.56 143.27,73.41 143.27,73.05 143.42,72.9 143.65,72.9 143.8,72.75 143.8,72.39 143.65,72.24 143.42,72.24 143.27,72.09 143.27,71.73 143.42,71.58 143.65,71.58 143.8,71.43 143.8,71.07 143.65,70.92 143.42,70.92 143.27,70.76 143.27,70.41 143.42,70.26 143.65,70.26 143.8,70.1 143.8,69.75 143.65,69.6 143.42,69.6 143.27,69.44 143.27,69.1 143.54,68.83 143.54,68.45 141.45,66.35 141.45,63.65 139.74,61.94 139.74,61.68 139.24,61.18 139.24,53.99 v1(139.05,53.8)
  BOTTOM w0.102: JDIM3.131 138.67,51.64 140.09,53.06 140.09,54.16 139.75,54.51 139.3,54.51 139.05,54.26 v1(139.05,53.8)
M_B_A4: length 77.8
  TOP w0.089: v1(142.36,107.87) 142.09,108.14 U3.AL6
  TOP w0.102: v1(139.3,53.2) 139.79,53.2 139.89,53.1 139.89,52.53 140.01,52.42 140.17,52.42 140.3,52.55 140.3,53.14 140.42,53.26 140.72,53.26 141.15,52.83 141.15,51.91 141.32,51.73 JDIM1.128
  IN1 w0.079: 141.71,95.81 141.49,96.03 141.49,104.71 141.92,105.15 141.92,107.43 v1(142.36,107.87)
  IN1 w0.152: 141.71,95.81 141.89,95.63 141.89,95.23 142.04,95.08 142.49,95.08 142.81,94.76 142.81,94.54 142.6,94.33 142.41,94.33 142.28,94.2 142.28,93.89 142.78,93.39 142.78,90.79 142.93,90.64 143.15,90.64 143.31,90.49 143.31,89.89 143.62,89.57 143.9,89.57 144.18,89.29 144.18,88.81 144.03,88.66 143.64,88.66 143.48,88.51 143.48,88.21 143.64,88.05 144.01,88.05 144.18,87.88 144.18,85.16 144.03,85.01 143.47,85.01 143.03,84.57 142.86,84.4 142.86,84.19 143.01,84.03 143.15,84.03 143.31,83.88 143.31,83.53 143.15,83.37 142.93,83.37 142.78,83.22 142.78,82.87 142.93,82.71 143.15,82.71 143.31,82.56 143.31,82.21 143.15,82.05 142.93,82.05 142.78,81.9 142.78,81.55 142.93,81.39 143.15,81.39 143.31,81.24 143.31,80.89 143.15,80.73 142.93,80.73 142.78,80.58 142.78,68.38 140.46,66.06 140.46,65.57 140.61,65.41 140.8,65.41 140.95,65.26 140.95,64.96 140.8,64.8 140.61,64.8 140.46,64.65 140.46,64.32 140.6,64.18 140.87,64.18 140.95,64.1 140.95,63.85 140.46,63.36 139.09,61.99 138.66,61.99 138.51,61.84 138.51,61.58 138.74,61.34 138.74,54.19 138.55,54 138.55,53.55 138.91,53.2 v1(139.3,53.2)
  BOTTOM w0.102: v1(139.3,53.2) 138.99,53.2 138.64,53.54 138.64,54.35 138.92,54.63 138.92,57.09 139.42,57.59 JDIM3.128
M_B_A5: length 74.8
  TOP w0.089: v1(143.17,107.81) 142.84,108.14 U3.AM6
  TOP w0.102: v1(140.73,54.58) 141.14,54.17 141.14,53.13 141.35,52.92 141.35,51.99 141.82,51.51 JDIM1.126
  IN1 w0.079: 141.97,96.56 141.87,96.66 141.87,104.6 142.37,105.1 142.76,105.5 142.76,107.41 v1(143.17,107.81)
  IN1 w0.152: v1(140.73,54.58) 141.63,53.68 141.63,52.65 141.23,52.26 140.25,52.26 139.94,52.57 139.94,53.51 139.75,53.69 139.75,58.67 139.9,58.82 140.08,58.82 140.23,58.97 140.23,59.33 140.08,59.48 139.9,59.48 139.75,59.63 139.75,60.99 140.23,61.47 140.23,61.73 142.69,64.19 142.69,66.9 144.3,68.5 144.3,83.5 145.17,84.37 145.17,90.32 144.9,90.6 144.45,90.6 144.3,90.75 144.3,91.2 143.77,91.73 143.77,94.76 141.97,96.56
  BOTTOM w0.102: JDIM3.126 139.92,57.61 139.36,57.04 139.36,55.7 140.49,54.58 v1(140.73,54.58)
