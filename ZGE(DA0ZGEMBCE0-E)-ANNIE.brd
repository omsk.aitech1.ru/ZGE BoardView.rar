# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Nets (continued)
9512_CSPSUM: PR256.1 PU24.22
9512_DAC: PC188.2 PC411.2 PR511.2 PU24.28
9512_EAP: PR275.1 PU24.29
9512_EN: PQ28.3 PR531.2 PR535.2 PU24.36
9512_EN_1: PC217.1 PD7.2 PQ31.2 PR320.1 PR332.2
9512_EN_S: PR219.1 PR222.1 PR225.2 PR228.2 PR231.2 PR234.2 PR237.2 PR240.2 PR531.1
9512_FB: PR260.2 PR262.2 PR281.1 PR284.2 PU24.31
9512_FBRTN: PC188.1 PC204.2 PC205.1 PC221.2 PC225.2 PR334.2 PR515.1 PR517.1 PU24.32
9512_IMON: PC414.1 PR273.1 PU24.25
9512_LPC: PR261.1 PR264.2 PU24.24
9512_PGOOD: PR312.1 PR527.2 PU24.38
9512_PSI: PR308.1 PR311.1 PR532.2 PU24.37
9512_PWM1: PR330.2 PR548.2 PU24.11
9512_PWM1_S: PR548.1 PU21.34
9512_PWM2: PR328.2 PR541.2 PU24.10
9512_PWM2_S: PR328.1 PU20.34
9512_PWM3: PR327.2 PR542.2 PU24.9
9512_PWM3_S: PR327.1 PU19.34
9512_PWM4: PR326.2 PR543.2 PU24.8
9512_PWM4_S: PR326.1 PU18.34
9512_PWM5: PR325.2 PR544.2 PU24.7
9512_PWM5_S: PR325.1 PU17.34
9512_PWM6: PR324.2 PR545.2 PU24.6
9512_PWM6_S: PR324.1 PU16.34
9512_PWM7: PR323.2 PR546.2 PU24.5
9512_PWM7_S: PR323.1 PU15.34
9512_PWM8: PR322.2 PR547.2 PU24.4
9512_PWM8_S: PR322.1 PU14.34
9512_REFADJ: PR315.2 PU24.40
9512_REFIN: PC225.1 PR319.2 PR329.2 PU24.1
9512_REFOUT: PR278.1 PU24.23
9512_SCL: PR305.1 PU24.35
9512_SDA: PR297.1 PU24.34
9512_TSENSE: PR520.1 PU24.33
9512_VID: PR314.2 PU24.39
9512_VINMON: PR265.1 PR266.1 PU24.27
9512_VREF: PC223.1 PR317.2 PU24.2(VREF)
9619_BST1: PR216.1 PU21.33
9619_BST2: PR215.1 PU20.33
9619_BST3: PR210.1 PU19.33
9619_BST4: PR214.1 PU18.33
9619_BST5: PR213.1 PU17.33
9619_BST6: PR212.1 PU16.33
9619_BST7: PR211.1 PU15.33
9619_BST8: PR257.1 PU14.33
9619_PHASE1: PC403.2 PU21.32
9619_PHASE2: PC404.2 PU20.32
9619_PHASE3: PC402.2 PU19.32
9619_PHASE4: PC405.2 PU18.32
9619_PHASE5: PC406.2 PU17.32
9619_PHASE6: PC407.2 PU16.32
9619_PHASE7: PC408.2 PU15.32
9619_PHASE8: PC184.2 PU14.32
9619_SW1: PL18.1 PR173.2 PU21.10
9619_SW2: PL17.1 PR170.2 PU20.10
9619_SW3: PL16.1 PR169.2 PU19.10
9619_SW4: PL15.1 PR166.2 PU18.10
9619_SW5: PL14.1 PR165.2 PU17.10
9619_SW6: PL13.1 PR168.2 PU16.10
9619_SW7: PL12.1 PR167.2 PU15.10
9619_SW8: PL11.1 PR171.2 PU14.10
9619_VOS1: PR160.1 PU21.1
9619_VOS2: PR159.1 PU20.1
9619_VOS3: PR158.1 PU19.1
9619_VOS4: PR157.1 PU18.1
9619_VOS5: PR156.1 PU17.1
9619_VOS6: PR155.1 PU16.1
9619_VOS7: PR154.1 PU15.1
9619_VOS8: PR153.1 PU14.1
24780_ACDET: PR258.2 PR282.2 PR499.2 PU23.6
24780_ACDRV: PR270.2 PU23.4
24780_ACN: PC196.2 PC199.1 PR69.2 PU23.1
24780_ACP: PC196.1 PC200.2 PR70.2 PU23.2
24780_BATDRV: PR303.2 PU23.18
24780_BATSRC: PR175.2 PU23.17
24780_BM#: PR182.2 PU23.16
24780_BST: PR243.1 PU23.25
24780_CMPIN: PR488.1 PR489.2 PR492.1 PU23.13
24780_CMPIN_R: PR487.2 PR489.1 PR490.1
24780_CMPOUT: PR196.2 PR197.2 PU23.14
24780_CMSRC: PR269.2 PU23.3
24780_DH: PQ30.4 PU23.26
24780_DL: PQ27.4 PU23.23
24780_ILIM: PC158.2 PR174.1 PR181.1 PU23.21
24780_LX: PC183.1 PL20.1 PQ27.5 PQ30.1 PQ30.2 PQ30.3(S3) PR310.1 PU23.27
24780_SRN: PC145.2 PC146.2 PR180.2 PR286.1
24780_SRP: PC145.1 PC156.2 PR179.2 PR302.1
24780_VCC: PC186.1 PR259.1 PU23.28(VCC)
51225_CS1: PR398.1 PU28.1
51225_CS2: PR378.1 PU28.5
51225_DH1: PQ34.1 PU28.16
51225_DH2: PQ37.1 PU28.10
51225_DL1: PQ34.8 PU28.15
51225_DL2: PQ37.8 PU28.11
51225_EN1: PR403.1 PU28.20
51225_FB1: PR377.1 PR391.1 PU28.2
51225_FB2: PR379.1 PR380.2 PU28.4
51225_SW1: PC263.1 PL23.1 PQ34.9 PR423.1 PU28.18
51225_SW2: PC264.1 PL22.2 PQ37.9 PR422.1 PU28.8
51225_VBST1: PR409.2 PU28.17
51225_VBST2: PR410.1 PU28.9
51225_VIN: PC272.1 PR419.1 PU28.12
61087COMP: PR218.2 PU22.1
61087EN: PC159.2 PR185.1 PU22.3
61087FB: PR198.2 PR199.1 PU22.2
61087FREQ: PR208.2 PR251.1 PU22.9
61087SS: PC181.2 PU22.10
61087SW: PD3.2 PL19.2 PU22.6 PU22.7(SW#2)
81215_ALERT: PR17.1 PU2.41
81215_SCLK: PR13.2 PU2.42
81215_SDIO: PR14.1 PU2.40
+SMDDR_VREF_CHA_DIMM0_R: C729.1 R771.1 R778.1 R793.2
+SMDDR_VREF_CHB_DIMM0_R: C236.1 R205.2 R216.2 R224.1
+SPI_VCC: C320.1 C328.2 R319.2 R335.2 R340.1 R452.1 R456.2 U19.8
+TPVDD: CN19.4 D56.1 Q42.2 Q48.2 Q48.5 Q79.3 R465.1 R482.1 R502.2 R568.2 R570.2 R572.2
+USBPWR: C227.1 C234.1 CN14.1 CN14.2 CN14.3 U8.12(VOUT) U11.12(VOUT)
+USBPWR3: C439.2 C448.2 C454.2 C474.2 CN7.1(VBUS) D72.1 U26.12(VOUT)
+VREFCA_CHA_DIMM: C702.2 C705.2 C706.1 C709.2 C712.2 JDIM2.164 JDIM4.164 R730.2 R771.2
+VREFCA_CHB_DIMM: C175.2 C186.1 C197.1 C207.1 C210.2 JDIM1.164 JDIM3.164 R164.2 R205.1
+WL_VDD: C152.1 C159.1 C160.1 C164.1 C169.2 C288.1 C815.1 C822.2 C824.2 CN16.2 CN16.4 CN16.72 CN16.74 Q26.2 Q28.2 Q31.3 R184.2 R191.2 R204.2 R220.2 R265.1 R362.1
A0_DP: R29.2 R30.2 U39.11
A0_EDP: R115.2 R116.2 U41.11
A0_TBT: R794.2 R795.2 U10.11
A_DE: R470.1 R512.2 U43.9
A_EQ1: R927.2 R947.1 U43.18
A_EQ2: R929.2 R955.1 U43.19
ACIN: PR263.1 PR276.2 PR280.1 U18.72
ACPRESENT: R542.1 U14.BG42 U18.84
ACZ_BCLK: C442.2 R488.2 U14.BD11
ACZ_RST#: R496.2 U14.BE10
ACZ_SDIN0_R: R491.2 U14.BE11
ACZ_SDO: R492.2 R493.1 U14.BF12
ACZ_SPKR: D32.2 R1040.2 U14.AW29
ACZ_SYNC: R494.2 U14.BG13
ADDR0: R1131.1 U30.36
ADDR1: R1130.1 U30.35
ADOGND: C338.1 C343.1 C352.2 C355.1 C358.1 C360.2 C370.1 C371.1 C396.1 C409.1 C419.1 C420.2 C421.2 C424.2 C463.1 C850.1 C879.2 C880.2 CN17.1 CN17.10 R392.1 R400.1 R409.2 R427.2 R428.1 R431.1 R442.2 R443.2 R461.1 R926.1 R953.2 R954.2 R956.1 R969.2 R971.2 R992.1 R1002.1 R1003.2 U17.29 U17.40 U17.47
ADP_BOARD_ID: R257.2 U18.122
ADP_ID: PJ1.7 PQ54.2 PR500.2 PR516.1
AMP_MUTE#: D59.1(CATHODE) R1021.1 U18.108
AN_DPSRC_RBIAS_1: R766.2 U7.N6
AUD_AZACPU_SCLK: R313.2 U3.G27
AUD_AZACPU_SCLK_R: R313.1 U14.AM3
AUD_AZACPU_SDI: R61.2 U14.AN3
AUD_AZACPU_SDI_R: R61.1 U3.G29
AUD_AZACPU_SDO: R358.1 U14.AM2
AUD_AZACPU_SDO_R: R358.2 U3.G25
AUX_SRCN_TBT_C: C731.1 U7.W11
AUX_SRCP_TBT_C: C737.1 U7.Y11
B_DE: R471.1 R513.2 U43.8
B_EQ1: R930.2 R972.1 U43.20
B_EQ2: R928.2 R949.1 U43.17
BAT-V: PC189.1 PC190.1 PC191.1 PC192.1 PC195.1 PC412.2 PC413.1 PD6.2 PJ22.8 PJ22.9 PJ22.10 PR286.2 PR296.2
BATLED0#: CN8.16 D83.1 U18.29
BATLED1#: CN8.17 D82.1 R430.2
BATLOW#: R534.1 R738.1 U14.BF44
BBS_BIT1: R536.1 R546.2 U14.BE23
BEEP1: D32.1(CATHODE) D36.1(CATHODE) R293.2
BEEP2: C289.1 C321.2 R292.1 R293.1
BEEP3: C321.1 U17.15
BI: PJ22.7 PR505.2 R869.1
BI_GATE: C830.1 Q30.5 Q73.2 R262.1 R901.1 R912.2 SW2.3 SW2.4
BL#: Q9.2 Q9.3 R82.1
BL_ON: D14.2 Q7.3 Q9.6 R50.1 R86.1
BLON_EN: Q9.5 Q11.3 R87.1 R89.2 R91.2 R93.2
BLONCON: CN10.33 R49.2 R50.2
BOARD_ID0: R58.1 R1058.1 R1106.1 U14.BB20
BOARD_ID0_R: C54.1 CN10.31 R58.2
BOARD_ID1: R56.1 R1052.1 R1091.1 U14.BB16
BOARD_ID1_R: C53.1 CN10.32 R56.2
BOARD_ID2: R970.2 R991.1 U14.AN18
BOARD_ID3: R487.2 R544.1 R547.1 U14.BF14
BOARD_ID4: R1045.2 R1090.1 U14.AR18
BOARD_ID5: R548.2 R554.1 U14.BF17
BOARD_ID6: R497.2 R549.1 U14.BE17
BOARD_ID7: R1041.2 R1102.1 U14.AV34
BOARD_ID8: R1051.2 R1101.1 U14.AW32
BOARD_ID9: R1050.2 R1100.1 U14.BA33
BOARD_ID10: R539.2 R580.1 U14.BE34
BOARD_ID11: R1124.2 R1125.1 U14.BD34
BOARD_ID12: R578.2 R581.1 U14.BF35
BOARD_ID13: R545.2 R616.1 U14.BD38
BT_EN: CN16.54(W_DISABLE2#) R191.1 R374.1
BUFRST: TPG68.1 UG1.BF9
C_GPU_TBT_AUXN: C230.2 R213.2 U10.25
C_GPU_TBT_AUXP: C233.2 R212.2 U10.24
C_GPU_TBT_D0: C167.2 U10.9
C_GPU_TBT_D0#: C172.2 U10.10
C_GPU_TBT_D1: C182.2 U10.12
C_GPU_TBT_D1#: C187.2 U10.13
C_GPU_TBT_D2: C193.2 U10.15
C_GPU_TBT_D2#: C201.2 U10.16
C_GPU_TBT_D3: C203.2 U10.18
C_GPU_TBT_D3#: C208.2 U10.19
C_INT_DP_AUXN: C512.1 CN2.17 ESD1.2 ESD1.9 Q57.6 R650.2 R663.1 U39.25
C_INT_DP_AUXP: C521.1 CN2.15 ESD1.1 ESD1.10(NC#4) Q60.6 R661.1 R664.2 U39.24
C_OUT_DP_TXN0: C31.1 CN2.3 D8.2
C_OUT_DP_TXN1: C25.1 CN2.6 D2.2
C_OUT_DP_TXN2: C27.1 CN2.9 D4.2
C_OUT_DP_TXN3: C29.1 CN2.12 D6.2
C_OUT_DP_TXP0: C30.1 CN2.1 D7.2
C_OUT_DP_TXP1: C24.1 CN2.4 D1.2
C_OUT_DP_TXP2: C26.1 CN2.7 D3.2
C_OUT_DP_TXP3: C28.1 CN2.10 D5.2
C_OUT_EDP_TXN0: C628.1 U41.39
C_OUT_EDP_TXN1: C619.1 U41.36
C_OUT_EDP_TXN2: C610.1 U41.34
C_OUT_EDP_TXN3: C601.1 U41.31
C_OUT_EDP_TXP0: C635.1 U41.40
C_OUT_EDP_TXP1: C626.1 U41.37
C_OUT_EDP_TXP2: C616.1 U41.33
C_OUT_EDP_TXP3: C606.1 U41.30
C_PEG_TXN0: C90.2 U3.B10
C_PEG_TXN1: C89.2 U3.B11
C_PEG_TXN2: C86.2 U3.B12
C_PEG_TXN3: C85.2 U3.B13
C_PEG_TXN4: C82.2 U3.B14
C_PEG_TXN5: C81.2 U3.B15
C_PEG_TXN6: C78.2 U3.B16
C_PEG_TXN7: C77.2 U3.B17
C_PEG_TXN8: C75.2 U3.C18
C_PEG_TXN9: C72.2 U3.A19
C_PEG_TXN10: C71.2 U3.C20
C_PEG_TXN11: C68.2 U3.A21
C_PEG_TXN12: C67.2 U3.C22
C_PEG_TXN13: C63.2 U3.A23
C_PEG_TXN14: C61.2 U3.C24
C_PEG_TXN15: C57.2 U3.A25
C_PEG_TXP0: C91.2 U3.C10
C_PEG_TXP1: C88.2 U3.A11
C_PEG_TXP2: C87.2 U3.C12
C_PEG_TXP3: C84.2 U3.A13
C_PEG_TXP4: C83.2 U3.C14
C_PEG_TXP5: C80.2 U3.A15
C_PEG_TXP6: C79.2 U3.C16
C_PEG_TXP7: C76.2 U3.A17
C_PEG_TXP8: C74.2 U3.B18
C_PEG_TXP9: C73.2 U3.B19
C_PEG_TXP10: C70.2 U3.B20
C_PEG_TXP11: C69.2 U3.B21
C_PEG_TXP12: C65.2 U3.B22
C_PEG_TXP13: C64.2 U3.B23
C_PEG_TXP14: C59.2 U3.B24
C_PEG_TXP15: C58.2 U3.B25
C_SPKL+: C466.1 CN21.6 L23.2
C_SPKL-: C471.1 CN21.5 L25.2
C_TX0_HDMI+: R636.1 U34.17
C_TX0_HDMI-: R635.1 U34.16
C_TX1_HDMI+: R638.1 U34.20
C_TX1_HDMI-: R637.1 U34.19
C_TX2_HDMI+: R644.1 U34.23
C_TX2_HDMI-: R639.1 U34.22
C_TXC_HDMI+: R634.1 U34.14
C_TXC_HDMI-: R632.1 U34.13
CAD_SNK: CN2.13 ESD1.5 ESD1.6 Q58.2 R9.1 R640.2 U1.2
CAD_SNK_R_DP: R9.2 R647.1 R649.1 U1.4 U39.29
CAD_SNK_R_EDP: R704.1 R705.1 U41.29
CATERR#: Q8.5 R78.2 TP6.1 U3.BM30
CCD_PWR: C49.2 C50.2 CN10.36 R37.2
CEN_SPK: C863.2 U17.21
CFG2: R75.1 U3.BN26
CFG4: R79.1 U3.BR20
CFG5: R84.1 U3.BM20
CFG6: R81.1 U3.BT20
CFG_RCOMP: R77.1 U3.BT25
CHA_DIMM0_SA0: JDIM2.256 R324.2 R325.2
CHA_DIMM0_SA1: JDIM2.260 R317.2 R323.2
CHA_DIMM0_SA2: JDIM2.166 R329.2 R330.2
CHA_DIMM1_SA0: JDIM4.256 R315.1 R322.1
CHA_DIMM1_SA1: JDIM4.260 R314.2 R316.2
CHA_DIMM1_SA2: JDIM4.166 R719.2 R722.2
CHB_DIMM0_SA0: JDIM1.256 R185.2 R186.2
CHB_DIMM0_SA1: JDIM1.260 R198.1 R199.1
CHB_DIMM0_SA2: JDIM1.166 R802.2 R805.2
CHB_DIMM1_SA0: JDIM3.256 R770.1 R776.1
CHB_DIMM1_SA1: JDIM3.260 R790.1 R797.1
CHB_DIMM1_SA2: JDIM3.166 R724.2 R725.2
CL_CLK: EC10.2 TP125.1 U14.AR2
CL_DATA: TP126.1 U14.AT5
CL_RST#: TP127.1 U14.AU4
CLK_CPU_BCLKN: U3.A32 U14.C8
CLK_CPU_BCLKP: U3.B31 U14.B8
CLK_DPLL_NSCCLKN: U3.D31 U14.C6
CLK_DPLL_NSCCLKP: U3.E31 U14.D7
CLK_PCI_EC: C918.1 EC11.2 R939.2 R1035.2 U18.13
CLK_PCI_EC_R: R1035.1 U14.BB36
CLK_PCI_LPC: C922.1 R178.2 R1049.2
CLK_PCI_LPC_C: CN16.60 R178.1
CLK_PCI_LPC_R: R1049.1 U14.BB34
CLK_PCIE_LANN: CN17.41 U14.AE6
CLK_PCIE_LANP: CN17.40 U14.AE7
CLK_PCIE_SSD1N: R834.1 U14.AJ6
CLK_PCIE_SSD1N_R: CN15.53 R834.2
CLK_PCIE_SSD1P: R837.1 U14.AJ7
CLK_PCIE_SSD1P_R: CN15.55 R837.2
CLK_PCIE_SSD2N: R1075.1 U14.AB2
CLK_PCIE_SSD2N_R: CN18.53 R1075.2
CLK_PCIE_SSD2P: R1086.1 U14.AB3
CLK_PCIE_SSD2P_R: CN18.55 R1086.2
CLK_PCIE_TBTN: U7.T19 U14.W4
CLK_PCIE_TBTP: U7.V19 U14.W3
CLK_PCIE_WLANN: CN16.49 U14.AC2
CLK_PCIE_WLANP: CN16.47 U14.AC3
CLK_VGA_N: U14.AH9 UG1.BM27
CLK_VGA_P: U14.AH10 UG1.BM26
CLKIN_XTAL: R175.2 R858.1 U14.R6
CLKOUT_SRC_N15: R207.2 U14.V2
CLKOUT_SRC_P15: R197.1 R203.2 U14.V3
CLKRUN#: R1121.1 U14.AV32 U18.93
CLR_CMOS: Q41.2 Q49.2 R586.2 U18.19
CNV_BRI_DT: CN16.36 R225.1 R355.2 R372.1
CNV_BRI_DT_R: R372.2 U14.AV4
CNV_BRI_RSP: R263.2 R393.2 U14.AY2
CNV_BRI_RSP_R: CN16.22 R263.1
CNV_MFUART2_RXD: CN16.48 R384.2
CNV_MFUART2_TXD: CN16.46 R404.2
CNV_PA_BLANKING: CN16.44 R946.2
CNV_RCOMP: R961.1 U14.BA1
CNV_RF_RESET#: CN16.10 Q38.6 R473.1
CNV_RF_RESET#_C: Q38.5 R988.2 U14.BE16
CNV_RGI_DT: CN16.32 R243.1 R403.1 R417.2
CNV_RGI_DT_R: R403.2 U14.BA4
CNV_RGI_RSP: R215.2 R366.2 U14.AV3
CNV_RGI_RSP_R: CN16.34 R215.1
CNV_WR_CLKN: CN16.21 U14.BD4
CNV_WR_CLKP: CN16.23 U14.BE3
CNV_WRXN0: CN16.15 U14.BB3
CNV_WRXN1: CN16.9 U14.BA3
CNV_WRXP0: CN16.17 U14.BB4
CNV_WRXP1: CN16.11 U14.BA2
CNV_WT_CLKN: CN16.71 U14.BC5
CNV_WT_CLKP: CN16.73 U14.BB6
CNV_WTXN0: CN16.65 U14.BE6
CNV_WTXN1: CN16.59 U14.BG6
CNV_WTXP0: CN16.67 U14.BD7
CNV_WTXP1: CN16.61 U14.BF6
COMP_4PH_A: PC25.2 PR33.1 PU2.6
CON_UTC_D1N: CN4.A7 D46.2 L6.2 R327.2
CON_UTC_D1P: CN4.A6 D47.2 L6.3 R342.2
CON_UTC_D2N: CN4.B7 D103.2 L34.2 R899.2
CON_UTC_D2P: CN4.B6 D101.2 L34.3 R892.2
CON_UTC_RX1N: C373.1 CN4.B10 D104.2 R397.2
CON_UTC_RX1P: C372.1 CN4.B11 D105.2 R396.2
CON_UTC_RX2N: C378.1 CN4.A10 D48.2 R399.2
CON_UTC_RX2P: C377.1 CN4.A11 D45.2 R398.2
CON_UTC_SBU1: C429.2 C477.2 CN4.A8 D41.2 R595.2
CON_UTC_SBU2: C425.2 C477.1 CN4.B8 D42.2 R571.2
CON_UTC_TX1N: C374.1 CN4.A3 D50.2
CON_UTC_TX1P: C375.1 CN4.A2 D51.2
CON_UTC_TX2N: C380.1 CN4.B3 D102.2
CON_UTC_TX2P: C379.1 CN4.B2 D100.2
CORE_PLLVDD: CG488.2 CG582.2 CG774.2 CG775.2 CG833.1 CG838.2 CG847.1 CG856.1 CG858.2 CG862.1 LG2.2 UG1.AF11 UG1.BB24 UG1.BC12 UG1.BD12 UG1.BD15 UG1.BD18 UG1.BD21 UG1.U42
CPU_2_PCH_TRIG: R63.1 U14.AK2
CPU_2_PCH_TRIG_R: R63.2 U3.J23
CPU_PCI_BCLKN: U3.C36 U14.B6
CPU_PCI_BCLKP: U3.D35 U14.A6
CPU_PLTRST#: R887.1 U14.AG5
CPU_PLTRST#R: R887.2 U3.BP35
CPU_THERMDA: C519.1 Q59.2 Q59.3 U38.2
CPU_THERMDC: C519.2 Q59.1(EMITTER) U38.3
CPU_VCCIO_PWR_GATE: PR289.1 Q34.3 R351.1
CRISIS_DISK_ENABLE: R365.1 R912.1
CSCL: R654.2 U34.29
CSCOMP_4PH_A: PC35.2 PC36.1 PR40.1 PR117.2 PR447.1 PU2.8
CSDA: R660.2 U34.28
CSN_1PH: PC4.1 PC9.2 PR79.2 PR114.2 PR430.1
CSP1_3PH_A: PC50.2 PR73.2 PU2.11
CSP2_3PH_A: PC54.2 PR31.2 PU2.12
CSP3_3PH_A: PC58.2 PR18.2 PU2.13
CSP4_4PH_A: PC64.1 PR20.1 PU2.26
CSREF_4PH_A: PC50.1 PC54.1 PC58.1 PC64.2 PC300.1 PR76.2 PR81.2 PR82.2 PR83.2 PU2.10
CSSUM_4PH_A: PC35.1 PC36.2 PR19.2 PR24.2 PR30.2 PR49.1 PR68.2 PU2.9
CTL0_DP: R23.2 R671.2 U39.22
CTL0_EDP: R713.2 R714.2 U41.22
CTL0_TBT_SDA: C782.2 R209.2 U10.22
CTL1_DP: R667.2 R668.2 R670.1 U39.23
CTL1_EDP: R710.1 R711.2 R712.2 U41.23
CTL1_TBT_HPDIN: R210.2 R211.1 R826.2 U10.23
CTL2_1: R165.2 U8.7
CTL2_2: R183.2 U11.7
CTL2_3: R1085.1 U26.7
CTL3_1: R166.2 U8.8
CTL3_2: R182.2 U11.8
CTL3_3: R1084.1 U26.8
D/C#: PC182.2 PR253.1 TP23.1
DCI_EN: R1142.2 R1143.1 U30.12
DCIN_ENB: R3.1 U34.3
DCPRTC: C436.2 C445.2 U14.BF47 U14.BG47
DDCCLK_NOR: Q62.4 R677.2
DDCCLK_NOR-1: Q62.3 R675.1
DDCDATA_NOR: Q62.1(S) R678.2
DDCDATA_NOR-1: Q62.6 R674.1
DDI1_TX0_DN: C173.2 U10.39
DDI1_TX0_DN_C: C173.1 U7.AC7
DDI1_TX0_DP: C168.2 U10.40
DDI1_TX0_DP_C: C168.1 U7.AB7
DDI1_TX1_DN: C188.2 U10.36
DDI1_TX1_DN_C: C188.1 U7.AC9
DDI1_TX1_DP: C183.2 U10.37
DDI1_TX1_DP_C: C183.1 U7.AB9
DDI1_TX2_DN: C194.2 U10.34
DDI1_TX2_DN_C: C194.1 U7.AC11
DDI1_TX2_DP: C202.2 U10.33
DDI1_TX2_DP_C: C202.1 U7.AB11
DDI1_TX3_DN: C204.2 U10.31
DDI1_TX3_DN_C: C204.1 U7.AC13
DDI1_TX3_DP: C209.2 U10.30
DDI1_TX3_DP_C: C209.1 U7.AB13
DDPB_CLK: R874.1 U14.AL13
DDPB_DATA: R893.1 U14.AR8
DDPB_HPD0: R1004.2 U14.AT6
DDPC_CLK: R862.1 U14.AN13
DDPC_DATA: R880.1 U14.AL10
DDPD_CLK: R888.1 TP95.1 U14.AL9
DDPD_DATA: R902.1 TP100.1 U14.AR3
DDR0_ALERT#: JDIM2.116 JDIM4.116 U3.AU5
DDR0_PAR: JDIM2.143 JDIM4.143 U3.AG3
DDR1_ALERT#: JDIM1.116 JDIM3.116 U3.AR8
DDR1_PAR: JDIM1.143 JDIM3.143 U3.AJ7
DDR4_SUSON_2V5: PR162.1 R458.2
DDR_DRAMRST#: C284.2 C319.2 C322.2 C323.2 C407.1 JDIM1.108 JDIM2.108 JDIM3.108 JDIM4.108 R336.1 R437.2
DDR_DRAMRST#_L: R437.1 U14.BB46
DDR_PG_CNTL: R90.2 U3.BT13
DDR_VTT: C191.1 C271.1 C281.1 C286.1 C290.1 C695.1 C699.1 C700.1 C837.1 C844.1 C848.1 C849.1 JDIM1.258(VTT) JDIM2.258(VTT) JDIM3.258(VTT) JDIM4.258(VTT) PC267.1 PU27.2(VTTSNS) PU27.20
DDR_VTTT_PG_CTRL: PR364.1 Q12.3 R92.1 R95.2
DDRA_ACT#: JDIM2.114 JDIM4.114 U3.AU3
DDRB_ACT#: JDIM1.114 JDIM3.114 U3.AT9
DEVSLP0_HDD: R328.2 R530.1 U14.AL48
DEVSLP0_R: CN20.1 R530.2
DEVSLP1_SSD1: R187.2 R241.2 U14.AH35
DEVSLP4_SSD2: R520.2 R896.2 U14.AR47
DEVSLP7: TP101.1 U14.AP47
DEVSLP_N1: CN15.38 R187.1 R196.2
DEVSLP_N2: CN18.38 R501.2 R520.1
DG_RTD3_CIO_PWR_EN: R126.1 R732.1 R739.2 U7.F1
DG_RTD3_USB_PWR_EN: R746.2 R758.1 U7.D4
DGPU_HOLD_RST#: R1031.1 R1062.2 U14.BF29 UG7.1
DGPU_OPP#: C393.1 Q32.2 R318.1 R410.2 U18.71
DGPU_OPP#_PROCHOT#: Q32.3 QG3.3 R318.2 RG15.2
DGPU_OVT#: DG6.1(CATHODE) QG9.3 QG21.3 RG46.1 RG51.2
DGPU_PWR_EN: R1034.1 R1065.2 U14.BD29 UG5.1 UG10.2
DGPU_PWROK: QG13.2 QG15.1(S) QG16.6 RG67.2
DGPU_PWROK_Q: QG15.3 R1081.1 R1122.1 U14.AW26
DGPU_THER_ALERT#: QG5.3 R230.1 R259.1
DIFFOUT_4PH_A: PC18.2 PR28.2 PU2.4
DIMM0_CHA_EVENT_N: JDIM2.134 R332.2 R333.2
DIMM0_CHB_EVENT_N: JDIM1.134 R331.2 R348.2
DIMM1_CHA_EVENT_N: JDIM4.134 R717.2 R718.2
DIMM1_CHB_EVENT_N: JDIM3.134 R720.2 R721.2
DMI_RXN0: U3.E8 U14.C33
DMI_RXN1: U3.F6 U14.C32
DMI_RXN2: U3.E5 U14.C31
DMI_RXN3: U3.J9 U14.C29
DMI_RXP0: U3.D8 U14.B33
DMI_RXP1: U3.E6 U14.B32
DMI_RXP2: U3.D5 U14.B31
DMI_RXP3: U3.J8 U14.B29
DMI_TXN0: U3.A8 U14.K34
DMI_TXN1: U3.B6 U14.G33
DMI_TXN2: U3.A5 U14.K32
DMI_TXN3: U3.B4 U14.G30
DMI_TXP0: U3.B8 U14.J35
DMI_TXP1: U3.C6 U14.F34
DMI_TXP2: U3.B5 U14.J32
DMI_TXP3: U3.D4 U14.F30
DMIC_CLK: C263.2 R70.1 R301.1
DMIC_CLK_C: C62.2 CN10.26 D12.1 R70.2 R691.1
DMIC_DAT: C264.2 R74.1 R302.1
DMIC_DATA_C: C66.2 CN10.25 D13.1 R74.2 R692.1
DNBSWON#: U14.BE46 U18.123
DP_D0: C528.1 UG1.BH17
DP_D0#: C529.1 UG1.BG17
DP_D1: C530.1 UG1.BG15
DP_D1#: C531.1 UG1.BF15
DP_D2: C532.1 UG1.BE14
DP_D2#: C533.1 UG1.BF14
DP_D3: C534.1 UG1.BH14
DP_D3#: C535.1 UG1.BG14
DP_HPD: C509.1 CN2.18 ESD1.4 ESD1.7 R18.2
DP_HPD_PCH: CG45.1 Q70.3 R18.1 R653.2 R789.2 RG22.2
DP_HPD_PCH_R: Q70.4 R781.1 U14.AN10
DP_HPD_TBT_Q: QG7.2 RG32.1 RG38.1
DP_TXN0_R: C529.2 U39.10
DP_TXN1_R: C531.2 U39.13
DP_TXN2_R: C533.2 U39.16
DP_TXN3_R: C535.2 U39.19
DP_TXP0_R: C528.2 U39.9
DP_TXP1_R: C530.2 U39.12
DP_TXP2_R: C532.2 U39.15
DP_TXP3_R: C534.2 U39.18
DP_USB_MUX_0V9: C455.2 C882.1 C900.2 C911.2 L17.2 L26.2 U24.10 U24.15 U24.41
DP_USB_MUX_AUXN: CG79.2 U24.9
DP_USB_MUX_AUXP: CG78.2 U24.8
DP_USB_MUX_AVDD09: C465.1 C874.2 C925.1 L26.1 U24.1 U24.21 U24.51
DP_USB_MUX_DCI_CLK: TP56.1 U24.47
DP_USB_MUX_DCI_DAT: TP58.1 U24.46
DP_USB_MUX_FLIP: R976.2 R1007.1 U24.29
DP_USB_MUX_I2C_ADR_SEL0: R1042.1 R1069.1 U24.36
DP_USB_MUX_I2C_ADR_SEL1: R1020.1 R1022.1 U24.35
DP_USB_MUX_ML0N: CG76.2 U24.56
DP_USB_MUX_ML0P: CG75.2 U24.55
DP_USB_MUX_ML1N: CG73.2 U24.59
DP_USB_MUX_ML1P: CG74.2 U24.58
DP_USB_MUX_ML2N: CG71.2 U24.3
DP_USB_MUX_ML2P: CG72.2 U24.2
DP_USB_MUX_ML3N: CG69.2 U24.6
DP_USB_MUX_ML3P: CG70.2 U24.5
DP_USB_MUX_OP_MODE0: R557.2 R563.1 U24.43
DP_USB_MUX_OP_MODE1: R1092.2 R1093.1 U24.42
DP_USB_MUX_POWER_EN: R622.2 R630.1 R1082.1 U24.7
DP_USB_MUX_PU_PWR: R563.2 R601.2 R622.1 R624.2 R1007.2 R1022.2 R1069.2 R1093.2
DP_USB_MUX_PULL1: R595.1 U24.45
DP_USB_MUX_PULL2: R571.1 U24.44
DP_USB_MUX_RX1N: C373.2 U24.16
DP_USB_MUX_RX1P: C372.2 U24.17
DP_USB_MUX_RX2N: C378.2 U24.26
DP_USB_MUX_RX2P: C377.2 U24.27
DP_USB_MUX_SBU1: C429.1 U24.34
DP_USB_MUX_SBU2: C425.1 U24.33
DP_USB_MUX_SCL: R485.1 U24.37
DP_USB_MUX_SDA: R507.1 U24.38
DP_USB_MUX_SSRXN: C480.1 U24.49
DP_USB_MUX_SSRXP: C481.1 U24.50
DP_USB_MUX_SSTXN: C482.1 U24.52
DP_USB_MUX_SSTXP: C483.1 U24.53
DP_USB_MUX_TEST_EN: TP51.1 U24.40
DP_USB_MUX_TEST_R: TP114.1 U24.28
DP_USB_MUX_TX1N: C374.2 U24.20
DP_USB_MUX_TX1P: C375.2 U24.19
DP_USB_MUX_TX2N: C380.2 U24.23
DP_USB_MUX_TX2P: C379.2 U24.24
DP_USB_MUX_VDDIO: C919.1 R1012.2 R1115.2 U24.11 U24.39
DP_USB_MUX_VIN: C384.2 C394.2 C405.2 C886.1 L36.1 U24.14
DP_USB_MUX_VX: L17.1 U24.13
DP_USB_MUX_XTAL_I: C395.2 R414.1 U24.30 Y3.1
DP_USB_MUX_XTAL_O: R426.1 U24.31(XTAL_O)
DP_USB_MUX_XTAL_O_R: C383.2 R414.2 R426.2 Y3.3
DP_USB_MXU_DCDC_GND: C384.1 C394.1 C405.1 C882.2 C886.2 C900.1 R963.2 U24.12
DPEQ0_A1_DP: R27.2 R28.2 U39.14
DPEQ0_A1_EDP: R113.2 R114.2 U41.14
DPEQ0_A1_TBT: R800.2 R806.2 U10.14
DPEQ1_DP: R662.2 R665.2 U39.2
DPEQ1_EDP: R706.2 R708.2 U41.2
DPEQ1_TBT: R788.2 R792.2 U10.2
DPSNK_RBIAS_1: R809.1 U7.Y18
DPWROK_R: R960.2 R965.2 U14.AW41
DRMOS_IMON1: PR283.1 PU21.38
DRMOS_IMON2: PR288.1 PU20.38
DRMOS_IMON3: PR300.1 PU19.38
DRMOS_IMON4: PR307.1 PU18.38
DRMOS_IMON5: PR309.1 PU17.38
DRMOS_IMON6: PR313.1 PU16.38
DRMOS_IMON7: PR316.2 PU15.38
DRMOS_IMON8: PR318.2 PU14.38
DRMOS_REFIN: PC198.1 PC203.2 PC206.2 PC208.2 PC210.2 PC212.2 PC213.2 PC215.2 PC415.2 PR200.1 PR201.2 PR202.2 PR203.2 PR204.2 PR205.2 PR206.2 PR207.1 PR278.2 PR279.2 PR287.1 PR290.1 PR518.1 PR523.1 PR525.1 PR530.1 PR534.1 PR538.1 PR540.1
DRVON: PC65.1 PR63.1 PR64.1 PR65.1 PR66.1 PR89.1 PU2.17
EAPD: D52.1(CATHODE) R475.1 R886.1
EC_FPBACK#: Q7.2 U18.86
EC_GPI2: R440.1 R446.1 U18.68
EC_PECI: R47.2 R266.1
EC_PECR_R: R266.2 U18.117
EC_PWROK: R1006.2 R1023.2 R1024.2 R1073.2 U18.33 U42.1
EC_PWROK_R: R1068.2 R1073.1 R1108.1 U14.AY42
EC_RST#: TP110.1 U14.BF38
ECAGND: C392.2 C422.1 L13.2 U18.75
EDP_AUX#_C: C639.2 CN10.6 R695.2 R700.1 R707.2 U41.25
EDP_AUX_C: C640.2 CN10.5 R696.2 R701.1 R709.2 U41.24
EDP_DISP_UTIL: TP3.1 U3.A33
EDP_HPD_CPU: R60.1 R1054.2 R1089.1 U14.AN6
EDP_HPD_GPU: CG67.1 R59.1 R702.2 RG33.2
EDP_HPD_R: CN10.30 R54.1
EDP_HPD_RR: C55.1 R54.2 R59.2 R60.2
EDP_RCOMP: R687.2 U3.D37
EDP_TXN0_C: C628.2 CN10.9
EDP_TXN1_C: C619.2 CN10.12
EDP_TXN2_C: C610.2 CN10.15
EDP_TXN3_C: C601.2 CN10.18
EDP_TXP0_C: C635.2 CN10.8
EDP_TXP1_C: C626.2 CN10.11
EDP_TXP2_C: C616.2 CN10.14
EDP_TXP3_C: C606.2 CN10.17
EDP_VDD_EN: R697.2 R698.2 R699.2 U40.4
EN: C435.1 R515.2 U43.7
EN_U3: R1144.1 U30.11
EQ_SEL_A0: R1.2 R6.1 U34.5
ESPI_EC_IO0: R1079.1 U14.BB39
ESPI_EC_IO1: R1107.1 U14.AW37
ESPI_EC_IO2: R1087.1 U14.AV37
ESPI_EC_IO3: R1078.1 U14.BA38
EXT_SMI#: R242.2 R258.2 TP28.1 U14.T48
F_SPKL+: C408.1 CN21.4 L18.2
F_SPKL-: C390.1 CN21.3 L16.2
F_SPKR+: C348.1 CN21.2 L9.2
F_SPKR-: C356.1 CN21.1 L10.2
FAN1_PWM: Q67.1(EMITTER) U18.32
FAN1_PWM_Q: C701.1 CN12.3 Q67.3 R728.2
FAN1_RPM: Q68.1(S) R743.2 R748.2 U18.47
FAN2_PWM: Q25.1(EMITTER) U18.31
FAN2_PWM_Q: C696.1 CN11.3 Q25.3 R734.2
FAN2_RPM: Q24.1(S) R156.2 R731.2 U18.48
FB_4PH_A: PC22.1 PC25.1 PR28.1 PR29.1 PU2.5
FB_CAL_PD_VDDQ: RG111.2 UG1.R44
FB_CAL_PU_GND: RG110.2 UG1.P44
FB_CAL_TERM_GND: RG112.2 UG1.R45
FB_VREF_PROBE: RG107.2 UG1.P45
FBA_CMD0: UG1.Y51 VRAM6.H3
FBA_CMD1: UG1.Y52 VRAM6.J3 VRAM6.K3
FBA_CMD2: RG102.1 UG1.Y49 VRAM6.J1
FBA_CMD3: UG1.AA52 VRAM6.J4 VRAM6.K4
FBA_CMD4: UG1.AA51 VRAM6.L3
FBA_CMD5: UG1.AA50 VRAM6.M4
FBA_CMD6: UG1.AC50 VRAM6.J5 VRAM6.K5
FBA_CMD7: UG1.AC51 VRAM6.H5 VRAM6.L5
FBA_CMD8: UG1.AC52 VRAM6.G4
FBA_CMD9: UG1.AC49 VRAM6.G11
FBA_CMD10: RG105.2 UG1.AD52 VRAM6.G10 VRAM6.M10
FBA_CMD11: UG1.AD51 VRAM6.H10 VRAM6.L10
FBA_CMD12: UG1.AD50 VRAM6.M11
FBA_CMD13: UG1.AF50 VRAM6.L12
FBA_CMD14: UG1.AF51 VRAM6.J11 VRAM6.K11
FBA_CMD15: UG1.AF52 VRAM6.J12 VRAM6.K12
FBA_CMD16: UG1.AN50 VRAM8.L3
FBA_CMD17: UG1.AN51 VRAM8.J3 VRAM8.K3
FBA_CMD18: RG142.1 UG1.AN52 VRAM8.J1
FBA_CMD19: UG1.AM49 VRAM8.J4 VRAM8.K4
FBA_CMD20: UG1.AM52 VRAM8.H3
FBA_CMD21: UG1.AM51 VRAM8.G4
FBA_CMD22: UG1.AM50 VRAM8.J5 VRAM8.K5
FBA_CMD23: UG1.AK50 VRAM8.H5 VRAM8.L5
FBA_CMD24: UG1.AK51 VRAM8.M4
FBA_CMD25: UG1.AK52 VRAM8.M11
FBA_CMD26: RG122.2 UG1.AJ49 VRAM8.G10 VRAM8.M10
FBA_CMD27: UG1.AJ52 VRAM8.H10 VRAM8.L10
FBA_CMD28: UG1.AJ51 VRAM8.G11
FBA_CMD29: UG1.AJ50 VRAM8.H12
FBA_CMD30: UG1.AG50 VRAM8.J12 VRAM8.K12
FBA_CMD31: UG1.AG51 VRAM8.J11 VRAM8.K11
FBA_CMD32: UG1.AF49 VRAM6.H12
FBA_CMD33: UG1.AG52 VRAM8.L12
FBA_DBI0: UG1.U47 VRAM6.D2
FBA_DBI1: UG1.Y48 VRAM6.D13
FBA_DBI2: UG1.AG47 VRAM6.R13
FBA_DBI3: UG1.AC48 VRAM6.R2
FBA_DBI4: UG1.BB51 VRAM8.D2
FBA_DBI5: UG1.AV50 VRAM8.D13
FBA_DBI6: UG1.AM48 VRAM8.R13
FBA_DBI7: UG1.AR49 VRAM8.R2
FBA_DEBUG0: TPG52.1 UG1.Y50
FBA_DEBUG1: TPG66.1 UG1.AR50
FBA_EDC0: UG1.R48 VRAM6.C2
FBA_EDC1: UG1.V48 VRAM6.C13
FBA_EDC2: UG1.AF44 VRAM6.T13
FBA_EDC3: UG1.AA48 VRAM6.T2
FBA_EDC4: UG1.BB52 VRAM8.C2
FBA_EDC5: UG1.AT50 VRAM8.C13
FBA_EDC6: UG1.AK48 VRAM8.T13
FBA_EDC7: UG1.AR51 VRAM8.T2
FBA_PLL_AVDD: CG29.1 CG31.1 CG35.1 CG407.1 CG410.1 CG414.1 CG504.1 CG581.1 CG724.1 LG1.1 UG1.AF42 UG1.AN42 UG1.L17 UG1.L29 UG1.L38 UG1.V11
FBA_VREFC: CG835.1 RG2.2 RG3.2 RG5.2 VRAM6.K1 VRAM8.K1
FBA_ZQ_1_A: RG115.1 VRAM6.J14
FBA_ZQ_1_B: RG113.1 VRAM6.K14(ZQ_B)
FBA_ZQ_2_A: RG117.1 VRAM8.J14
FBA_ZQ_2_B: RG116.1 VRAM8.K14(ZQ_B)
FBB_CMD0: UG1.B35 VRAM3.H3
FBB_CMD1: UG1.A35 VRAM3.J3 VRAM3.K3
FBB_CMD2: RG97.1 UG1.D35 VRAM3.J1
FBB_CMD3: UG1.A36 VRAM3.J4 VRAM3.K4
FBB_CMD4: UG1.B36 VRAM3.L3
FBB_CMD5: UG1.C36 VRAM3.M4
FBB_CMD6: UG1.C38 VRAM3.J5 VRAM3.K5
FBB_CMD7: UG1.B38 VRAM3.H5 VRAM3.L5
FBB_CMD8: UG1.A38 VRAM3.G4
FBB_CMD9: UG1.D38 VRAM3.G11
FBB_CMD10: RG95.2 UG1.A39 VRAM3.G10 VRAM3.M10
FBB_CMD11: UG1.B39 VRAM3.H10 VRAM3.L10
FBB_CMD12: UG1.C39 VRAM3.M11
FBB_CMD13: UG1.C41 VRAM3.L12
FBB_CMD14: UG1.B41 VRAM3.J11 VRAM3.K11
FBB_CMD15: UG1.A41 VRAM3.J12 VRAM3.K12
FBB_CMD16: UG1.B49 VRAM4.L3
FBB_CMD17: UG1.A49 VRAM4.J3 VRAM4.K3
FBB_CMD18: RG91.1 UG1.A48 VRAM4.J1
FBB_CMD19: UG1.D47 VRAM4.J4 VRAM4.K4
FBB_CMD20: UG1.A47 VRAM4.H3
FBB_CMD21: UG1.B47 VRAM4.G4
FBB_CMD22: UG1.C47 VRAM4.J5 VRAM4.K5
FBB_CMD23: UG1.C45 VRAM4.H5 VRAM4.L5
FBB_CMD24: UG1.B45 VRAM4.M4
FBB_CMD25: UG1.A45 VRAM4.M11
FBB_CMD26: RG82.2 UG1.D44 VRAM4.G10 VRAM4.M10
FBB_CMD27: UG1.A44 VRAM4.H10 VRAM4.L10
FBB_CMD28: UG1.B44 VRAM4.G11
FBB_CMD29: UG1.C44 VRAM4.H12
FBB_CMD30: UG1.C42 VRAM4.J12 VRAM4.K12
FBB_CMD31: UG1.B42 VRAM4.J11 VRAM4.K11
FBB_CMD32: UG1.D41 VRAM3.H12
FBB_CMD33: UG1.A42 VRAM4.L12
FBB_DBI0: UG1.C32 VRAM3.D2
FBB_DBI1: UG1.E33 VRAM3.D13
FBB_DBI2: UG1.E44 VRAM3.R13
FBB_DBI3: UG1.G39 VRAM3.R2
FBB_DBI4: UG1.P49 VRAM4.D2
FBB_DBI5: UG1.L48 VRAM4.D13
FBB_DBI6: UG1.D50 VRAM4.R13
FBB_DBI7: UG1.H50 VRAM4.R2
FBB_DEBUG0: TPG36.1 UG1.C35
FBB_DEBUG1: TPG42.1 UG1.B50
FBB_EDC0: UG1.B33 VRAM3.C2
FBB_EDC1: UG1.E35 VRAM3.C13
FBB_EDC2: UG1.G44 VRAM3.T13
FBB_EDC3: UG1.H38 VRAM3.T2
FBB_EDC4: UG1.P50 VRAM4.C2
FBB_EDC5: UG1.J48 VRAM4.C13
FBB_EDC6: UG1.D51 VRAM4.T13
FBB_EDC7: UG1.F51 VRAM4.T2
FBB_FB_TCK0: TPG33.1 VRAM3.N5
FBB_FB_TDI0: TPG21.1 VRAM3.F10
FBB_FB_TDO0: TPG31.1 VRAM3.N10
FBB_FB_TMS0: TPG11.1 VRAM3.F5
FBB_VREFC: CG192.1 RG1.2 RG4.2 RG6.2 VRAM3.K1 VRAM4.K1
FBB_ZQ_1_A: RG84.1 VRAM3.J14
FBB_ZQ_1_B: RG90.1 VRAM3.K14(ZQ_B)
FBB_ZQ_2_A: RG92.1 VRAM4.J14
FBB_ZQ_2_B: RG81.1 VRAM4.K14(ZQ_B)
FBC_CMD0: UG1.C11 VRAM1.H3
FBC_CMD1: UG1.B11 VRAM1.J3 VRAM1.K3
FBC_CMD2: RG83.1 UG1.A11 VRAM1.J1
FBC_CMD3: UG1.D11 VRAM1.J4 VRAM1.K4
FBC_CMD4: UG1.A12 VRAM1.L3
FBC_CMD5: UG1.B12 VRAM1.M4
FBC_CMD6: UG1.C12 VRAM1.J5 VRAM1.K5
FBC_CMD7: UG1.C14 VRAM1.H5 VRAM1.L5
FBC_CMD8: UG1.B14 VRAM1.G4
FBC_CMD9: UG1.A14 VRAM1.G11
FBC_CMD10: RG86.2 UG1.D14 VRAM1.G10 VRAM1.M10
FBC_CMD11: UG1.A15 VRAM1.H10 VRAM1.L10
FBC_CMD12: UG1.B15 VRAM1.M11
FBC_CMD13: UG1.C15 VRAM1.L12
FBC_CMD14: UG1.C17 VRAM1.J11 VRAM1.K11
FBC_CMD15: UG1.B17 VRAM1.J12 VRAM1.K12
FBC_CMD16: UG1.B24 VRAM2.L3
FBC_CMD17: UG1.A24 VRAM2.J3 VRAM2.K3
FBC_CMD18: RG93.1 UG1.D23 VRAM2.J1
FBC_CMD19: UG1.A23 VRAM2.J4 VRAM2.K4
FBC_CMD20: UG1.B23 VRAM2.H3
FBC_CMD21: UG1.C23 VRAM2.G4
FBC_CMD22: UG1.C21 VRAM2.J5 VRAM2.K5
FBC_CMD23: UG1.B21 VRAM2.H5 VRAM2.L5
FBC_CMD24: UG1.A21 VRAM2.M4
FBC_CMD25: UG1.D20 VRAM2.M11
FBC_CMD26: RG88.2 UG1.A20 VRAM2.G10 VRAM2.M10
FBC_CMD27: UG1.B20 VRAM2.H10 VRAM2.L10
FBC_CMD28: UG1.C20 VRAM2.G11
FBC_CMD29: UG1.C18 VRAM2.H12
FBC_CMD30: UG1.B18 VRAM2.J12 VRAM2.K12
FBC_CMD31: UG1.A18 VRAM2.J11 VRAM2.K11
FBC_CMD32: UG1.A17 VRAM1.H12
FBC_CMD33: UG1.D17 VRAM2.L12
FBC_DBI0: UG1.A5 VRAM1.D2
FBC_DBI1: UG1.C8 VRAM1.D13
FBC_DBI2: UG1.J18 VRAM1.R13
FBC_DBI3: UG1.F12 VRAM1.R2
FBC_DBI4: UG1.D29 VRAM2.D2
FBC_DBI5: UG1.E27 VRAM2.D13
FBC_DBI6: UG1.F20 VRAM2.R13
FBC_DBI7: UG1.E26 VRAM2.R2
FBC_DEBUG0: TPG37.1 UG1.A9
FBC_DEBUG1: TPG39.1 UG1.C24
FBC_EDC0: UG1.D5 VRAM1.C2
FBC_EDC1: UG1.D8 VRAM1.C13
FBC_EDC2: UG1.E17 VRAM1.T13
FBC_EDC3: UG1.E12 VRAM1.T2
FBC_EDC4: UG1.E30 VRAM2.C2
FBC_EDC5: UG1.B29 VRAM2.C13
FBC_EDC6: UG1.G21 VRAM2.T13
FBC_EDC7: UG1.E24 VRAM2.T2
FBC_VREFC: CG191.1 RG96.2 RG98.2 RG99.2 VRAM1.K1 VRAM2.K1
FBC_ZQ_1_A: RG87.1 VRAM1.J14
FBC_ZQ_1_B: RG94.1 VRAM1.K14(ZQ_B)
FBC_ZQ_2_A: RG89.1 VRAM2.J14
FBC_ZQ_2_B: RG85.1 VRAM2.K14(ZQ_B)
FBD_CMD0: UG1.AD2 VRAM7.H3
FBD_CMD1: UG1.AD1 VRAM7.J3 VRAM7.K3
FBD_CMD2: RG119.1 UG1.AD4 VRAM7.J1
FBD_CMD3: UG1.AC1 VRAM7.J4 VRAM7.K4
FBD_CMD4: UG1.AC2 VRAM7.L3
FBD_CMD5: UG1.AC3 VRAM7.M4
FBD_CMD6: UG1.AA3 VRAM7.J5 VRAM7.K5
FBD_CMD7: UG1.AA2 VRAM7.H5 VRAM7.L5
FBD_CMD8: UG1.AA1 VRAM7.G4
FBD_CMD9: UG1.AA4 VRAM7.G11
FBD_CMD10: RG114.2 UG1.Y1 VRAM7.G10 VRAM7.M10
FBD_CMD11: UG1.Y2 VRAM7.H10 VRAM7.L10
FBD_CMD12: UG1.Y3 VRAM7.M11
FBD_CMD13: UG1.V3 VRAM7.L12
FBD_CMD14: UG1.V2 VRAM7.J11 VRAM7.K11
FBD_CMD15: UG1.V1 VRAM7.J12 VRAM7.K12
FBD_CMD16: UG1.L3 VRAM5.L3
FBD_CMD17: UG1.L2 VRAM5.J3 VRAM5.K3
FBD_CMD18: RG100.1 UG1.L1 VRAM5.J1
FBD_CMD19: UG1.M4 VRAM5.J4 VRAM5.K4
FBD_CMD20: UG1.M1 VRAM5.H3
FBD_CMD21: UG1.M2 VRAM5.G4
FBD_CMD22: UG1.M3 VRAM5.J5 VRAM5.K5
FBD_CMD23: UG1.P3 VRAM5.H5 VRAM5.L5
FBD_CMD24: UG1.P2 VRAM5.M4
FBD_CMD25: UG1.P1 VRAM5.M11
FBD_CMD26: RG103.2 UG1.R4 VRAM5.G10 VRAM5.M10
FBD_CMD27: UG1.R1 VRAM5.H10 VRAM5.L10
FBD_CMD28: UG1.R2 VRAM5.G11
FBD_CMD29: UG1.R3 VRAM5.H12
FBD_CMD30: UG1.U3 VRAM5.J12 VRAM5.K12
FBD_CMD31: UG1.U2 VRAM5.J11 VRAM5.K11
FBD_CMD32: UG1.V4 VRAM7.H12
FBD_CMD33: UG1.U1 VRAM5.L12
FBD_DBI0: UG1.AJ1 VRAM7.D2
FBD_DBI1: UG1.AG1 VRAM7.D13
FBD_DBI2: UG1.AA7 VRAM7.R13
FBD_DBI3: UG1.AD5 VRAM7.R2
FBD_DBI4: UG1.D3 VRAM5.D2
FBD_DBI5: UG1.H3 VRAM5.D13
FBD_DBI6: UG1.U5 VRAM5.R13
FBD_DBI7: UG1.M9 VRAM5.R2
FBD_DEBUG0: TPG59.1 UG1.AD3
FBD_DEBUG1: TPG48.1 UG1.J3
FBD_EDC0: UG1.AJ3 VRAM7.C2
FBD_EDC1: UG1.AG2 VRAM7.C13
FBD_EDC2: UG1.AA9 VRAM7.T13
FBD_EDC3: UG1.AF4 VRAM7.T2
FBD_EDC4: UG1.E3 VRAM5.C2
FBD_EDC5: UG1.H2 VRAM5.C13
FBD_EDC6: UG1.U6 VRAM5.T13
FBD_EDC7: UG1.M5 VRAM5.T2
FBD_VREFC: CG702.1 RG101.2 RG118.2 RG126.2 VRAM5.K1 VRAM7.K1
FBD_ZQ_1_A: RG109.1 VRAM7.J14
FBD_ZQ_1_B: RG108.1 VRAM7.K14(ZQ_B)
FBD_ZQ_2_A: RG106.1 VRAM5.J14
FBD_ZQ_2_B: RG104.1 VRAM5.K14(ZQ_B)
FBVDD_EN: PR8.2 UG9.4(Y)
FBVDD_PSI: PR5.2 RG17.2 UG1.BB2
FBVDDQ_MEM: CG1.1 CG2.1 CG3.1 CG4.1 CG5.1 CG6.1 CG7.1 CG8.1 CG9.1 CG10.1 CG11.1 CG12.1 CG13.1 CG17.1 CG20.1 CG21.1 CG22.1 CG23.1 CG24.1 CG25.1 CG26.1 CG27.1 CG28.1 CG32.1 CG33.1 CG34.1 CG43.1 CG44.1 CG85.1 CG86.1 CG87.1 CG88.1 CG89.1 CG90.1 CG91.1 CG92.1 CG93.1 CG94.1 CG95.1 CG96.1 CG97.1 CG99.1 CG101.1 CG102.1 CG103.1 CG105.1 CG106.1 CG107.1 CG108.1 CG114.1 CG115.1 CG116.1 CG117.1 CG118.1 CG119.1 CG120.1 CG121.1 CG122.1 CG123.1 CG124.1 CG125.1 CG126.1 CG127.1 CG128.1 CG129.1 CG130.1 CG131.1 CG132.1 CG133.1 CG134.1 CG135.1 CG136.1 CG137.1 CG138.1 CG139.1 CG140.1 CG141.1 CG142.1 CG143.1 CG144.1 CG145.1 CG146.1 CG147.1 CG148.1 CG149.1 CG150.1 CG151.1 CG152.1 CG153.1 CG154.1 CG155.1 CG156.1 CG157.1 CG158.1 CG159.1 CG160.1 CG161.1 CG162.1 CG163.1 CG164.1 CG165.1 CG166.1 CG167.1 CG168.1 CG169.1 CG170.1 CG171.1 CG172.1 CG173.1 CG174.1 CG175.1 CG176.1 CG177.1 CG178.1 CG179.1 CG180.1 CG181.1 CG182.1 CG183.1 CG184.1 CG185.1 CG186.1 CG187.1 CG188.1 CG189.1 CG190.1 CG193.1 CG194.1 CG195.1 CG196.1 CG197.1 CG198.1 CG199.1 CG200.1 CG201.1 CG202.1 CG203.1 CG204.1 CG205.1 CG206.1 CG207.1 CG208.1 CG209.1 CG210.1 CG211.1 CG212.1 CG213.1 CG214.1 CG215.1 CG216.1 CG217.1 CG218.1 CG219.1 CG220.1 CG221.1 CG222.1 CG223.1 CG224.1 CG225.1 CG226.1 CG227.1 CG228.1 CG229.1 CG230.1 CG231.1 CG232.1 CG233.1 CG234.1 CG235.1 CG236.1 CG237.1 CG238.1 CG239.1 CG240.1 CG241.1 CG242.1 CG243.1 CG244.1 CG245.1 CG246.1 CG247.1 CG248.1 CG249.1 CG250.1 CG251.1 CG252.1 CG253.1 CG254.1 CG255.1 CG256.1 CG257.1 CG258.1 CG259.1 CG260.1 CG261.1 CG262.1 CG263.1 CG264.1 CG265.1 CG266.1 CG267.1 CG268.1 CG269.1 CG270.1 CG271.1 CG272.1 CG274.1 CG276.1 CG278.1 CG281.1 CG283.1 CG284.1 CG285.1 CG287.1 CG289.1 CG290.1 CG291.1 CG292.1 CG293.1 CG294.1 CG295.1 CG296.1 CG297.1 CG298.1 CG299.1 CG300.1 CG302.1 CG303.1 CG304.1 CG305.1 CG306.1 CG307.1 CG308.2 CG309.1 CG310.1 CG311.1 CG312.1 CG314.1 CG315.1 CG316.1 CG317.1 CG318.1 CG319.1 CG320.1 CG321.1 CG322.1 CG323.1 CG324.1 CG325.1 CG326.1 CG327.1 CG328.1 CG329.1 CG330.1 CG332.1 CG333.1 CG334.1 CG335.1 CG337.1 CG338.1 CG339.1 CG341.1 CG342.1 CG343.1 CG344.1 CG345.1 CG346.1 CG347.1 CG349.1 CG350.1 CG351.2 CG352.1 CG354.1 CG355.1 CG356.2 CG357.1 CG358.1 CG359.1 CG360.2 CG361.2 CG362.2 CG363.1 CG364.2 CG365.2 CG366.1 CG367.1 CG368.1 CG369.1 CG370.1 CG371.1 CG372.2 CG373.1 CG374.2 CG375.2 CG376.1 CG377.2 CG378.2 CG379.1 CG380.1 CG381.2 CG382.1 CG383.1 CG384.1 CG385.2 CG386.1 CG387.1 CG388.1 CG389.1 CG390.2 CG391.2 CG392.2 CG393.1 CG394.1 CG395.2 CG396.1 CG397.2 CG398.1 CG399.2 CG400.2 CG401.1 CG402.1 CG403.1 CG404.1 CG405.2 CG406.1 CG408.1 CG409.2 CG416.1 CG417.1 CG418.2 CG422.1 CG423.1 CG425.1 CG426.1 CG427.1 CG428.1 CG429.1 CG430.1 CG431.1 CG432.1 CG433.1 CG434.1 CG455.1 CG459.2 CG460.2 CG461.2 CG462.1 CG463.1 CG478.1 CG480.2 CG481.2 CG483.1 CG484.1 CG485.1 CG487.1 CG490.1 CG503.2 CG505.1 CG506.1 CG507.1 CG508.1 CG509.1 CG510.1 CG511.1 CG512.1 CG513.1 CG514.1 CG515.1 CG517.2 CG519.2 CG520.2 CG522.1 CG523.1 CG534.1 CG535.1 CG537.1 CG538.1 CG539.1 CG540.1 CG541.2 CG542.2 CG543.1 CG544.1 CG547.2 CG548.2 CG549.1 CG553.1 CG563.2 CG564.1 CG565.1 CG566.2 CG567.1 CG568.1 CG574.1 CG575.1 CG577.1 CG579.2 CG583.1 CG585.1 CG587.1 CG588.1 CG589.1 CG593.1 CG611.1 CG612.1 CG617.1 CG618.1 CG619.1 CG620.1 CG621.1 CG622.1 CG623.1 CG624.1 CG640.2 CG641.2 CG642.2 CG643.2 CG644.1 CG645.1 CG646.2 CG647.2 CG648.1 CG649.1 CG676.1 CG677.1 CG678.1 CG679.1 CG680.1 CG681.2 CG682.1 CG683.1 CG684.1 CG685.1 CG686.1 CG687.1 CG688.1 CG701.1 CG703.1 CG704.1 CG707.1 CG711.1 CG712.1 CG723.1 CG726.1 CG730.1 CG731.1 CG734.1 CG735.1 CG740.1 CG747.1 CG748.1 CG805.1 CG806.1 CG816.1 CG817.1 CG818.1 CG819.1 CG820.1 CG821.1 CG822.1 CG823.1 PC20.1 PC77.1 PC91.1 PC92.1 PC317.1 PC318.1 PC320.1 PC325.1 PC330.1 PC331.1 PL1.2 PL8.2 PR444.1 PR464.1 RG1.1 RG5.1 RG82.1 RG86.1 RG88.1 RG95.1 RG99.1 RG103.1 RG105.1 RG111.1 RG114.1 RG118.1 RG122.1 UG1.AA10 UG1.AA11 UG1.AA42 UG1.AA43 UG1.AC10 UG1.AC11 UG1.AC42 UG1.AC43 UG1.AD10 UG1.AD11 UG1.AD42 UG1.AD43 UG1.AF10 UG1.AF43 UG1.AG10 UG1.AG11 UG1.AG42 UG1.AG43 UG1.AJ10 UG1.AJ11 UG1.AJ42 UG1.AJ43 UG1.AK10 UG1.AK11 UG1.AK42 UG1.AK43 UG1.AM42 UG1.AM43 UG1.AN43 UG1.AR42 UG1.AR43 UG1.AT43 UG1.K12 UG1.K14 UG1.K15 UG1.K17 UG1.K18 UG1.K20 UG1.K21 UG1.K23 UG1.K24 UG1.K26 UG1.K27 UG1.K29 UG1.K30 UG1.K32 UG1.K33 UG1.K35 UG1.K36 UG1.K38 UG1.K39 UG1.K41 UG1.L14 UG1.L15 UG1.L18 UG1.L20 UG1.L21 UG1.L23 UG1.L24 UG1.L26 UG1.L27 UG1.L30 UG1.L32 UG1.L33 UG1.L35 UG1.L36 UG1.L39 UG1.M10 UG1.M43 UG1.P10 UG1.P11 UG1.P42 UG1.P43 UG1.R10 UG1.R11 UG1.R42 UG1.R43 UG1.U10 UG1.U11 UG1.U43 UG1.V10 UG1.V42 UG1.V43 UG1.Y10 UG1.Y11 UG1.Y42 UG1.Y43 VRAM1.A1 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C4 VRAM1.C11 VRAM1.C14 VRAM1.E1 VRAM1.E5 VRAM1.E10 VRAM1.E14 VRAM1.F4 VRAM1.F11 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.J2 VRAM1.J13 VRAM1.K2 VRAM1.K13 VRAM1.L1 VRAM1.L2 VRAM1.L13 VRAM1.L14 VRAM1.N4 VRAM1.N11 VRAM1.P1 VRAM1.P5 VRAM1.P10 VRAM1.P14 VRAM1.T1 VRAM1.T4 VRAM1.T11 VRAM1.T14 VRAM1.U5 VRAM1.U10 VRAM1.V1 VRAM1.V14 VRAM2.A1 VRAM2.A14 VRAM2.B5 VRAM2.B10 VRAM2.C1 VRAM2.C4 VRAM2.C11 VRAM2.C14 VRAM2.E1 VRAM2.E5 VRAM2.E10 VRAM2.E14 VRAM2.F4 VRAM2.F11 VRAM2.H1 VRAM2.H2 VRAM2.H13 VRAM2.H14 VRAM2.J2 VRAM2.J13 VRAM2.K2 VRAM2.K13 VRAM2.L1 VRAM2.L2 VRAM2.L13 VRAM2.L14 VRAM2.N4 VRAM2.N11 VRAM2.P1 VRAM2.P5 VRAM2.P10 VRAM2.P14 VRAM2.T1 VRAM2.T4 VRAM2.T11 VRAM2.T14 VRAM2.U5 VRAM2.U10 VRAM2.V1 VRAM2.V14 VRAM3.A1 VRAM3.A14 VRAM3.B5 VRAM3.B10 VRAM3.C1 VRAM3.C4 VRAM3.C11 VRAM3.C14 VRAM3.E1 VRAM3.E5 VRAM3.E10 VRAM3.E14 VRAM3.F4 VRAM3.F11 VRAM3.H1 VRAM3.H2 VRAM3.H13 VRAM3.H14 VRAM3.J2 VRAM3.J13 VRAM3.K2 VRAM3.K13 VRAM3.L1 VRAM3.L2 VRAM3.L13 VRAM3.L14 VRAM3.N4 VRAM3.N11 VRAM3.P1 VRAM3.P5 VRAM3.P10 VRAM3.P14 VRAM3.T1 VRAM3.T4 VRAM3.T11 VRAM3.T14 VRAM3.U5 VRAM3.U10 VRAM3.V1 VRAM3.V14 VRAM4.A1 VRAM4.A14 VRAM4.B5 VRAM4.B10 VRAM4.C1 VRAM4.C4 VRAM4.C11 VRAM4.C14 VRAM4.E1 VRAM4.E5 VRAM4.E10 VRAM4.E14 VRAM4.F4 VRAM4.F11 VRAM4.H1 VRAM4.H2 VRAM4.H13 VRAM4.H14 VRAM4.J2 VRAM4.J13 VRAM4.K2 VRAM4.K13 VRAM4.L1 VRAM4.L2 VRAM4.L13 VRAM4.L14 VRAM4.N4 VRAM4.N11 VRAM4.P1 VRAM4.P5 VRAM4.P10 VRAM4.P14 VRAM4.T1 VRAM4.T4 VRAM4.T11 VRAM4.T14 VRAM4.U5 VRAM4.U10 VRAM4.V1 VRAM4.V14 VRAM5.A1 VRAM5.A14 VRAM5.B5 VRAM5.B10 VRAM5.C1 VRAM5.C4 VRAM5.C11 VRAM5.C14 VRAM5.E1 VRAM5.E5 VRAM5.E10 VRAM5.E14 VRAM5.F4 VRAM5.F11 VRAM5.H1 VRAM5.H2 VRAM5.H13 VRAM5.H14 VRAM5.J2 VRAM5.J13 VRAM5.K2 VRAM5.K13 VRAM5.L1 VRAM5.L2 VRAM5.L13 VRAM5.L14 VRAM5.N4 VRAM5.N11 VRAM5.P1 VRAM5.P5 VRAM5.P10 VRAM5.P14 VRAM5.T1 VRAM5.T4 VRAM5.T11 VRAM5.T14 VRAM5.U5 VRAM5.U10 VRAM5.V1 VRAM5.V14 VRAM6.A1 VRAM6.A14 VRAM6.B5 VRAM6.B10 VRAM6.C1 VRAM6.C4 VRAM6.C11 VRAM6.C14 VRAM6.E1 VRAM6.E5 VRAM6.E10 VRAM6.E14 VRAM6.F4 VRAM6.F11 VRAM6.H1 VRAM6.H2 VRAM6.H13 VRAM6.H14 VRAM6.J2 VRAM6.J13 VRAM6.K2 VRAM6.K13 VRAM6.L1 VRAM6.L2 VRAM6.L13 VRAM6.L14 VRAM6.N4 VRAM6.N11 VRAM6.P1 VRAM6.P5 VRAM6.P10 VRAM6.P14 VRAM6.T1 VRAM6.T4 VRAM6.T11 VRAM6.T14 VRAM6.U5 VRAM6.U10 VRAM6.V1 VRAM6.V14 VRAM7.A1 VRAM7.A14 VRAM7.B5 VRAM7.B10 VRAM7.C1 VRAM7.C4 VRAM7.C11 VRAM7.C14 VRAM7.E1 VRAM7.E5 VRAM7.E10 VRAM7.E14 VRAM7.F4 VRAM7.F11 VRAM7.H1 VRAM7.H2 VRAM7.H13 VRAM7.H14 VRAM7.J2 VRAM7.J13 VRAM7.K2 VRAM7.K13 VRAM7.L1 VRAM7.L2 VRAM7.L13 VRAM7.L14 VRAM7.N4 VRAM7.N11 VRAM7.P1 VRAM7.P5 VRAM7.P10 VRAM7.P14 VRAM7.T1 VRAM7.T4 VRAM7.T11 VRAM7.T14 VRAM7.U5 VRAM7.U10 VRAM7.V1 VRAM7.V14 VRAM8.A1 VRAM8.A14 VRAM8.B5 VRAM8.B10 VRAM8.C1 VRAM8.C4 VRAM8.C11 VRAM8.C14 VRAM8.E1 VRAM8.E5 VRAM8.E10 VRAM8.E14 VRAM8.F4 VRAM8.F11 VRAM8.H1 VRAM8.H2 VRAM8.H13 VRAM8.H14 VRAM8.J2 VRAM8.J13 VRAM8.K2 VRAM8.K13 VRAM8.L1 VRAM8.L2 VRAM8.L13 VRAM8.L14 VRAM8.N4 VRAM8.N11 VRAM8.P1 VRAM8.P5 VRAM8.P10 VRAM8.P14 VRAM8.T1 VRAM8.T4 VRAM8.T11 VRAM8.T14 VRAM8.U5 VRAM8.U10 VRAM8.V1 VRAM8.V14
FBVDDQ_SENSE: PR459.2 UG1.E52
FLIP_DP: R24.2 R672.2 U39.21
FLIP_EDP: R715.2 R716.2 U41.21
FLIP_TBT_CLK: R208.2 R823.2 U10.21
FP_FUSE_GPU: CG713.2 RG124.1 UG1.BD14 UG4.8(VOUT)
FRM_LCK#: Q14.3 RG27.2 UG1.BG2
FRM_LCK#_PANEL: CN10.20 Q14.1(EMITTER)
FRONT_L_SPK: C381.2 U17.23
FRONT_R_SPK: C361.2 U17.22
FVDDQ_SENSE_I: PR294.2 PR359.1
FVDDQ_SENSE_V: PR295.2 PR357.1 PR360.2
G1_FRONT: R952.2 R953.1 U20.11
G1_REAR: R971.1 R999.2 U22.11
G1_SUB: R443.1 R1039.2 U25.11
G2_FRONT: R968.2 R969.1 U20.12
G2_REAR: R954.1 R982.2 U22.12
G2_SUB: R442.1 R1038.2 U25.12
G5719LX2.5V: PL10.1 PU13.3
GC6_1V8_MAIN_EN: RG21.2 RG179.1 UG1.BE1 UG6.2 UG8.2
GC6FBEN: QG22.2 QG23.2 RG68.1 RG178.2 UG1.BB5 UG9.1 UG11.1
GC6FBEN_Q: QG24.3 R1094.1 R1163.2 R1164.1
GC6FBEN_Q_EC: QG25.3 R297.2 R1165.1
GFX_SCL: QG18.4 RG128.2 UG1.BJ8
GFX_SDA: QG18.1(S) RG135.2 UG1.BH8
GLS_LED_CTL_B: Q20.2 R117.2 U4.31
GLS_LED_CTL_G: Q21.2 R121.2 U4.30
GLS_LED_CTL_R: Q21.5 R124.2 U4.27
GLS_LED_EN_B: CN9.6 D16.1 Q20.3
GLS_LED_EN_G: CN9.5 D19.1 Q21.6
GLS_LED_EN_R: CN9.4 D17.1 Q21.3
GLS_LED_PWR: C10.1 CN9.1 CN9.2 D20.1 Q23.3 R152.1
GLS_LED_PWR_CTL: Q23.2 R145.2 U4.26
GPIO18_IFPE_HPD: QG6.3 RG24.2 UG1.BE3
GPIO18_IFPE_HPD_Q: QG6.2 RG22.1 RG23.1
GPIO22_SWAPRDY_IN: RG11.1 UG1.BB6
GPIO23_RASTER_SYNC1: RG26.2 UG1.BG3
GPIO24_IFPF_HPD: Q64.2 Q78.2 R440.2 R526.1 R1074.2 R1083.2
GPIO24_IFPF_HPD_PCH: Q78.3 R239.2 RG196.1
GPIO26_FP_FUSE: RG125.1 UG1.BE7 UG4.4
GPIO27_IFPC_HPD: QG4.3 RG12.2 UG1.BA4
GPIO27_IFPE_HPD_Q: QG4.2 RG9.1 RG10.1
GPIO28_OC_WARN#: PR351.2 RG7.2 RG8.2 UG1.BB4
GPIO29_IDLE_IN_SW: RG14.2 UG1.BA3
GPP_B2: R579.1 R620.1 U14.BE32
GPP_B15: TP108.1 U14.BB26
GPP_C11: R1059.2 U14.AP24
GPP_G3: R441.1 U14.BF9
GPP_H21: R895.1 U14.AH48
GPP_I14: R239.1 U14.AM7
GPP_J0: R946.1 U14.AV6
GPP_J1: Q34.2 R383.2 U14.AY3
GPP_J8: R384.1 U14.AW2
GPP_J9: R404.1 R416.2 R914.1 U14.AU9
GPP_J10: R998.1 U14.AV7
GPP_K21: R852.2 R856.1 U14.T45
GPU_ADC_INN: CG869.2 PR339.1 UG1.BJ11
GPU_ADC_INP: CG865.2 PR338.1 UG1.BJ9
GPU_CLK: C499.2 UG1.BE17
GPU_CLK#: C498.2 UG1.BF17
GPU_CLK#_C: C498.1 U34.48
GPU_CLK_C: C499.1 U34.47
GPU_D0: C504.2 UG1.BG18
GPU_D0#: C503.2 UG1.BF18
GPU_D0#_C: C503.1 U34.45
GPU_D0_C: C504.1 U34.44
GPU_D1: C506.2 UG1.BH20
GPU_D1#: C505.2 UG1.BG20
GPU_D1#_C: C505.1 U34.42
GPU_D1_C: C506.1 U34.41
GPU_D2: C510.2 UG1.BE20
GPU_D2#: C507.2 UG1.BF20
GPU_D2#_C: C507.1 U34.39
GPU_D2_C: C510.1 U34.38
GPU_DDCCLK: R676.1 R677.1 R682.1 RG57.2 UG1.BK9
GPU_DDCCLK_Q: R656.2 R681.1 R682.2 U34.34
GPU_DDCDATA: R678.1 R679.2 R683.1 RG56.1 UG1.BL9
GPU_DDCDATA_Q: R655.2 R683.2 R684.1 U34.33
GPU_GPIO24_IFPF_HPD: Q64.3 RG130.2 RG133.1 UG1.BD5
GPU_IFPB_I2C_SCL: QG14.4 QG20.4 RG54.1 RG58.2 UG1.BH12
GPU_IFPB_I2C_SDA: QG14.1(S) QG20.1(S) RG59.2 RG66.1 UG1.BG12
GPU_TBT_AUXN: C230.1 C731.2 RG170.2 UG1.BH11
GPU_TBT_AUXP: C233.1 C737.2 RG166.2 UG1.BG11
GPU_TBT_D0: C167.1 UG1.BG24
GPU_TBT_D0#: C172.1 UG1.BF24
GPU_TBT_D1: C182.1 UG1.BE23
GPU_TBT_D1#: C187.1 UG1.BF23
GPU_TBT_D2: C193.1 UG1.BH23
GPU_TBT_D2#: C201.1 UG1.BG23
GPU_TBT_D3: C203.1 UG1.BG21
GPU_TBT_D3#: C208.1 UG1.BF21
GPU_THROTTING#: DG2.1(CATHODE) PR291.2 RG15.1 RG16.2
GPU_TSENSE: PR220.1 PR223.1 PR226.2 PR229.2 PR232.2 PR235.2 PR238.2 PR241.2 PR520.2
GPU_USB_I2C_SCL: Q63.1(S) Q65.4 RG131.2 RG134.1 UG1.BB8
GPU_USB_I2C_SDA: Q63.4 Q65.1(S) RG129.1 RG132.2 UG1.BB7
GPU_USB_L0+: C835.2 UG1.BA2
GPU_USB_L0-: C834.2 UG1.BA1
GPU_USB_L1+: C856.2 UG1.BA8
GPU_USB_L1-: C857.2 UG1.BA7
GPUEVENT#: DG1.2 RG19.2 UG1.BD1
GPUEVENT#_PCH: DG1.1(CATHODE) U14.BD30
GPUT_CLK: QG18.3 R274.2
GPUT_DATA: QG18.6 R275.2
GSPI0_MOSI: R1095.1 R1126.2 U14.BE30
GSPI1_MOSI: R1036.1 R1096.2 U14.BA26
H_CPU_SVIDALRT#: R35.1 U3.BH31
H_CPU_SVIDDAT: R41.1 R42.2 U3.BH29
H_PM_DOWN: R57.1 U14.AE2
H_PM_DOWN_R: R57.2 U3.BP31
H_PRDY#: R234.2 U3.BP27
H_PRDY#_L: R234.1 R345.2 U14.AM5
H_PREQ#: R76.2 R233.2 U3.BL30
H_PREQ#_L: R233.1 U14.AL2
H_PROCHOT#: C60.2 PR22.2 PR25.2 PR484.2 Q29.3 R67.2 R68.1
H_PROCHOT#_CPU: EC1.2 R68.2 U3.BR30
H_PROCHOT#_R: PQ52.2 PQ53.2 PR194.1 PR197.1 PR507.1 PU23.10
H_TCK: R69.2 R248.2 U3.BR28
H_TDI: R73.2 R244.2 U3.BL32
H_TDO: R72.2 R188.2 U3.BT28
H_TMS: R71.2 R264.2 U3.BP28
H_TRST#: R65.2 R346.2 U3.BP30
H_TRST#_L: R346.1 R364.2 U14.AM4
H_VCCST_PWRGD: C92.1 Q16.6 R107.2 R108.1
HDMI_HPD: C9.1 CN1.19 RV1.1 U34.21
HDMI_HPD_DC: R15.1 R20.2 U34.40
HDMI_HPD_PCH: CG38.1 Q70.6 R20.1 R783.2 RG9.2
HDMI_HPD_PCH_R: Q70.1(S) R798.1 U14.AP9
HDMI_RST#: C525.2 R657.2 U34.35
HDMI_SCLK: CN1.15 R10.2 R675.2 RV4.1 U34.7
HDMI_SDATA: CN1.16 R11.2 R674.2 RV3.1 U34.8
HDMI_SEL#_A1: R659.2 U34.32
HOLLD#_7: RG72.2 UG2.7
HP-L1: CN17.2 U17.46
HP-R1: CN17.3 U17.45
HP_JD#_EC: CN17.4 R565.2 U18.80
HP_JD#_EC_CODEC: Q53.2 R401.2 R623.1
HPD_2PL: TP12.1 UG1.BG1
HPD_IFPD: QG8.3 RG29.2 UG1.BH1
HPD_TBT: QG7.3 RG28.2 UG1.BG4
HRESET: R854.1 R998.2 U13.44
HWPG: D33.2 D35.2 D37.2 D38.2 D106.2 R104.1 R368.1 U18.21
HWPG_1.8VS5: D33.1(CATHODE) PR415.1 PR416.2
HWPG_1VS5: D35.1(CATHODE) PR386.2 PU29.1
HWPG_2.5V: D38.1(CATHODE) PR149.2 PR150.1 PR367.1
HWPG_VDDR: D106.1(CATHODE) PR366.2 PR373.1
I2C0_SCL: R451.1 R585.1 U14.BC22
I2C0_SDA: R438.1 R600.1 U14.BF23
I2C1_SCL: EC6.2 R996.1 R1057.1 U14.BE21
I2C1_SDA: R483.1 R997.1 U14.BF21
I2C_EN_DP: R25.2 R26.2 U39.17
I2C_EN_EDP: R111.2 R112.2 U41.17
I2C_EN_TBT: R815.2 R817.2 U10.17
I2C_SEL_PIN: R658.2 U34.31
I2C_TP_SCL_R: CN19.9 D74.1 Q48.1(S) R558.2 R570.1
I2C_TP_SDA_R: CN19.8 D73.1 Q48.4 R568.1 R599.2
I2CB_SCL_G: RG138.2 UG1.BG8
I2CB_SDA_G: RG140.2 UG1.BF8
I2CC_SCL_GFX: QG10.4 RG40.2 UG1.BG9
I2CC_SDA_GFX: QG10.1(S) RG39.2 UG1.BH9
I2S2_RXD: R1117.2 U14.AW18
I2S2_SCLK: R1118.2 U14.AV18
ICMNT: C422.2 PC187.2 PR254.1 PR488.2 U18.67
IFPAB_RSET: RG152.2 UG1.BD23
IFPB_I2C_SCL: QG14.3 R425.2 R1005.2 R1013.1 RG54.2
IFPB_I2C_SDA: QG14.6 R986.2 R1001.2 R1046.1 RG66.2
IFPC_RSET: RG144.2 UG1.BD20
IFPEF_RSET: RG148.2 UG1.BD17
IFPF_AUX+: CG68.1 CG78.1 RG169.2 UG1.BM8
IFPF_AUX-: CG68.2 CG79.1 RG168.2 UG1.BM9
IFPF_L0+: CG75.1 UG1.BL14
IFPF_L0-: CG76.1 UG1.BK14
IFPF_L1+: CG74.1 UG1.BK12
IFPF_L1-: CG73.1 UG1.BL12
IFPF_L2+: CG72.1 UG1.BM12
IFPF_L2-: CG71.1 UG1.BM11
IFPF_L3+: CG70.1 UG1.BL11
IFPF_L3-: CG69.1 UG1.BK11
ILIM_4PH_A: PR447.2 PU2.7
ILIM_HI1: R181.1 U8.16
ILIM_HI2: R229.1 U11.16
ILIM_HI3: R1029.1 U26.16
ILIM_LO1: R180.1 U8.15
ILIM_LO2: R228.1 U11.15
ILIM_LO3: R1030.2 U26.15
IMVP_PWRGD: PR429.2 PR436.2 Q6.2 R1019.2 U42.2
INT_DP_AUXN: QG12.4 RG53.2 UG1.BL8
INT_DP_AUXN_Q: C512.2 Q57.3 QG12.3
INT_DP_AUXP: QG12.1(S) RG52.2 UG1.BK8
INT_DP_AUXP_Q: C521.2 Q60.3 QG12.6
INT_EDP_AUXN: C639.1 RG156.2 UG1.BF11
INT_EDP_AUXP: C640.1 RG149.2 UG1.BE11
INT_EDP_TXN0: C681.1 UG1.BM17
INT_EDP_TXN0_R: C681.2 U41.10
INT_EDP_TXN1: C683.1 UG1.BK17
INT_EDP_TXN1_R: C683.2 U41.13
INT_EDP_TXN2: C685.1 UG1.BL15
INT_EDP_TXN2_R: C685.2 U41.16
INT_EDP_TXN3: C687.1 UG1.BM14
INT_EDP_TXN3_R: C687.2 U41.19
INT_EDP_TXP0: C680.1 UG1.BM18
INT_EDP_TXP0_R: C680.2 U41.9
INT_EDP_TXP1: C682.1 UG1.BL17
INT_EDP_TXP1_R: C682.2 U41.12
INT_EDP_TXP2: C684.1 UG1.BK15
INT_EDP_TXP2_R: C684.2 U41.15
INT_EDP_TXP3: C686.1 UG1.BM15
INT_EDP_TXP3_R: C686.2 U41.18
INT_ULT_DP_HPD: R22.1 R653.1 R670.2 U39.32
INT_ULT_EDP_HPD: R702.1 R703.1 R710.2 U41.32
ITP_PMODE: TP99.1 U14.AL3
JTAG_SEL: RG164.2 TPG69.1 UG1.BK23
JTAG_TCK: TPG4.1 UG1.BK24
JTAG_TDI: TPG3.1 UG1.BM23
JTAG_TDO: TPG5.1 UG1.BM24
JTAG_TMS: TPG6.1 UG1.BL23
JTAG_TRST#: RG42.2 UG1.BL24
KBL_DET#: C441.1 R538.1 TP52.1 U14.BF32
LAN_DIS#: TP119.1 U14.BF41
LAN_PWR#: R389.1 R824.2 R829.2
LANVCC: C776.1 C777.1 CN14.6 Q71.3
LANWAKE_N: R481.1 R543.1 U14.BG44
LCD_BL_PWM: Q17.2 RG150.1 UG1.BD7
LCD_BLEN: Q13.2 RG136.2 UG1.BA5
LCD_OD_EN#: Q4.2 R547.2
LCD_OD_EN_R: CN10.37 Q4.3 R33.1 R34.2
LCD_VDD: R699.1 RG160.2 UG1.BH3
LCDVCC: C650.1 C660.2 C669.1 C670.1 C671.2 C672.1 C673.2 C943.1 CN10.1 CN10.2 CN10.3 CN10.4 Q14.2 R93.1 R94.2 R100.1 R106.2 U40.1(OUT)
LID#: CN8.6 D14.1(CATHODE) D86.1 R80.2 R226.1
LID#_EC_L: C245.2 D31.1 R226.2 U18.118
LID#_MACRO: CN19.20 R298.1
LPC_LAD0: R179.2 R1079.2 U18.10
LPC_LAD0_C: CN16.58 R179.1
LPC_LAD1: R173.2 R1107.2 U18.9
LPC_LAD1_C: CN16.66 R173.1
LPC_LAD2: R168.2 R1087.2 U18.8
LPC_LAD2_C: CN16.68 R168.1
LPC_LAD3: R167.2 R1078.2 U18.7
LPC_LAD3_C: CN16.70 R167.1
LPC_LFRAME#: R176.2 U14.BE38 U18.6
LPC_LFRAME#_C: CN16.62 R176.1
LPC_PIRQAB: R1123.2 U14.BA36
M_A_A0: JDIM2.144 JDIM4.144 U3.AH3
M_A_A1: JDIM2.133 JDIM4.133 U3.AP4
M_A_A2: JDIM2.132 JDIM4.132 U3.AN4
M_A_A3: JDIM2.131 JDIM4.131 U3.AP5
M_A_A4: JDIM2.128 JDIM4.128 U3.AP2
M_A_A5: JDIM2.126 JDIM4.126 U3.AP1
M_A_A6: JDIM2.127 JDIM4.127 U3.AP3
M_A_A7: JDIM2.122 JDIM4.122 U3.AN1
M_A_A8: JDIM2.125 JDIM4.125 U3.AN3
M_A_A9: JDIM2.121 JDIM4.121 U3.AT4
M_A_A10: JDIM2.146 JDIM4.146 U3.AH2
M_A_A11: JDIM2.120 JDIM4.120 U3.AN2
M_A_A12: JDIM2.119 JDIM4.119 U3.AU4
M_A_A13: JDIM2.158 JDIM4.158 U3.AE3
M_A_A14: JDIM2.151 JDIM4.151 U3.AG4
M_A_A15: JDIM2.156 JDIM4.156 U3.AD1
M_A_A16: JDIM2.152 JDIM4.152 U3.AH4
M_A_BG#0: JDIM2.115 JDIM4.115 U3.AU1
M_A_BG#1: JDIM2.113 JDIM4.113 U3.AU2
M_A_BS#0: JDIM2.150 JDIM4.150 U3.AH5
M_A_BS#1: JDIM2.145 JDIM4.145 U3.AH1
M_A_CB0: JDIM2.92 JDIM4.87 U3.BA2
M_A_CB1: JDIM2.88 JDIM4.91 U3.BA1
M_A_CB2: JDIM2.101 JDIM4.104 U3.AY4
M_A_CB3: JDIM2.100 JDIM4.105 U3.AY5
M_A_CB4: JDIM2.91 JDIM4.88 U3.BA5
M_A_CB5: JDIM2.87 JDIM4.92 U3.BA4
M_A_CB6: JDIM2.104 JDIM4.101 U3.AY1
M_A_CB7: JDIM2.105 JDIM4.100 U3.AY2
M_A_CKE0: JDIM2.109 U3.AT1
M_A_CKE1: JDIM2.110 U3.AT2
M_A_CKE2: JDIM4.109 U3.AT3
M_A_CKE3: JDIM4.110 U3.AT5
M_A_CS#0: JDIM2.149 U3.AD5
M_A_CS#1: JDIM2.157 U3.AE2
M_A_CS#2: JDIM4.149 U3.AD2
M_A_CS#3: JDIM4.157 U3.AE5
M_A_DIM0_CLKN0: JDIM2.139 U3.AG2
M_A_DIM0_CLKN1: JDIM2.140 U3.AK1
M_A_DIM0_CLKP0: JDIM2.137 U3.AG1
M_A_DIM0_CLKP1: JDIM2.138 U3.AK2
M_A_DIM1_CLKN0: JDIM4.139 U3.AK3
M_A_DIM1_CLKN1: JDIM4.140 U3.AL1
M_A_DIM1_CLKP0: JDIM4.137 U3.AL3
M_A_DIM1_CLKP1: JDIM4.138 U3.AL2
M_A_DQ0: JDIM2.7 JDIM4.4 U3.BR6
M_A_DQ1: JDIM2.16 JDIM4.21 U3.BT6
M_A_DQ2: JDIM2.20 JDIM4.17 U3.BP3
M_A_DQ3: JDIM2.3 JDIM4.8 U3.BR3
M_A_DQ4: JDIM2.8 JDIM4.3 U3.BN5
M_A_DQ5: JDIM2.4 JDIM4.7 U3.BP6
M_A_DQ6: JDIM2.17 JDIM4.20 U3.BP2
M_A_DQ7: JDIM2.21 JDIM4.16 U3.BN3
M_A_DQ8: JDIM2.28 JDIM4.25 U3.BL4
M_A_DQ9: JDIM2.24 JDIM4.29 U3.BL5
M_A_DQ10: JDIM2.37 JDIM4.42 U3.BL2
M_A_DQ11: JDIM2.41 JDIM4.38 U3.BM1
M_A_DQ12: JDIM2.29 JDIM4.24 U3.BK4
M_A_DQ13: JDIM2.25 JDIM4.28 U3.BK5
M_A_DQ14: JDIM2.42 JDIM4.37 U3.BK1
M_A_DQ15: JDIM2.38 JDIM4.41 U3.BK2
M_A_DQ16: JDIM2.46 JDIM4.49 U3.BG4
M_A_DQ17: JDIM2.50 JDIM4.45 U3.BG5
M_A_DQ18: JDIM2.58 JDIM4.63 U3.BF4
M_A_DQ19: JDIM2.62 JDIM4.59 U3.BF5
M_A_DQ20: JDIM2.45 JDIM4.50 U3.BG2
M_A_DQ21: JDIM2.49 JDIM4.46 U3.BG1
M_A_DQ22: JDIM2.59 JDIM4.62 U3.BF1
M_A_DQ23: JDIM2.63 JDIM4.58 U3.BF2
M_A_DQ24: JDIM2.66 JDIM4.71 U3.BD2
M_A_DQ25: JDIM2.70 JDIM4.67 U3.BD1
M_A_DQ26: JDIM2.80 JDIM4.83 U3.BC4
M_A_DQ27: JDIM2.84 JDIM4.79 U3.BC5
M_A_DQ28: JDIM2.71 JDIM4.66 U3.BD5
M_A_DQ29: JDIM2.67 JDIM4.70 U3.BD4
M_A_DQ30: JDIM2.83 JDIM4.80 U3.BC1
M_A_DQ31: JDIM2.79 JDIM4.84 U3.BC2
M_A_DQ32: JDIM2.174 JDIM4.169 U3.AB1
M_A_DQ33: JDIM2.170 JDIM4.173 U3.AB2
M_A_DQ34: JDIM2.187 JDIM4.182 U3.AA4
M_A_DQ35: JDIM2.183 JDIM4.186 U3.AA5
M_A_DQ36: JDIM2.169 JDIM4.174 U3.AB5
M_A_DQ37: JDIM2.173 JDIM4.170 U3.AB4
M_A_DQ38: JDIM2.182 JDIM4.187 U3.AA2
M_A_DQ39: JDIM2.186 JDIM4.183 U3.AA1
M_A_DQ40: JDIM2.191 JDIM4.194 U3.V5
M_A_DQ41: JDIM2.190 JDIM4.195 U3.V2
M_A_DQ42: JDIM2.208 JDIM4.203 U3.U1
M_A_DQ43: JDIM2.204 JDIM4.207 U3.U2
M_A_DQ44: JDIM2.194 JDIM4.191 U3.V1
M_A_DQ45: JDIM2.195 JDIM4.190 U3.V4
M_A_DQ46: JDIM2.207 JDIM4.204 U3.U5
M_A_DQ47: JDIM2.203 JDIM4.208 U3.U4
M_A_DQ48: JDIM2.225 JDIM4.228 U3.R2
M_A_DQ49: JDIM2.229 JDIM4.224 U3.P5
M_A_DQ50: JDIM2.215 JDIM4.212 U3.R4
M_A_DQ51: JDIM2.216 JDIM4.211 U3.P4
M_A_DQ52: JDIM2.211 JDIM4.216 U3.R5
M_A_DQ53: JDIM2.228 JDIM4.225 U3.P2
M_A_DQ54: JDIM2.212 JDIM4.215 U3.R1
M_A_DQ55: JDIM2.224 JDIM4.229 U3.P1
M_A_DQ56: JDIM2.237 JDIM4.232 U3.M4
M_A_DQ57: JDIM2.232 JDIM4.237 U3.M1
M_A_DQ58: JDIM2.246 JDIM4.249 U3.L4
M_A_DQ59: JDIM2.245 JDIM4.250 U3.L2
M_A_DQ60: JDIM2.233 JDIM4.236 U3.M5
M_A_DQ61: JDIM2.236 JDIM4.233 U3.M2
M_A_DQ62: JDIM2.250 JDIM4.245 U3.L5
M_A_DQ63: JDIM2.249 JDIM4.246 U3.L1
M_A_DQSN0: JDIM2.11 JDIM4.11 U3.BR5
M_A_DQSN1: JDIM2.32 JDIM4.32 U3.BL3
M_A_DQSN2: JDIM2.53 JDIM4.53 U3.BG3
M_A_DQSN3: JDIM2.74 JDIM4.74 U3.BD3
M_A_DQSN4: JDIM2.177 JDIM4.177 U3.AA3
M_A_DQSN5: JDIM2.198 JDIM4.198 U3.U3
M_A_DQSN6: JDIM2.219 JDIM4.219 U3.P3
M_A_DQSN7: JDIM2.240 JDIM4.240 U3.L3
M_A_DQSN8: JDIM2.95 JDIM4.95 U3.BA3
M_A_DQSP0: JDIM2.13 JDIM4.13 U3.BP5
M_A_DQSP1: JDIM2.34 JDIM4.34 U3.BK3
M_A_DQSP2: JDIM2.55 JDIM4.55 U3.BF3
M_A_DQSP3: JDIM2.76 JDIM4.76 U3.BC3
M_A_DQSP4: JDIM2.179 JDIM4.179 U3.AB3
M_A_DQSP5: JDIM2.200 JDIM4.200 U3.V3
M_A_DQSP6: JDIM2.221 JDIM4.221 U3.R3
M_A_DQSP7: JDIM2.242 JDIM4.242 U3.M3
M_A_DQSP8: JDIM2.97 JDIM4.97 U3.AY3
M_A_ODT0: JDIM2.155 U3.AD3
M_A_ODT1: JDIM2.161 U3.AE4
M_A_ODT2: JDIM4.155 U3.AE1
M_A_ODT3: JDIM4.161 U3.AD4
M_B_A0: JDIM1.144 JDIM3.144 U3.AJ9
M_B_A1: JDIM1.133 JDIM3.133 U3.AK6
M_B_A2: JDIM1.132 JDIM3.132 U3.AK5
M_B_A3: JDIM1.131 JDIM3.131 U3.AL5
M_B_A4: JDIM1.128 JDIM3.128 U3.AL6
M_B_A5: JDIM1.126 JDIM3.126 U3.AM6
M_B_A6: JDIM1.127 JDIM3.127 U3.AN7
M_B_A7: JDIM1.122 JDIM3.122 U3.AN10
M_B_A8: JDIM1.125 JDIM3.125 U3.AN8
M_B_A9: JDIM1.121 JDIM3.121 U3.AR11
M_B_A10: JDIM1.146 JDIM3.146 U3.AH7
M_B_A11: JDIM1.120 JDIM3.120 U3.AN11
M_B_A12: JDIM1.119 JDIM3.119 U3.AR10
M_B_A13: JDIM1.158 JDIM3.158 U3.AF9
M_B_A14: JDIM1.151 JDIM3.151 U3.AH11
M_B_A15: JDIM1.156 JDIM3.156 U3.AF8
M_B_A16: JDIM1.152 JDIM3.152 U3.AH10
M_B_BG#0: JDIM1.115 JDIM3.115 U3.AR9
M_B_BG#1: JDIM1.113 JDIM3.113 U3.AR7
M_B_BS#0: JDIM1.150 JDIM3.150 U3.AH8
M_B_BS#1: JDIM1.145 JDIM3.145 U3.AH9
M_B_CB0: JDIM1.105 JDIM3.100 U3.AW11
M_B_CB1: JDIM1.92 JDIM3.87 U3.AY11
M_B_CB2: JDIM1.87 JDIM3.92 U3.AY8
M_B_CB3: JDIM1.100 JDIM3.105 U3.AW8
