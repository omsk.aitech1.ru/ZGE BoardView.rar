# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R77  49.9_1%_4  [R0402]  163.9 121.86 180 top
R78  49.9_1%_6  [R0603]  166.08 119.78 270 top
R79  *1K_1%_4  [R0402]  163.92 118.48 180 top
R80  *100K_5%_4  [R0402]  176.04 118.28 270 top
R81  *1K_1%_4  [R0402]  163.92 117.46 180 top
R82  10K_1%_2  [R0201]  176.04 117.01 180 top
R83  *4.7K_1%_4  [R0402]  168.75 116.96 90 top
R84  *1K_1%_4  [R0402]  163.92 116.43 180 top
R85  *360_1%_6  [R0603]  166.84 116.25 180 top
R86  1K_5%_2  [R0201]  180.49 115.74 0 top
R87  100K_1%_4  [R0402]  178.71 114.85 0 top
R88  100K_1%_4  [R0402]  164 114.19 0 top
R89  *short_0402  [S0402]  180.99 113.2 0 top
R90  10K_1%_4  [R0402]  163.97 113.15 0 top
R91  *10_5%_4  [R0402]  180.99 112.18 0 top
R92  100K_1%_4  [R0402]  166.31 111.32 0 top
R93  1K_1%_4  [R0402]  180.99 111.17 0 top
R94  10K_1%_2  [R0201]  180.87 110.15 0 top
R95  10K_1%_4  [R0402]  166.69 109.87 270 top
R96  10K_1%_4  [R0402]  167.91 108.73 270 top
R97  *0_5%_4  [R0402]  166.46 107.69 90 top
R98  *10K_1%_4  [R0402]  165.48 107.66 270 top
R99  121_1%_4  [R0402]  113.94 105.71 0 top
R100  1K_1%_4  [R0402]  179.98 105.45 270 top
R101  4.7K_1%_4  [R0402]  108.31 105.23 180 top
R102  24.9/F_4  [R0402]  113.94 104.56 180 top
R103  *0_5%_4  [R0402]  104.61 104.54 90 top
R104  *short_0402  [S0402]  105.63 104.54 90 top
R105  75_1%_4  [R0402]  113.94 103.42 180 top
R106  10K_1%_2  [R0201]  179.81 103.24 270 top
R107  60.4/F_4  [R0402]  105.63 102.81 270 top
R108  1K_1%_4  [R0402]  104.61 102.78 270 top
R109  100_1%_4  [R0402]  113.94 102.28 0 top
R110  *short_0603  [S0603]  111.52 100.67 270 top
R111  *1K_1%_4  [R0402]  175.25 86 270 top
R112  1K_1%_4  [R0402]  175.28 88.15 270 top
R113  1K_1%_4  [R0402]  176.29 88.15 270 top
R114  *1K_1%_4  [R0402]  177.31 88.15 270 top
R115  1K_1%_4  [R0402]  178.33 88.15 270 top
R116  *1K_1%_4  [R0402]  179.34 88.15 270 top
R117  100K_1%_4  [R0402]  7.46 71.26 270 top
R118  4.7K_5%_4  [R0402]  9.01 69.89 270 top
R119  4.7K_5%_4  [R0402]  10.51 69.89 90 top
R120  4.7K_5%_4  [R0402]  11.68 69.88 90 top
R121  100K_1%_4  [R0402]  7.03 67.76 270 top
R122  4.7K_1%_4  [R0402]  9.32 65.83 90 top
R123  4.7K_1%_4  [R0402]  10.33 65.83 90 top
R124  100K_1%_4  [R0402]  7.08 65.75 90 top
R125  *short_0805  [S0805]  12.46 63.16 180 top
R126  *100K_1%_4  [R0402]  267.87 58.99 180 top
R127  100K_1%_4  [R0402]  263.89 58.94 0 top
R128  100K_1%_4  [R0402]  261.87 58.94 180 top
R129  *0_5%_4  [R0402]  258.96 59.35 90 top
R130  *0_5%_4  [R0402]  252.02 58.14 0 bottom
R131  100K_1%_4  [R0402]  260 59.35 270 top
R132  2.2K_5%_4  [R0402]  261.21 58.55 0 bottom
R133  2.2K_5%_4  [R0402]  262.93 58.6 180 bottom
R134  *10K_1%_2  [R0201]  257.42 58.97 270 top
R135  10K_1%_2  [R0201]  258.13 58.97 270 top
R136  10K_1%_2  [R0201]  270.12 58.97 90 top
R137  *10K_1%_2  [R0201]  270.89 58.46 90 top
R138  *10K_1%_2  [R0201]  271.6 58.46 90 top
R139  *short_0402  [S0402]  272.81 58.46 0 top
R140  *10K_1%_2  [R0201]  254.02 57.95 90 top
R141  *0_1%_6  [R0603]  281.07 57.45 270 top
R142  *short_0603  [S0603]  282.59 57.45 270 top
R143  100K_1%_4  [R0402]  252.24 56.68 0 top
R144  100K_1%_4  [R0402]  254.4 56.68 0 top
R145  *4.7K_5%_4  [R0402]  7.11 55.95 270 top
R146  *short_0805  [S0805]  193.82 55.84 0 top
R147  100K_1%_4  [R0402]  254.4 55.67 0 top
R148  1M_1%_4  [R0402]  252.17 55.42 180 top
R149  *2.2K_5%_4  [R0402]  250.64 54.92 90 top
R150  *short_0402  [S0402]  254.4 54.65 180 top
R151  24.9_1%_4  [R0402]  179 54.65 270 top
R152  *short_0402  [S0402]  7.11 54.23 270 top
R153  *short_0402  [S0402]  252.18 54.44 180 top
R154  *short_0402  [S0402]  254.4 53.51 180 top
R155  *short_0402  [S0402]  278.15 53.38 0 top
R156  10K_1%_4  [R0402]  8.78 53 90 top
R157  1M_1%_4  [R0402]  270.91 53 90 top
R158  1M_1%_4  [R0402]  272.18 53 90 top
R159  *short_0603  [S0603]  199.16 52.94 180 top
R160  *100K_1%_4  [R0402]  210.46 52.87 0 top
R161  100K_1%_2  [R0201]  20.47 52.43 180 top
R162  *0_5%_2  [R0201]  208.96 52.97 180 top
R163  *short_0402  [S0402]  278.15 51.35 0 top
R164  2_1%_6  [R0603]  180.22 51.16 90 top
R165  10K_1%_2  [R0201]  13.49 50.91 90 top
R166  10K_1%_2  [R0201]  15.31 50.49 0 top
R167  *short_0402  [S0402]  51.64 50.17 180 top
R168  *short_0402  [S0402]  53.36 50.13 180 top
R169  *short_0402  [S0402]  222.06 50.05 270 top
R170  *short_0402  [S0402]  221.04 49.98 270 top
R171  100_1%_4  [R0402]  210.71 49.19 0 top
R172  *short_0603  [S0603]  198.73 49.09 180 top
R173  *short_0402  [S0402]  53.54 49.01 180 top
R174  1K_1%_4  [R0402]  10.05 48.68 90 top
R175  *short_0402  [S0402]  49.8 48.56 0 top
R176  *short_0402  [S0402]  53.54 48.05 0 top
R177  *short_0603  [S0603]  198.73 47.67 180 top
R178  *short_0402  [S0402]  49.8 47.54 0 top
R179  *short_0402  [S0402]  53.54 47.08 180 top
R180  39K_1%_2  [R0201]  18.56 46.65 270 top
R181  20K_1%_2  [R0201]  19.32 46.65 270 top
R182  10K_1%_2  [R0201]  16.5 46.4 270 top
R183  10K_1%_2  [R0201]  17.27 46.4 270 top
R184  *10K_1%_4  [R0402]  49.6 46.52 0 top
R185  *short_0402  [S0402]  99.41 46.35 270 top
R186  *0_5%_4  [R0402]  100.4 46.24 270 top
R187  *short_0402  [S0402]  194.62 45.76 0 top
R188  *short_0402  [S0402]  188.89 45.73 270 top
R189  *51_5%_4  [R0402]  189.85 45.73 90 top
R190  48.7_4  [R0402]  196.76 45.71 0 top
R191  *10K_1%_4  [R0402]  49.6 45.51 0 top
R192  *short_0805  [S0805]  234.89 45.47 90 top
R193  *100K_1%_4  [R0402]  192.09 45.46 0 top
R194  100K_1%_2  [R0201]  19.98 45.33 180 top
R195  1K_1%_4  [R0402]  199.31 44.76 180 top
R196  *100K_1%_4  [R0402]  194.46 44.75 0 top
R197  *0_5%_4  [R0402]  196.8 44.65 0 top
R198  *0_5%_4  [R0402]  99.41 44.59 270 top
R199  *short_0402  [S0402]  100.37 44.26 270 top
R200  *short_0402  [S0402]  49.8 43.98 180 top
R201  *short_0402  [S0402]  194.58 43.78 180 top
R202  1K_1%_4  [R0402]  199.29 43.59 0 top
R203  48.7_4  [R0402]  196.81 43.56 180 top
R204  *4.7K_1%_4  [R0402]  52.38 43.3 270 top
R205  *short_0402  [S0402]  179.87 42.73 180 top
R206  1_1%_4  [R0402]  284.9 42.71 180 top
R207  48.7_4  [R0402]  196.77 42.57 180 top
R208  1K_1%_4  [R0402]  238.78 42.46 270 top
R209  1K_1%_4  [R0402]  239.79 42.46 270 top
R210  *1K_1%_4  [R0402]  240.81 42.46 270 top
R211  *0_5%_4  [R0402]  241.83 42.46 90 top
R212  100K_1%_4  [R0402]  242.97 42.46 270 top
R213  100K_1%_4  [R0402]  244.24 42.46 270 top
R214  113_1%_4  [R0402]  198.33 42.21 90 top
R215  22_1%_4  [R0402]  49.8 41.82 180 top
R216  1K_1%_4  [R0402]  179.87 41.74 180 top
R217  1_1%_4  [R0402]  284.9 41.7 180 top
R218  60.4_1%_4  [R0402]  199.31 41.51 90 top
R219  30_1%_4  [R0402]  196.78 41.5 180 top
R220  4.7K_1%_4  [R0402]  52.47 41.19 270 top
R221  *short_0402  [S0402]  83.33 41.19 0 top
R222  10K_1%_2  [R0201]  235.6 40.94 0 top
R223  *short_0402  [S0402]  237.13 40.94 180 top
R224  1K_1%_4  [R0402]  179.87 40.74 0 top
R225  10K_1%_4  [R0402]  49.83 40.61 0 top
R226  33_1%_2  [R0201]  73.55 40.48 0 top
R227  *short_0402  [S0402]  85.06 40.43 180 top
R228  39K_1%_2  [R0201]  17.14 40.4 180 top
R229  20K_1%_2  [R0201]  18.21 40.34 0 top
R230  10K_1%_2  [R0201]  70.13 40.15 180 top
R231  100K_1%_4  [R0402]  71.56 40.08 0 top
R232  *short_0402  [S0402]  193.36 40.04 270 top
R233  *short_0402  [S0402]  192.4 40.04 270 top
R234  *short_0402  [S0402]  191.44 40.02 270 top
R235  2.2_1%_6  [R0603]  82.62 39.92 0 top
R236  *0_5%_4  [R0402]  80.82 39.75 90 top
R237  4.7K_1%_2  [R0201]  77.97 39.73 90 top
R238  4.7K_1%_2  [R0201]  78.71 39.71 90 top
R239  *short_0402  [S0402]  189.23 40.91 180 top
R240  *100K_5%_2  [R0201]  79.98 39.64 90 top
R241  *100K_1%_4  [R0402]  233.12 39.59 180 top
R242  *100K_1%_4  [R0402]  231.03 39.56 0 top
R243  20K_1%_4  [R0402]  49.27 39.54 180 top
R244  *short_0402  [S0402]  197.33 39.2 0 top
R245  4.7K_1%_2  [R0201]  76.09 39.16 90 top
R246  4.7K_1%_2  [R0201]  76.82 39.16 90 top
R247  1M_1%_4  [R0402]  258.34 39.16 90 top
R248  *short_0402  [S0402]  198.92 39.13 270 top
R249  4.7K_5%_4  [R0402]  272.31 38.9 90 top
R250  4.7K_5%_4  [R0402]  273.32 38.9 90 top
R251  4.7K_5%_4  [R0402]  274.34 38.9 90 top
R252  *10K_1%_4  [R0402]  275.35 38.9 270 top
R253  4.7K_5%_4  [R0402]  276.37 38.9 90 top
R254  *0_5%_4  [R0402]  278.4 38.9 90 top
R255  *short_0402  [S0402]  279.42 38.9 90 top
R256  *10K_1%_4  [R0402]  233 38.63 0 top
R257  4.7K_1%_4  [R0402]  72.07 38.62 90 top
R258  *10K_1%_4  [R0402]  231.04 38.59 0 top
R259  *short_0201  [S0201]  70.18 38.55 270 top
R260  *0_5%_4  [R0402]  96.81 38.54 0 top
R261  10K_1%_2  [R0201]  84.85 38.52 90 top
R262  100K_1%_4  [R0402]  91.87 38.42 180 top
R263  22_1%_4  [R0402]  49.68 38.27 180 top
R264  *short_0402  [S0402]  197.33 38.24 0 top
R265  *0_5%_6  [R0603]  52.64 38.15 180 top
R266  33_1%_2  [R0201]  75.83 38.04 270 top
R267  *10K_1%_2  [R0201]  69.34 38.04 90 top
R268  100K_1%_4  [R0402]  62.29 37.98 270 top
R269  *short_0402  [S0402]  280.82 37.89 180 top
R270  *4.7K_1%_4  [R0402]  233.12 37.65 0 top
R271  *30K_5%_4  [R0402]  231.04 37.53 0 top
R272  *10K_1%_2  [R0201]  81.06 37.38 90 top
R273  10K_1%_2  [R0201]  82.5 37.38 90 top
R274  *short_0201  [S0201]  78.66 37.38 90 top
R275  *short_0201  [S0201]  77.84 37.34 90 top
R276  *10K_1%_2  [R0201]  81.77 37.3 90 top
R277  1K_1%_4  [R0402]  258.34 37.25 90 top
R278  *short_0402  [S0402]  280.82 36.87 180 top
R279  *10K_1%_4  [R0402]  233.09 36.68 0 top
R280  *short_0402  [S0402]  31.5 36.6 90 top
R281  *10K_1%_4  [R0402]  230.96 36.56 180 top
R282  CNV@100K_5%_4  [R0402]  54.98 36.55 90 top
R283  51_5%_4  [R0402]  199.27 36.11 90 top
R284  33_1%_2  [R0201]  69.11 36.06 0 top
R285  *10K_1%_4  [R0402]  280.82 35.86 0 top
R286  *0_5%_4  [R0402]  92.98 35.81 0 top
R287  100K_1%_4  [R0402]  62.7 35.8 180 top
R288  1K_1%_4  [R0402]  230.96 35.54 0 top
R289  1K_1%_4  [R0402]  233.09 35.54 180 top
R290  *10K_1%_2  [R0201]  95.9 35.47 180 top
R291  *10K_1%_4  [R0402]  256.69 35.47 0 top
R292  4.7K_5%_2  [R0201]  25.65 35.25 90 top
R293  47K_1%_2  [R0201]  26.36 35.25 90 top
R294  22_1%_2  [R0201]  27.32 35.25 270 top
R296  *short_0402  [S0402]  36.16 35.12 0 top
R297  *short_0402  [S0402]  67.48 34.99 180 top
R298  33_1%_2  [R0201]  65.55 34.88 90 top
R299  *10K_1%_4  [R0402]  280.82 34.84 180 top
R300  CNV@10K_5%_4  [R0402]  53.92 34.79 180 top
R301  22_1%_2  [R0201]  32.63 34.76 270 top
R302  22_1%_2  [R0201]  33.52 34.76 270 top
R303  1K_1%_4  [R0402]  230.93 34.48 0 top
R304  *short_0402  [S0402]  256.69 34.46 0 top
R305  10K_1%_4  [R0402]  233.09 34.45 180 top
R306  10K_1%_4  [R0402]  56.84 34.84 270 top
R307  4.7K_1%_2  [R0201]  85.11 34.33 90 top
R308  *4.7K_5%_4  [R0402]  57.81 34.83 90 top
R309  *4.7K_5%_4  [R0402]  58.78 34.39 90 top
R310  *4.7K_5%_4  [R0402]  59.75 34.39 90 top
R311  1M_5%_4  [R0402]  254.75 34.31 0 top
R312  4.7K_1%_2  [R0201]  86.25 34.26 0 top
R313  30_1%_4  [R0402]  197.95 34.2 270 top
R314  *0_5%_4  [R0402]  107.92 34.07 270 top
R315  *0_5%_4  [R0402]  105.98 34.06 90 top
R316  *short_0402  [S0402]  108.9 34.08 270 top
R317  *short_0402  [S0402]  109.92 34.08 270 top
R318  *short_0402  [S0402]  87.78 34.08 270 top
R319  *short_0402  [S0402]  238.14 34.18 0 top
R320  33_5%_4  [R0402]  240.23 34.08 0 top
R321  33_5%_4  [R0402]  242.08 34.08 180 top
R322  *short_0402  [S0402]  106.96 34.05 90 top
R323  *0_5%_4  [R0402]  110.95 34.05 270 top
R324  *short_0402  [S0402]  112.96 34 270 top
R325  *0_5%_4  [R0402]  111.94 34 270 top
R326  *short_0402  [S0402]  66.88 34 0 top
R327  *short_0402  [S0402]  284.5 33.95 180 top
R328  *100K_1%_4  [R0402]  234.59 33.92 90 top
R329  *short_0402  [S0402]  127.91 33.82 270 top
R330  *0_5%_4  [R0402]  129.05 33.82 270 top
R331  240_1%_4  [R0402]  138.7 33.82 90 top
R332  240_1%_4  [R0402]  139.72 33.82 90 top
R333  *1K_1%_4  [R0402]  140.86 33.82 270 top
R334  10K_1%_4  [R0402]  236.03 33.62 0 top
R335  *2.55K_1%_4  [R0402]  243.48 33.54 90 top
R336  470_1%_4  [R0402]  147.18 33.44 180 top
R337  1M_5%_4  [R0402]  254.75 33.29 0 top
R338  *10K_1%_4  [R0402]  231.09 33.26 180 top
R339  2.2_1%_6  [R0603]  64.09 33.12 180 top
R340  *1K_1%_4  [R0402]  240.23 33.06 180 top
R341  33_5%_4  [R0402]  242.1 32.98 180 top
R342  *short_0402  [S0402]  284.5 32.94 180 top
R343  10K_1%_4  [R0402]  233.19 32.81 180 top
R344  *0_5%_4  [R0402]  36.85 32.68 180 top
R345  *51_5%_4  [R0402]  199.29 32.67 180 top
R346  *short_0402  [S0402]  196.82 32.56 270 top
R347  *10K_1%_4  [R0402]  267.1 32.55 180 top
R348  *1K_1%_4  [R0402]  139.34 32.43 0 top
R349  *short_0402  [S0402]  256.69 32.43 0 top
R350  *4.7K_5%_4  [R0402]  60.24 32.17 270 top
R351  *10K_1%_4  [R0402]  189.5 32.17 270 top
R352  *short_0402  [S0402]  254.75 32.15 0 top
R353  *4.7K_5%_4  [R0402]  58.74 32 90 top
R354  *4.7K_5%_4  [R0402]  57.43 32.45 90 top
R355  *4.7K_1%_4  [R0402]  195.22 31.92 180 top
R356  2.2_1%_6  [R0603]  89.15 31.79 270 top
R357  *2.2_1%_6  [R0603]  64.51 31.53 180 top
R358  30_1%_4  [R0402]  199.31 31.61 0 top
R359  *10K_1%_4  [R0402]  267.1 31.54 0 top
R360  33_5%_4  [R0402]  233.19 31.33 0 top
R361  *short_0402  [S0402]  254.65 31.13 180 top
R362  *0_5%_6  [R0603]  50.08 30.85 90 top
R363  10K_1%_4  [R0402]  60.98 30.79 0 top
R364  *51_5%_4  [R0402]  199.34 30.52 180 top
R365  *short_0402  [S0402]  87.52 30.39 0 top
R366  20K_1%_4  [R0402]  196.36 30.37 180 top
R367  *short_0402  [S0402]  65.85 30.33 180 top
R368  10K_1%_2  [R0201]  51.4 30.32 270 top
R369  *short_0402  [S0402]  233.19 30.31 0 top
R370  *0_5%_4  [R0402]  254.65 30.01 0 top
R371  *short_0201  [S0201]  53.49 29.63 180 top
R372  33_5%_4  [R0402]  199.28 29.51 180 top
R373  *short_0402  [S0402]  36.85 29.4 180 top
R374  33_1%_2  [R0201]  88.97 29.38 180 top
R375  *100K_5%_4  [R0402]  252.11 29.38 270 top
R376  *100K_5%_4  [R0402]  253.13 29.38 270 top
R377  100K_1%_4  [R0402]  233.19 29.34 180 top
R378  *4.7K_1%_4  [R0402]  230.86 29.17 0 top
R379  *0_1%_6  [R0603]  245.79 29.99 0 top
R380  *0_5%_4  [R0402]  254.65 29 0 top
R381  *short_0201  [S0201]  53.49 28.87 180 top
R382  100K_1%_4  [R0402]  233.19 28.33 180 top
R383  *10K_1%_4  [R0402]  197 28.24 180 top
R384  *0_5%_4  [R0402]  199.28 28.24 0 top
R385  *100_1%_4  [R0402]  230.86 28.18 180 top
R386  *10K_1%_4  [R0402]  273.79 28.15 270 top
R387  *10K_1%_4  [R0402]  272.82 28.15 90 top
R388  *short_0402  [S0402]  87.55 27.97 0 top
R389  *short_0402  [S0402]  66.59 27.63 180 top
R390  *short_0201  [S0201]  53.49 27.19 180 top
R391  *short_0805  [S0805]  192.04 27.47 0 top
R392  2K_5%_4  [R0402]  38.91 27.3 90 top
R393  20K_1%_4  [R0402]  197.02 27.22 180 top
R394  100K_1%_4  [R0402]  246.14 26.99 180 top
R395  *0_5%_2  [R0201]  89.03 27.09 0 top
R396  220K_5%_4  [R0402]  266.9 26.92 180 top
R397  220K_5%_4  [R0402]  268.69 26.89 0 top
R398  220K_5%_4  [R0402]  260.62 26.84 180 top
R399  220K_5%_4  [R0402]  262.4 26.84 0 top
R400  *short_0201  [S0201]  14.98 26.66 90 top
R401  *short_0402  [S0402]  66.54 26.65 0 top
R402  *short_0201  [S0201]  53.49 26.48 180 top
R403  33_5%_4  [R0402]  199.31 26.46 180 top
R404  *0_5%_4  [R0402]  197 26.2 0 top
R405  *short_0402  [S0402]  253.76 26.2 180 top
R406  *short_0402  [S0402]  246.14 26.03 180 top
R407  1K_5%_4  [R0402]  38.5 25.95 180 top
R408  *0_5%_4  [R0402]  248.94 25.95 270 top
R409  2K_5%_4  [R0402]  18.56 25.57 270 top
R410  *100K_1%_4  [R0402]  90.32 25.19 90 top
R411  10M_5%_4  [R0402]  230.65 25.38 90 top
R412  *short_0402  [S0402]  66.56 25.36 180 top
R413  *short_0201  [S0201]  53.49 25.06 180 top
R414  1M_1%_4  [R0402]  259.61 25.31 0 top
R415  1K_5%_4  [R0402]  20.08 25.19 0 top
R416  *4.7K_1%_4  [R0402]  197 25.19 180 top
R417  *100K_1%_4  [R0402]  199.31 25.06 0 top
R418  *short_0402  [S0402]  246.14 25.06 0 top
R419  1K_5%_4  [R0402]  38.5 24.81 180 top
R420  *short_0402  [S0402]  66.89 24.4 0 top
R421  33_1%_2  [R0201]  88.56 24.22 180 top
R422  *short_0201  [S0201]  53.49 24.3 180 top
R423  1K_5%_4  [R0402]  20.08 24.04 0 top
R424  *0_5%_4  [R0402]  246.14 24.04 0 top
R425  *0_5%_4  [R0402]  254.91 23.92 180 top
R426  1K_1%_4  [R0402]  258.21 23.92 270 top
R427  2K_5%_4  [R0402]  38.5 23.82 0 top
R428  2K_5%_4  [R0402]  18.56 23.66 270 top
R429  100K_1%_4  [R0402]  89.55 23.41 270 top
R430  *short_0402  [S0402]  66.61 23.44 0 top
R431  *0_5%_4  [R0402]  40.25 23.31 90 top
R432  200_1%_4  [R0402]  199.31 23.28 0 top
R433  *short_0201  [S0201]  53.49 22.85 180 top
R434  *0_5%_4  [R0402]  246.14 23.03 180 top
R435  *short_0402  [S0402]  254.88 22.9 180 top
R436  4.7K_1%_4  [R0402]  230.65 22.71 90 top
R437  *short_0402  [S0402]  231.62 22.71 90 top
R438  2.2K_5%_4  [R0402]  197 22.39 0 top
R439  *short_0402  [S0402]  37.74 22.29 180 top
R440  *0_5%_2  [R0201]  89.45 22.18 0 top
R441  *10K_1%_4  [R0402]  199.31 22.14 0 top
R442  0_5%_4  [R0402]  19.83 22.01 270 top
R443  0_5%_4  [R0402]  20.85 22.01 270 top
R444  *short_0201  [S0201]  53.49 22.14 180 top
R445  *short_0402  [S0402]  246.14 22.07 180 top
R446  *10K_1%_2  [R0201]  90.65 21.73 0 top
R447  71.5K_1%_4  [R0402]  191.92 21.63 0 top
R448  *short_0402  [S0402]  254.91 21.5 180 top
R449  *short_0402  [S0402]  233.32 21.42 180 top
R450  33_1%_2  [R0201]  89.43 21.38 180 top
R451  2.2K_5%_4  [R0402]  197 21.38 0 top
R452  4.7K_1%_4  [R0402]  236.75 21.2 270 top
R453  *short_0402  [S0402]  237.77 21.2 270 top
R454  33_5%_4  [R0402]  238.77 21.2 90 top
R455  33_5%_4  [R0402]  239.94 20.98 90 top
R456  *1K_1%_4  [R0402]  240.92 21.2 270 top
R458  *short_0402  [S0402]  64.47 20.72 0 top
R459  *short_0805  [S0805]  40.53 20.62 90 top
R460  10K_1%_4  [R0402]  196.11 20.36 180 top
R461  *0_5%_4  [R0402]  35.71 20.29 90 top
R462  *4.7K_5%_4  [R0402]  49.45 20.29 270 top
R463  4.99K_1%_4  [R0402]  54.76 20.26 270 top
R464  100K_1%_4  [R0402]  66.55 21.27 0 top
R465  10K_1%_2  [R0201]  90.98 20.23 180 top
R466  100K_1%_4  [R0402]  254.91 20.21 0 top
R467  *10K_1%_4  [R0402]  56.38 20.16 0 top
R468  4.7K_1%_4  [R0402]  191.92 20.16 0 top
R469  *10K_1%_4  [R0402]  58.34 19.93 180 top
R470  *4.7K_5%_4  [R0402]  44.09 19.98 270 top
R471  *4.7K_5%_4  [R0402]  45.1 19.98 270 top
R472  *short_0402  [S0402]  50.41 19.85 270 top
R473  4.7K_1%_4  [R0402]  190.52 19.73 270 top
R474  10K_1%_4  [R0402]  223.31 19.59 270 top
R475  *SUB@0_5%_4  [R0402]  12.92 19.55 180 top
R476  100K_1%_4  [R0402]  214.14 19.54 270 top
R477  2.2K_5%_4  [R0402]  215.67 19.54 270 top
R478  2.2K_5%_4  [R0402]  216.63 19.54 270 top
R479  *short_0402  [S0402]  224.3 19.54 90 top
R480  *short_0402  [S0402]  225.3 19.54 90 top
R481  4.7K_1%_4  [R0402]  226.31 19.54 90 top
R482  10K_1%_2  [R0201]  90.95 19.5 180 top
R483  2.2K_5%_4  [R0402]  212.95 19.5 90 top
R484  *49.9K_1%_4  [R0402]  210.99 19.47 270 top
R485  *short_0402  [S0402]  257.45 19.47 0 top
R486  *short_0402  [S0402]  221.82 19.46 270 top
R487  *10K_1%_4  [R0402]  207.21 19.42 270 top
R488  33_5%_4  [R0402]  202.26 19.42 270 top
R489  33_5%_4  [R0402]  209.98 19.42 270 top
R490  10K_1%_4  [R0402]  219.22 19.42 90 top
R491  *short_0402  [S0402]  201.29 19.41 270 top
R492  33_5%_4  [R0402]  204.31 19.41 270 top
R493  1K_1%_4  [R0402]  205.28 19.41 90 top
R494  33_5%_4  [R0402]  206.25 19.41 270 top
R495  100K_1%_4  [R0402]  217.91 19.4 90 top
R496  33_5%_4  [R0402]  200.32 19.4 270 top
R497  iTPM@10K_1%_4  [R0402]  208.76 19.36 270 top
R498  10K_1%_4  [R0402]  196.11 19.22 180 top
R499  *10K_1%_4  [R0402]  56.38 19.14 180 top
R500  *short_0402  [S0402]  70.12 19.09 90 top
R501  *100K_1%_4  [R0402]  197.55 18.89 270 top
R502  0_5%_6  [R0603]  94.76 17.97 90 top
R503  *SUB@10K_1%_2  [R0201]  11.67 18.76 270 top
R504  SUB@0.1_1%_8  [R0805]  19.42 18.74 0 top
R505  *short_0402  [S0402]  246.14 18.71 180 top
R506  100K_1%_4  [R0402]  54.86 18.51 90 top
R507  *short_0402  [S0402]  257.45 18.46 0 top
R508  *short_0402  [S0402]  231.36 18.4 90 top
R509  M_KB@10K_1%_2  [R0201]  87.14 18.2 180 top
R510  M_KB@10K_1%_2  [R0201]  91.36 18.1 270 top
R511  10K_1%_2  [R0201]  10.43 17.9 180 top
R512  *4.7K_5%_4  [R0402]  44.09 17.82 270 top
R513  *4.7K_5%_4  [R0402]  45.36 17.82 270 top
R514  *short_0402  [S0402]  47.59 17.82 270 top
R515  *4.7K_5%_4  [R0402]  46.4 17.8 270 top
R516  *10K_1%_4  [R0402]  59.73 19.45 90 top
R517  *0_5%_2  [R0201]  80.9 17.6 90 top
R518  *0_5%_2  [R0201]  80.16 16.98 90 top
R519  4.7K_5%_4  [R0402]  65.3 17.44 0 top
R520  *short_0402  [S0402]  199.48 17.36 90 top
R521  *0_5%_4  [R0402]  246.14 17.19 270 top
R522  *short_0402  [S0402]  247.16 17.19 270 top
R523  *0_5%_4  [R0402]  248.18 17.19 270 top
R524  *4.7K_5%_4  [R0402]  249.19 17.19 270 top
R525  10K_1%_4  [R0402]  250.21 17.19 90 top
R526  *short_0402  [S0402]  251.22 17.19 270 top
R527  *0_5%_4  [R0402]  252.24 17.19 270 top
R528  *0_5%_4  [R0402]  254.27 17.19 90 top
R529  *2.2K_5%_4  [R0402]  255.54 17.19 90 top
R530  *short_0402  [S0402]  36.26 17.14 0 top
R531  *0_5%_4  [R0402]  228.75 17.05 180 top
R532  100K_1%_4  [R0402]  230.59 16.96 0 top
R533  *100K_1%_4  [R0402]  232.37 16.95 0 top
R534  10K_1%_4  [R0402]  227.35 16.81 90 top
R535  2.2K_5%_4  [R0402]  213.38 16.77 270 top
R536  *20K_1%_4  [R0402]  212.09 16.75 270 top
R537  2.2K_5%_4  [R0402]  214.4 16.75 270 top
R538  *100K_1%_4  [R0402]  218.84 16.75 90 top
R539  *10K_1%_4  [R0402]  219.96 16.75 270 top
R540  *short_0402  [S0402]  223.03 16.75 90 top
R541  *short_0402  [S0402]  225.29 16.75 90 top
R542  100K_1%_4  [R0402]  224.28 16.75 90 top
R543  *0_5%_4  [R0402]  226.31 16.75 90 top
R544  10K_1%_4  [R0402]  204.11 16.68 90 top
R545  *OP@10K_1%_4  [R0402]  222.07 16.68 270 top
R546  4.7K_1%_4  [R0402]  211.11 16.67 270 top
R547  *short_0402  [S0402]  203.02 16.65 270 top
R548  i7@10K_1%_4  [R0402]  205.13 16.62 270 top
R549  *dTPM@10K_1%_4  [R0402]  207.16 16.62 90 top
R550  33_5%_4  [R0402]  209.95 13.76 0 top
R551  33_5%_4  [R0402]  210.15 16.75 270 top
R552  *short_0402  [S0402]  216.56 16.62 90 top
R553  33_5%_4  [R0402]  208.93 17.4 270 top
R554  *i9@10K_1%_4  [R0402]  206.14 16.62 90 top
R555  *0_5%_4  [R0402]  240.05 16.55 0 top
R556  *short_0402  [S0402]  242.87 16.48 0 top
R557  *4.7K_5%_4  [R0402]  257.45 16.42 180 top
R558  *short_0402  [S0402]  89.36 16.02 0 top
R559  *4.7K_5%_4  [R0402]  277.22 15.86 90 top
R560  100K_1%_4  [R0402]  49.48 15.64 270 top
R561  4.99K_1%_4  [R0402]  278.56 15.57 180 top
R562  4.7K_5%_4  [R0402]  58.44 15.51 270 top
R563  4.7K_5%_4  [R0402]  257.47 15.46 0 top
R564  *2.2K_5%_4  [R0402]  251.66 15.41 180 top
R565  *short_0402  [S0402]  9.42 15.28 180 top
R566  1K_1%_4  [R0402]  236.81 15.03 0 top
R567  4.7K_5%_4  [R0402]  61.74 15.03 90 top
R568  *2.2K_5%_4  [R0402]  90.95 15 180 top
R569  10K_1%_4  [R0402]  246.09 14.6 270 top
R570  *2.2K_5%_4  [R0402]  87.22 14.55 90 top
R571  100K_1%_4  [R0402]  258.51 14.49 0 top
R572  *10K_1%_2  [R0201]  86.23 14.39 0 top
R573  *2.2K_5%_4  [R0402]  251.66 14.39 180 top
R574  *20K_1%_4  [R0402]  213.33 14.28 90 top
R575  4.7K_1%_4  [R0402]  212.34 14.28 270 top
R576  10K_1%_4  [R0402]  215.84 14.22 90 top
R577  *4.7K_1%_4  [R0402]  211.35 14.22 270 top
R578  *N-GS@10K_1%_4  [R0402]  219.99 14.21 90 top
R579  4.7K_1%_4  [R0402]  216.96 14.21 90 top
R580  10K_1%_4  [R0402]  217.95 14.21 90 top
R581  GS@10K_1%_4  [R0402]  218.96 14.19 90 top
R582  4.7K_5%_4  [R0402]  67.2 14.14 90 top
R583  *2.2K_5%_4  [R0402]  255.49 14.14 270 top
R584  *short_0402  [S0402]  84.85 14.01 180 top
R585  *short_0402  [S0402]  90.95 14.01 0 top
R586  100K_1%_4  [R0402]  205.63 14.01 90 top
R587  *0_5%_4  [R0402]  8.52 13.92 270 top
R588  4.7K_5%_4  [R0402]  71.27 13.76 270 top
R589  100K_1%_4  [R0402]  72.28 13.76 270 top
R590  100K_1%_4  [R0402]  76.35 13.76 270 top
R591  100K_1%_4  [R0402]  77.36 13.76 90 top
R592  100K_1%_4  [R0402]  81.43 13.76 270 top
R593  100K_1%_4  [R0402]  82.44 13.76 270 top
R594  200K_1%_4  [R0402]  11.7 13.5 270 top
R595  100K_1%_4  [R0402]  258.51 13.53 0 top
R596  4.7K_5%_4  [R0402]  65.3 13.38 180 top
R597  *short_0402  [S0402]  84.91 13 180 top
R598  *short_0402  [S0402]  86.71 13 0 top
R599  *short_0402  [S0402]  88.49 13 180 top
R600  *short_0402  [S0402]  90.95 12.97 0 top
R601  *short_0402  [S0402]  266.59 12.74 90 top
R603  *2.2K_5%_4  [R0402]  212.94 12.61 180 top
R604  10K_1%_2  [R0201]  7.38 12.61 0 top
R605  100K_1%_4  [R0402]  208.93 12.36 0 top
R606  *2.2K_5%_4  [R0402]  214.86 12.62 0 top
R607  *short_0402  [S0402]  282.52 12.95 180 top
R608  *short_0402  [S0402]  253.64 12.46 0 top
R609  *short_0402  [S0402]  206.77 11.94 180 top
R610  8.87K_1%_4  [R0402]  259.73 11.85 90 top
R613  *short_0402  [S0402]  282.52 11.93 180 top
R614  *short_0402  [S0402]  253.64 11.5 0 top
R615  *10K_1%_4  [R0402]  218.83 11.21 90 top
R616  DIS@10K_1%_4  [R0402]  219.81 11.2 90 top
R617  *10K_1%_4  [R0402]  217.85 11.21 90 top
R618  20K_5%_4  [R0402]  201.95 11.34 270 top
R619  20K_5%_4  [R0402]  203.88 11.34 270 top
R620  *0_5%_4  [R0402]  216.87 11.21 90 top
R621  *short_0201  [S0201]  280.56 10.96 0 top
R622  *10K_1%_4  [R0402]  266.59 10.96 90 top
R623  *10K_5%_4  [R0402]  7.03 10.58 270 top
R624  *0_5%_4  [R0402]  265.07 10.58 180 top
R625  *short_0402  [S0402]  253.64 10.53 0 top
R627  *short_0201  [S0201]  280.56 10.25 0 top
R628  14K_1%_4  [R0402]  260.09 10.02 270 top
R629  100K_1%_4  [R0402]  253.64 9.57 180 top
R630  *short_0402  [S0402]  255.54 9.57 0 top
R631  10K_1%_2  [R0201]  282.14 8.45 0 top
R632  *short_0402  [S0402]  57.78 165.58 180 bottom
R633  *short_0603  [S0603]  99.13 164.61 0 bottom
R634  *short_0402  [S0402]  57.78 164.57 180 bottom
R635  *short_0402  [S0402]  59.77 164.23 180 bottom
R636  *short_0402  [S0402]  59.77 163.22 180 bottom
R637  *short_0402  [S0402]  57.76 162.74 180 bottom
R638  *short_0402  [S0402]  57.76 161.72 180 bottom
R639  *short_0402  [S0402]  59.57 161.47 180 bottom
R640  1M_1%_4  [R0402]  81.71 161.46 180 bottom
R641  10K_1%_2  [R0201]  75.05 161.2 0 bottom
R642  10K_1%_2  [R0201]  73.93 161.18 180 bottom
R643  5.1M_5%_4  [R0402]  86.71 160.61 90 bottom
R644  *short_0402  [S0402]  59.57 160.45 180 bottom
R645  33_1%_2  [R0201]  42.15 159.96 180 bottom
R646  *short_0402  [S0402]  95.62 160.47 90 bottom
R647  *4.7K_1%_4  [R0402]  89.05 159.81 180 bottom
R648  *4.7K_5%_4  [R0402]  55.82 159.35 180 bottom
R649  4.7K_1%_4  [R0402]  89.02 158.79 180 bottom
R650  100K_5%_4  [R0402]  83.99 158.79 180 bottom
R651  *short_0603  [S0603]  98.07 157.91 0 bottom
R652  4.99K_1%_4  [R0402]  47.26 157.9 90 bottom
R653  *short_0402  [S0402]  91.1 157.88 270 bottom
R654  *10K_1%_4  [R0402]  54.55 157.83 270 bottom
R655  *0_5%_4  [R0402]  51.58 157.83 270 bottom
R656  *0_5%_4  [R0402]  50.62 157.83 270 bottom
R657  10K_1%_4  [R0402]  49.29 157.83 270 bottom
R658  *4.7K_5%_4  [R0402]  53.57 157.81 270 bottom
R659  *4.7K_5%_4  [R0402]  52.56 157.81 270 bottom
R660  *10K_1%_4  [R0402]  55.52 157.79 270 bottom
R661  100K_5%_4  [R0402]  83.99 157.39 0 bottom
R662  *1K_1%_4  [R0402]  97.55 156.51 180 bottom
R663  100K_5%_4  [R0402]  88.03 156 180 bottom
R664  100K_5%_4  [R0402]  86.25 156 180 bottom
R665  *1K_1%_4  [R0402]  97.55 155.49 0 bottom
R666  10K_1%_2  [R0201]  19.78 157.67 90 bottom
R667  *1K_1%_4  [R0402]  86.28 154.85 180 bottom
R668  1K_1%_4  [R0402]  86.28 153.84 180 bottom
R669  *2.2K_5%_4  [R0402]  21.19 152.87 90 bottom
R670  *0_5%_4  [R0402]  86.28 152.82 0 bottom
R671  *1K_1%_4  [R0402]  90.06 148 90 bottom
R672  *1K_1%_4  [R0402]  89.05 148 90 bottom
R673  *2.2K_5%_4  [R0402]  103.56 146.38 90 bottom
R674  *short_0402  [S0402]  9.8 143.55 270 bottom
R675  *short_0402  [S0402]  8.65 143.55 270 bottom
R676  2.2K_5%_4  [R0402]  10.81 139.23 270 bottom
R677  *short_0402  [S0402]  9.85 139.23 270 bottom
R678  *short_0402  [S0402]  8.78 139.23 270 bottom
R679  2.2K_5%_4  [R0402]  7.38 139.23 90 bottom
R680  *short_0805  [S0805]  173.12 138.45 0 bottom
R681  *2.2K_5%_4  [R0402]  10.81 137.46 270 bottom
R682  *0_5%_4  [R0402]  9.8 137.46 90 bottom
R683  *0_5%_4  [R0402]  8.78 137.46 90 bottom
R684  *2.2K_5%_4  [R0402]  7.77 137.46 270 bottom
R685  *short_0603  [S0603]  109.62 133.63 180 bottom
R686  *short_0805  [S0805]  157.63 133.18 180 bottom
R687  24.9_1%_4  [R0402]  122.76 133.26 90 bottom
R688  *0_5%_6  [R0603]  109.62 132.12 0 bottom
R689  *short_0603  [S0603]  109.62 130.6 0 bottom
R690  *short_0603  [S0603]  109.62 129.07 180 bottom
R691  *33_5%_4  [R0402]  172.28 126.51 0 bottom
R692  *33_5%_4  [R0402]  172.3 125.44 0 bottom
R694  100K_5%_4  [R0402]  176.55 105.96 270 bottom
R695  *100K_5%_4  [R0402]  180.87 107.48 270 bottom
R696  *100K_5%_4  [R0402]  179.57 107.48 270 bottom
R697  100K_5%_4  [R0402]  178.05 107.23 0 bottom
R698  *10_5%_4  [R0402]  178.61 105.71 270 bottom
R699  10_5%_4  [R0402]  177.65 105.71 270 bottom
R700  *100K_5%_4  [R0402]  180.89 105.32 90 bottom
R701  *100K_5%_4  [R0402]  179.57 105.32 90 bottom
R702  *short_0402  [S0402]  176.27 99.38 270 bottom
R703  100K_5%_4  [R0402]  175.5 97.47 270 bottom
R704  *4.7K_1%_4  [R0402]  173.25 97.04 0 bottom
R705  4.7K_1%_4  [R0402]  173.35 95.29 0 bottom
R706  *1K_1%_4  [R0402]  181.89 94.29 180 bottom
R707  100K_5%_4  [R0402]  170.55 93.82 180 bottom
R708  1K_1%_4  [R0402]  181.89 93.27 0 bottom
R709  100K_5%_4  [R0402]  170.55 92.37 180 bottom
R710  *0_5%_4  [R0402]  169.43 91.38 0 bottom
R711  1K_1%_4  [R0402]  171.63 90.45 180 bottom
R712  *1K_1%_4  [R0402]  169.46 90.42 180 bottom
R713  *1K_1%_4  [R0402]  171.63 89.44 180 bottom
R714  1K_1%_4  [R0402]  169.46 89.42 180 bottom
R715  *1K_1%_4  [R0402]  171.63 88.42 180 bottom
R716  1K_1%_4  [R0402]  169.49 88.41 180 bottom
R717  240_1%_4  [R0402]  97.12 67.59 0 bottom
R718  *1K_1%_4  [R0402]  95.44 67.2 270 bottom
R719  *short_0402  [S0402]  92.96 67.14 0 bottom
R720  240_1%_4  [R0402]  97.48 66.17 90 bottom
R721  *1K_1%_4  [R0402]  96.43 66.19 90 bottom
R722  *0_5%_4  [R0402]  92.94 66.08 0 bottom
R723  4.7K_1%_4  [R0402]  182.56 65.49 270 bottom
R724  *0_5%_4  [R0402]  93.41 64.59 90 bottom
R725  *short_0402  [S0402]  91.72 63.08 180 bottom
R726  4.7K_1%_4  [R0402]  180.15 63.39 0 bottom
R727  24.9_1%_4  [R0402]  177.69 63.35 180 bottom
R728  10K_1%_4  [R0402]  195.93 61.38 90 bottom
R729  *short_0402  [S0402]  6.11 61.76 90 bottom
R730  2_1%_6  [R0603]  178.29 60.41 180 bottom
R731  *0_5%_4  [R0402]  10.43 52.65 180 bottom
R732  10K_1%_2  [R0201]  269.2 58.09 90 bottom
R733  1K_1%_4  [R0402]  191.38 59.99 270 bottom
R734  10K_1%_4  [R0402]  12.21 50.61 0 bottom
R735  10K_1%_4  [R0402]  8.65 52.65 180 bottom
R736  10K_1%_2  [R0201]  265.28 58.35 0 bottom
R737  *short_0402  [S0402]  254.7 59.1 180 bottom
R738  *0_5%_4  [R0402]  264.27 58.59 270 bottom
R739  *short_0402  [S0402]  267.98 58.05 180 bottom
R740  *2.2K_5%_4  [R0402]  259.72 59.02 270 bottom
R741  *2.2K_5%_4  [R0402]  258.76 59.02 270 bottom
R742  *10K_1%_2  [R0201]  266.27 58.23 90 bottom
R743  10K_1%_4  [R0402]  190.26 57.45 90 bottom
R744  *10K_1%_2  [R0201]  265.22 57.01 90 bottom
R745  *2.2K_5%_4  [R0402]  256.79 57.44 0 bottom
R746  *0_5%_4  [R0402]  267.53 57.09 0 bottom
R747  10K_1%_4  [R0402]  196.11 56.81 90 bottom
R748  *0_5%_4  [R0402]  195.09 56.81 270 bottom
R749  100K_1%_4  [R0402]  263.57 56.33 270 bottom
R750  *0_5%_6  [R0603]  274.08 56.3 180 bottom
R751  100K_1%_4  [R0402]  262.61 56.26 270 bottom
R752  100K_1%_4  [R0402]  261.05 56.23 270 bottom
R753  10K_1%_2  [R0201]  260.19 56.13 270 bottom
R754  10K_1%_2  [R0201]  259.48 56.13 270 bottom
R755  10K_1%_2  [R0201]  258.77 56.13 270 bottom
R756  10K_1%_2  [R0201]  258.06 56.13 270 bottom
R757  100_1%_2  [R0201]  266.31 56.07 90 bottom
R758  10K_1%_2  [R0201]  267.02 56.02 270 bottom
R759  10K_1%_2  [R0201]  265.22 56.02 90 bottom
R760  10K_1%_2  [R0201]  264.51 56 90 bottom
R761  *short_0402  [S0402]  208.04 55.29 180 bottom
R762  *2.2K_5%_4  [R0402]  256.05 55.16 0 bottom
R763  100K_1%_4  [R0402]  257.83 54.91 0 bottom
R764  0_5%_6  [R0603]  274.08 54.78 180 bottom
R765  4.75K_0.1%_4  [R0402]  265.63 54.65 180 bottom
R766  14K_1%_4  [R0402]  261.71 54.65 180 bottom
R767  *10K_1%_2  [R0201]  254.53 54.52 180 bottom
R768  *short_0402  [S0402]  251.3 54.52 180 bottom
R769  1M_1%_4  [R0402]  268.19 54.4 180 bottom
R770  *0_5%_4  [R0402]  97.66 53.99 270 bottom
R771  *short_0402  [S0402]  178.48 51.62 0 bottom
R772  100K_1%_4  [R0402]  258.09 53.49 270 bottom
R773  1M_1%_4  [R0402]  268.19 53.43 180 bottom
R774  100_1%_2  [R0201]  256.18 53.38 90 bottom
R775  2.2K_5%_4  [R0402]  251.26 53.14 0 bottom
R776  *short_0402  [S0402]  97.81 52.26 90 bottom
R777  *2.2K_5%_4  [R0402]  255.16 53 270 bottom
R778  1K_1%_4  [R0402]  178.48 50.65 0 bottom
R779  0_5%_6  [R0603]  275.25 52.65 90 bottom
R780  *0_5%_6  [R0603]  273.5 52.62 90 bottom
R781  1M_1%_4  [R0402]  202.84 52.62 0 bottom
R782  *short_0402  [S0402]  186.58 52.37 180 bottom
R783  *100K_1%_4  [R0402]  204.62 51.73 0 bottom
R784  100K_1%_4  [R0402]  255.42 51.48 180 bottom
R785  3.32K_1%_4  [R0402]  249.32 51.43 270 bottom
R786  2.2K_5%_4  [R0402]  250.59 51.4 270 bottom
R787  *short_0402  [S0402]  186.58 51.35 180 bottom
R788  *1K_1%_4  [R0402]  242.33 50.84 180 bottom
R789  *100K_1%_4  [R0402]  199.54 50.84 270 bottom
R790  *short_0402  [S0402]  98.16 50.79 0 bottom
R791  *short_0402  [S0402]  253.89 50.71 90 bottom
R792  1K_1%_4  [R0402]  244.37 50.71 0 bottom
R793  1K_1%_4  [R0402]  178.48 48.67 180 bottom
R794  *1K_1%_4  [R0402]  241.19 49.44 0 bottom
R795  1K_1%_4  [R0402]  239.41 49.44 180 bottom
R796  *short_0402  [S0402]  186.58 49.32 180 bottom
R797  *0_5%_4  [R0402]  97.88 49.47 180 bottom
R798  1M_1%_4  [R0402]  201.95 49.06 180 bottom
R799  100K_1%_2  [R0201]  281.58 48.81 0 bottom
R800  1K_1%_4  [R0402]  239.41 48.3 180 bottom
R801  *short_0402  [S0402]  186.58 48.3 180 bottom
R802  *short_0402  [S0402]  106.64 48.08 180 bottom
R803  100K_1%_2  [R0201]  281.58 48.05 0 bottom
R804  3.01K_1%_4  [R0402]  261.51 47.85 90 bottom
R805  *0_5%_4  [R0402]  104.21 47.69 180 bottom
R806  *1K_1%_4  [R0402]  240.81 47.67 90 bottom
R807  *short_0402  [S0402]  247.29 47.03 180 bottom
R808  *CNVI@0_5%_6  [R0603]  178.07 47.45 180 bottom
R809  14K_1%_4  [R0402]  258.84 46.55 90 bottom
R810  *short_0402  [S0402]  186.58 46.52 180 bottom
R811  499_1%_2  [R0201]  265.8 46.22 270 bottom
R812  499_1%_2  [R0201]  265.04 46.22 90 bottom
R813  *4.7K_1%_4  [R0402]  247.34 45.84 180 bottom
R814  1M_1%_2  [R0201]  202.96 45.8 270 bottom
R815  *1K_1%_4  [R0402]  239.41 45.76 180 bottom
R816  *short_0402  [S0402]  186.58 45.51 180 bottom
R817  1K_1%_4  [R0402]  240.81 45.38 270 bottom
R818  4.7K_1%_4  [R0402]  246.91 44.36 90 bottom
R819  *short_0402  [S0402]  186.58 43.48 180 bottom
R820  33_5%_2  [R0201]  203.62 43.43 270 bottom
R821  33_5%_2  [R0201]  202.91 43.43 270 bottom
R822  3.32K_1%_4  [R0402]  251.99 43.6 0 bottom
R823  *1K_1%_4  [R0402]  240.94 42.84 270 bottom
R824  10K_1%_4  [R0402]  19.16 42.81 90 bottom
R825  *10K_1%_4  [R0402]  233.11 42.79 180 bottom
R826  1K_1%_4  [R0402]  242.97 42.46 270 bottom
R827  *short_0402  [S0402]  186.58 42.46 180 bottom
R828  10K_1%_4  [R0402]  235.5 42.15 0 bottom
R829  100K_5%_4  [R0402]  17.49 42.03 180 bottom
R830  10K_1%_4  [R0402]  235.46 41.19 0 bottom
R831  *10K_1%_4  [R0402]  233.45 40.88 0 bottom
R832  *10K_1%_4  [R0402]  231.09 40.85 180 bottom
R833  *short_0603  [S0603]  213.89 41.82 0 bottom
R834  *short_0402  [S0402]  186.58 40.55 180 bottom
R835  *10K_1%_4  [R0402]  229.3 40.78 0 bottom
R836  100K_1%_4  [R0402]  231.02 39.66 180 bottom
R837  *short_0402  [S0402]  186.58 39.54 180 bottom
R838  *short_0603  [S0603]  214.3 39.16 0 bottom
R839  *short_0402  [S0402]  279.16 38.9 90 bottom
R840  *0_5%_4  [R0402]  278.15 38.9 90 bottom
R841  *10K_1%_4  [R0402]  273.32 38.9 90 bottom
R842  *10K_1%_4  [R0402]  272.31 38.9 90 bottom
R843  10K_5%_4  [R0402]  251.78 38.78 270 bottom
R844  10K_1%_4  [R0402]  233.12 38.68 180 bottom
R845  620_1%_4  [R0402]  199.79 38.57 0 bottom
R846  *10K_1%_4  [R0402]  230.98 38.57 180 bottom
R847  *2.2K_5%_4  [R0402]  240.3 38.52 180 bottom
R848  *0_5%_4  [R0402]  186.58 38.52 180 bottom
R849  *1K_1%_4  [R0402]  233.11 37.68 180 bottom
R850  *100K_1%_4  [R0402]  227.42 37.66 0 bottom
R851  *3.32K_1%_4  [R0402]  243.38 37.65 180 bottom
R852  *20K_1%_4  [R0402]  229.16 37.64 0 bottom
R853  *short_0402  [S0402]  269.13 37.63 0 bottom
R854  *short_0402  [S0402]  246.27 37.63 180 bottom
R855  2K_1%_4  [R0402]  200.02 37.61 0 bottom
R856  *100K_1%_4  [R0402]  230.96 37.54 180 bottom
R857  *2.2K_5%_4  [R0402]  240.3 37.51 180 bottom
R858  10K_1%_4  [R0402]  204.2 37.38 90 bottom
R859  4.7K_5%_4  [R0402]  187.22 37.18 0 bottom
R860  *100_1%_2  [R0201]  185.82 37.18 0 bottom
R861  100K_1%_4  [R0402]  235.81 36.99 180 bottom
R862  *10K_1%_4  [R0402]  199.79 36.64 0 bottom
R863  *short_0402  [S0402]  233.03 36.62 180 bottom
R864  *10K_1%_4  [R0402]  230.9 36.57 180 bottom
R865  *10K_1%_4  [R0402]  259.1 36.49 180 bottom
R866  *3.32K_1%_4  [R0402]  240.3 36.49 0 bottom
R867  *1K_1%_4  [R0402]  208.81 36.43 180 bottom
R868  *short_0603  [S0603]  220.6 36.37 180 bottom
R869  *short_0402  [S0402]  88.36 36.35 0 bottom
R870  1M_5%_4  [R0402]  245.89 36.24 90 bottom
R871  *100K_1%_4  [R0402]  235.81 35.99 180 bottom
R872  *short_0402  [S0402]  212.57 35.95 270 bottom
R873  10K_1%_4  [R0402]  229.08 35.69 0 bottom
R874  *10K_1%_4  [R0402]  199.79 35.67 0 bottom
R875  10K_1%_4  [R0402]  233.07 35.6 180 bottom
R876  4.7K_5%_4  [R0402]  259.1 35.47 180 bottom
R877  *10K_1%_4  [R0402]  227.72 35.4 270 bottom
R878  *100K_1%_4  [R0402]  235.91 34.95 180 bottom
R879  1K_1%_4  [R0402]  229.73 34.72 0 bottom
R880  *10K_1%_4  [R0402]  199.79 34.66 0 bottom
R881  *100K_1%_4  [R0402]  234.01 34.6 180 bottom
R882  10K_1%_4  [R0402]  231.29 34.46 90 bottom
R883  4.7K_5%_4  [R0402]  259.1 34.46 180 bottom
R884  1M_5%_4  [R0402]  245.89 34.46 270 bottom
R885  10K_1%_4  [R0402]  232.64 34.21 90 bottom
R886  *short_0201  [S0201]  32.71 33.73 180 bottom
R887  *short_0402  [S0402]  207.03 33.77 180 bottom
R888  *10K_1%_4  [R0402]  199.79 33.64 0 bottom
R889  100K_1%_4  [R0402]  235.93 33.44 180 bottom
R890  4.7K_5%_4  [R0402]  278.4 33.32 180 bottom
R891  1K_1%_4  [R0402]  229.18 33.31 0 bottom
R892  *short_0402  [S0402]  284.54 33.08 180 bottom
R893  *10K_1%_4  [R0402]  199.82 32.65 0 bottom
R894  *short_0402  [S0402]  211.05 32.6 270 bottom
R895  10K_1%_4  [R0402]  223.48 32.59 0 bottom
R896  *100K_1%_4  [R0402]  235.91 32.45 180 bottom
R897  *4.7K_5%_4  [R0402]  278.4 32.3 0 bottom
R898  *short_0402  [S0402]  268.32 32.2 90 bottom
R899  *short_0402  [S0402]  284.54 32.07 180 bottom
R900  *100K_1%_4  [R0402]  233.08 31.86 0 bottom
R901  *100K_1%_4  [R0402]  89.22 31.81 180 bottom
R902  *10K_1%_4  [R0402]  199.79 31.6 0 bottom
R903  *10K_1%_4  [R0402]  280.18 31.16 180 bottom
R904  *10K_1%_4  [R0402]  278.4 31.16 180 bottom
R905  10K_1%_4  [R0402]  235.95 31.1 0 bottom
R906  *short_0603  [S0603]  217.85 30.62 0 bottom
R907  10K_1%_2  [R0201]  212.44 30.31 180 bottom
R908  *short_0402  [S0402]  224.71 30.49 0 bottom
R909  10K_1%_4  [R0402]  233.19 30.29 180 bottom
R910  10K_1%_4  [R0402]  235.95 30.08 0 bottom
R911  100K_1%_4  [R0402]  37.79 29.4 180 bottom
R912  *short_0402  [S0402]  89.12 29.71 180 bottom
R914  10K_1%_4  [R0402]  207.68 29.48 180 bottom
R915  *0_5%_4  [R0402]  264.81 29.38 180 bottom
R916  10K_5%_4  [R0402]  249.45 29.25 270 bottom
R917  *10K_5%_4  [R0402]  248.43 29.25 270 bottom
R918  100K_5%_4  [R0402]  247.29 29.25 270 bottom
R919  100K_1%_4  [R0402]  233.17 29.22 180 bottom
R920  100K_5%_4  [R0402]  250.84 29.12 0 bottom
R921  TPM@33_5%_4  [R0402]  235.98 29.08 0 bottom
R922  *0_5%_6  [R0603]  218.1 28.91 0 bottom
R923  *4.7K_5%_4  [R0402]  53.49 28.74 180 bottom
R925  *0_5%_4  [R0402]  64.99 28.41 180 bottom
R926  *short_0402  [S0402]  39.9 28.36 270 bottom
R927  *4.7K_5%_4  [R0402]  46.63 28.35 90 bottom
R928  *4.7K_5%_4  [R0402]  45.49 28.35 90 bottom
R929  *4.7K_5%_4  [R0402]  47.6 28.32 90 bottom
R930  *4.7K_5%_4  [R0402]  48.56 28.26 90 bottom
R931  *20K_1%_4  [R0402]  233.07 28.23 180 bottom
R932  *0_5%_6  [R0603]  209.31 28.11 90 bottom
R933  *short_0402  [S0402]  187.7 27.98 90 bottom
R934  *short_0402  [S0402]  186.73 27.98 90 bottom
R935  10K_1%_4  [R0402]  202.24 27.97 180 bottom
R936  33_5%_4  [R0402]  235.98 27.88 0 bottom
R937  *0_5%_4  [R0402]  251.35 27.73 180 bottom
R938  *4.7K_5%_4  [R0402]  53.49 27.6 0 bottom
R939  *22_5%_4  [R0402]  63.16 27.58 270 bottom
R940  *4.7K_1%_4  [R0402]  226.31 27.48 180 bottom
R941  *short_0402  [S0402]  212.85 27.41 180 bottom
R942  3.32K_1%_4  [R0402]  246.14 27.35 180 bottom
R944  *4.7K_1%_4  [R0402]  229.89 27.11 0 bottom
R945  33_5%_4  [R0402]  235.94 26.56 0 bottom
R946  *0_5%_4  [R0402]  199.74 26.33 0 bottom
R947  4.7K_5%_4  [R0402]  46.96 26.33 270 bottom
R948  *short_0201  [S0201]  244.42 26.25 0 bottom
R949  4.7K_5%_4  [R0402]  45.97 26.31 270 bottom
R950  *short_0402  [S0402]  185.57 26.08 180 bottom
R951  *10K_1%_2  [R0201]  230.66 26 0 bottom
R952  *0_5%_4  [R0402]  42.81 26.11 0 bottom
R953  0_5%_4  [R0402]  40.25 25.95 0 bottom
R954  0_5%_4  [R0402]  16.78 25.95 180 bottom
R955  4.7K_5%_4  [R0402]  48.33 25.77 180 bottom
R956  *0_5%_4  [R0402]  14.12 25.68 0 bottom
R957  *short_0402  [S0402]  251.78 25.59 0 bottom
R958  *short_0201  [S0201]  244.42 25.49 0 bottom
R959  *0_5%_4  [R0402]  253.54 25.52 180 bottom
R960  680K_1%_4  [R0402]  229.64 25.38 270 bottom
R961  150_1%_4  [R0402]  201.94 25.24 0 bottom
R962  *4.7K_5%_4  [R0402]  62.62 25.19 180 bottom
R963  *short_0402  [S0402]  273.2 25.19 0 bottom
R964  3.32K_1%_4  [R0402]  247.8 25.14 90 bottom
R965  *short_0402  [S0402]  231.04 25.09 0 bottom
R966  *short_0402  [S0402]  185.57 25.06 180 bottom
R967  1M_1%_4  [R0402]  227.64 24.94 0 bottom
R968  *0_5%_4  [R0402]  42.81 25.07 0 bottom
R969  0_5%_4  [R0402]  40.25 24.91 0 bottom
R970  *10K_1%_4  [R0402]  207.03 13.76 180 top
R971  0_5%_4  [R0402]  16.78 24.81 180 bottom
R972  4.7K_5%_4  [R0402]  48.23 24.71 180 bottom
R973  1K_5%_4  [R0402]  22.6 24.63 90 bottom
R974  1K_5%_4  [R0402]  23.87 24.58 90 bottom
R975  *0_5%_4  [R0402]  253.56 24.53 180 bottom
R976  4.7K_5%_4  [R0402]  261.64 24.45 0 bottom
R977  BLM15GG471SN1D  [R0402]  208.83 24.45 180 bottom
R978  200_1%_4  [R0402]  199.72 24.35 180 bottom
R979  *4.7K_5%_4  [R0402]  62.72 24.23 0 bottom
R980  *short_0402  [S0402]  86.86 24.22 0 bottom
R981  *short_0402  [S0402]  235.6 24.15 0 bottom
R982  *0_5%_4  [R0402]  14.12 23.87 180 bottom
R983  *0_5%_4  [R0402]  227.49 23.83 0 bottom
R984  *short_0402  [S0402]  252.06 23.74 90 bottom
R985  *short_0402  [S0402]  185.57 23.66 180 bottom
R986  2.2K_5%_4  [R0402]  255.02 23.56 180 bottom
R987  *100K_1%_4  [R0402]  248.18 23.54 180 bottom
R988  75K_1%_4  [R0402]  210.94 23.51 0 bottom
R989  10K_1%_2  [R0201]  68.95 23.51 270 bottom
R990  200_1%_4  [R0402]  199.69 23.36 0 bottom
R991  SUB@10K_1%_4  [R0402]  208.43 14.52 270 top
R992  *short_0402  [S0402]  38.68 23.26 90 bottom
R993  *short_0402  [S0402]  86.86 23.21 0 bottom
R994  *4.7K_5%_4  [R0402]  53.49 23.03 0 bottom
R995  *4.7K_5%_4  [R0402]  62.78 22.95 0 bottom
R996  *0_5%_2  [R0201]  246.55 22.9 90 bottom
R997  *0_5%_2  [R0201]  245.76 22.9 90 bottom
R998  *0_5%_4  [R0402]  216.28 22.85 90 bottom
R999  *0_5%_4  [R0402]  14.12 22.83 180 bottom
R1000  *short_0402  [S0402]  185.57 22.65 180 bottom
R1001  *0_5%_4  [R0402]  255.03 22.52 180 bottom
R1002  2K_5%_4  [R0402]  23.51 22.39 270 bottom
R1003  2K_5%_4  [R0402]  22.5 22.39 90 bottom
R1004  *short_0402  [S0402]  199.69 22.34 180 bottom
R1005  2.2K_5%_4  [R0402]  257.45 22.29 270 bottom
R1006  *10K_1%_2  [R0201]  235 22.18 90 bottom
R1007  *4.7K_5%_4  [R0402]  261 22.14 0 bottom
R1008  *49.9K_1%_4  [R0402]  212.75 21.89 270 bottom
R1009  *4.7K_5%_4  [R0402]  53.49 21.89 180 bottom
R1010  *4.7K_5%_4  [R0402]  64.59 21.86 180 bottom
R1011  *10K_1%_4  [R0402]  228.17 21.7 180 bottom
R1012  *short_0402  [S0402]  264.74 21.56 90 bottom
R1013  *short_0402  [S0402]  255.1 20.96 270 bottom
R1014  *0_5%_6  [R0603]  89.43 21.48 270 bottom
R1016  TPM@10K_5%_4  [R0402]  242.97 21.38 90 bottom
R1017  *short_0402  [S0402]  240.2 20.9 0 bottom
R1018  *short_0402  [S0402]  237.89 21.38 90 bottom
R1019  *0_5%_4  [R0402]  229.59 21.34 270 bottom
R1020  *10K_1%_4  [R0402]  261 21.12 180 bottom
R1021  *SUB@0_5%_4  [R0402]  13.86 21.12 180 bottom
R1022  4.7K_5%_4  [R0402]  259.61 21 270 bottom
R1023  *short_0402  [S0402]  231.09 20.76 180 bottom
R1024  *0_5%_4  [R0402]  232.91 20.73 0 bottom
R1025  *short_0603  [S0603]  202.82 20.47 270 bottom
R1026  *short_0603  [S0603]  201.29 20.47 270 bottom
R1027  *short_0402  [S0402]  186.07 20.36 90 bottom
R1028  *short_0402  [S0402]  185.06 20.36 90 bottom
R1029  20K_1%_4  [R0402]  278.28 20.29 0 bottom
R1030  39K_1%_4  [R0402]  280.05 20.23 0 bottom
R1031  10K_1%_2  [R0201]  218.83 20.09 180 bottom
R1032  10K_1%_2  [R0201]  235 20.06 270 bottom
R1034  10K_1%_2  [R0201]  217.83 20 0 bottom
R1035  22_1%_4  [R0402]  228.19 19.95 0 bottom
R1036  100K_1%_4  [R0402]  216.83 19.81 90 bottom
R1037  *short_0402  [S0402]  230.91 19.79 0 bottom
R1038  *0_5%_4  [R0402]  21.3 19.7 270 bottom
R1039  *0_5%_4  [R0402]  22.32 19.68 270 bottom
R1040  20K_1%_4  [R0402]  221.64 19.67 90 bottom
R1041  *NVL@10K_1%_4  [R0402]  222.65 19.6 90 bottom
R1042  *10K_1%_4  [R0402]  259.99 19.6 180 bottom
R1043  *short_0402  [S0402]  247.97 20.67 90 bottom
R1044  TPM@33_1%_2  [R0201]  243.78 19.6 270 bottom
R1045  10K_1%_2  [R0201]  207.92 17.95 0 bottom
R1046  *short_0402  [S0402]  251.24 19.76 90 bottom
R1047  10K_1%_4  [R0402]  226.69 19.57 270 bottom
R1048  *49.9K_1%_4  [R0402]  214.26 19.56 270 bottom
R1049  22_1%_4  [R0402]  225.7 19.54 90 bottom
R1050  *N-Macro@10K_1%_4  [R0402]  224.69 19.54 90 bottom
R1051  N-Tobii@10K_1%_4  [R0402]  223.67 19.54 90 bottom
R1052  *100K_1%_4  [R0402]  208.94 19.54 90 bottom
R1053  *1K_1%_2  [R0201]  206.77 17.34 90 bottom
R1054  100K_1%_4  [R0402]  207.54 19.47 90 bottom
R1055  *short_0402  [S0402]  210.2 19.53 270 bottom
R1056  *short_0402  [S0402]  213.26 19.53 270 bottom
R1057  2.2K_5%_4  [R0402]  212.24 19.52 90 bottom
R1058  *100K_1%_4  [R0402]  211.2 19.51 270 bottom
R1059  100K_1%_4  [R0402]  215.24 19.5 270 bottom
R1060  *0_5%_4  [R0402]  249.71 19.53 180 bottom
R1061  *0_5%_4  [R0402]  255.01 19.16 180 bottom
R1062  *10K_1%_2  [R0201]  218.94 19.24 90 bottom
R1063  TPM@10K_5%_4  [R0402]  239.79 19.22 90 bottom
R1064  TPM@10K_5%_4  [R0402]  237.89 19.22 270 bottom
R1065  *10K_1%_2  [R0201]  218.08 19.21 180 bottom
R1066  TPM@33_1%_2  [R0201]  240.68 18.84 270 bottom
R1067  TPM@33_1%_2  [R0201]  238.91 18.84 270 bottom
R1068  *0_5%_4  [R0402]  231.01 18.83 180 bottom
R1069  4.7K_5%_4  [R0402]  257.7 18.58 0 bottom
R1070  10K_5%_4  [R0402]  42.01 18.33 0 bottom
R1071  *20K_1%_4  [R0402]  221.88 18.25 0 bottom
R1072  *0_5%_4  [R0402]  243.86 18.08 90 bottom
R1073  *0_5%_4  [R0402]  235.71 17.99 180 bottom
R1074  *0_5%_4  [R0402]  253.76 17.64 0 bottom
R1075  *short_0402  [S0402]  183.23 19.37 180 bottom
R1076  *10K_1%_4  [R0402]  249.83 17.69 180 bottom
R1077  *0_5%_4  [R0402]  251.21 17.37 270 bottom
R1078  33_5%_4  [R0402]  231.47 17.41 90 bottom
R1079  33_5%_4  [R0402]  230.5 17.41 90 bottom
R1080  100K_1%_4  [R0402]  277.92 17.26 270 bottom
R1081  *10K_1%_2  [R0201]  219.22 17.26 270 bottom
R1082  *10K_1%_4  [R0402]  267.1 17.19 90 bottom
R1083  100K_1%_4  [R0402]  252.24 17.19 90 bottom
R1084  10K_1%_4  [R0402]  280.21 17.18 270 bottom
R1085  10K_1%_4  [R0402]  279.19 17.18 270 bottom
R1086  *short_0402  [S0402]  183.23 18.41 180 bottom
R1087  33_5%_4  [R0402]  234.24 16.97 90 bottom
R1088  *1K_1%_2  [R0201]  207.54 16.93 90 bottom
R1089  *1K_1%_4  [R0402]  205.63 16.83 90 bottom
R1090  *10K_1%_2  [R0201]  208.3 16.93 270 bottom
R1091  10K_1%_4  [R0402]  209.19 17.19 90 bottom
R1092  4.7K_5%_4  [R0402]  259.86 16.91 0 bottom
R1093  *4.7K_5%_4  [R0402]  257.7 16.91 0 bottom
R1094  *short_0402  [S0402]  220.11 16.88 270 bottom
R1095  *100K_1%_4  [R0402]  218.34 16.88 90 bottom
R1096  *1K_1%_4  [R0402]  217.19 16.88 270 bottom
R1097  200K_1%_4  [R0402]  215.41 16.88 90 bottom
R1098  *10K_1%_4  [R0402]  214.37 16.87 90 bottom
R1099  2.2K_5%_4  [R0402]  210.2 17.19 90 bottom
R1100  Macro@10K_1%_4  [R0402]  224.18 16.87 90 bottom
R1101  *Tobii@10K_1%_4  [R0402]  223.16 16.87 90 bottom
R1102  VL@10K_1%_4  [R0402]  222.15 16.87 90 bottom
R1103  150K_1%_4  [R0402]  221.19 16.87 90 bottom
R1104  *20K_1%_4  [R0402]  213.33 16.85 90 bottom
R1105  *4.7K_1%_4  [R0402]  212.37 16.85 270 bottom
R1106  10K_1%_4  [R0402]  211.4 16.85 90 bottom
R1107  33_5%_4  [R0402]  232.88 16.8 0 bottom
R1108  *short_0402  [S0402]  235.73 16.68 0 bottom
R1109  *short_0402  [S0402]  253.97 16.5 180 bottom
R1110  10K_1%_2  [R0201]  216.28 16.49 90 bottom
R1111  *short_0402  [S0402]  39.39 16.42 270 bottom
R1112  *short_0402  [S0402]  282.62 16.02 90 bottom
R1113  *short_0402  [S0402]  281.63 16.02 90 bottom
R1114  *short_0402  [S0402]  253.97 15.54 180 bottom
R1115  *0_5%_4  [R0402]  265.8 15.49 270 bottom
R1116  49.9K_1%_4  [R0402]  248.28 15.33 0 bottom
R1117  *0_5%_4  [R0402]  208.66 14.49 270 bottom
R1118  *0_5%_4  [R0402]  207.64 14.49 270 bottom
R1119  10K_1%_4  [R0402]  212.95 14.54 270 bottom
R1120  *10K_1%_4  [R0402]  211.93 14.54 270 bottom
R1121  10K_1%_4  [R0402]  214.04 14.51 270 bottom
R1122  10K_1%_2  [R0201]  218.84 14.9 270 bottom
R1123  10K_1%_4  [R0402]  224.2 14.14 270 bottom
R1124  *Max-Q@10K_1%_4  [R0402]  220.84 14.09 270 bottom
R1125  Max-P@10K_1%_4  [R0402]  219.81 14.09 90 bottom
R1126  *1K_1%_4  [R0402]  217.95 14.52 270 bottom
R1127  4.7K_5%_4  [R0402]  277.69 14.93 0 bottom
R1128  4.7K_5%_4  [R0402]  277.69 15.92 0 bottom
R1129  10K_1%_4  [R0402]  222.68 13.79 180 bottom
R1130  *4.7K_5%_4  [R0402]  275.02 13.73 90 bottom
R1131  *4.7K_5%_4  [R0402]  273.88 13.76 90 bottom
R1132  *short_0402  [S0402]  251.64 13.79 90 bottom
R1133  2.2K_5%_4  [R0402]  253.38 13.38 270 bottom
R1134  2.2K_5%_4  [R0402]  254.37 13.35 270 bottom
R1135  100K_1%_4  [R0402]  242.97 21.38 90 top
R1136  348K_1%_4  [R0402]  249.32 13 0 bottom
R1137  *short_0402  [S0402]  272.05 12.87 180 bottom
R1138  *short_0805  [S0805]  231.16 12.11 180 bottom
R1139  *short_0805  [S0805]  225.19 12.11 180 bottom
