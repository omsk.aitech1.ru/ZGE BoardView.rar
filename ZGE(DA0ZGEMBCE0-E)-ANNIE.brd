# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_EDP_TXN1_R: length 1.9
  BOTTOM w0.14: C683.2 177.45,88.66 177.59,88.8 177.59,89.94 177.53,89.99 U41.13
INT_EDP_TXN2: length 160.5
  TOP w0.102: v1(46.74,91.37) 46.74,91.18 46.85,91.07 47.14,91.07 47.29,91.21 47.29,92.19 47.12,92.35 47.12,93.37 47.03,93.47 46.54,93.47 46.42,93.58 46.42,94.07 46.49,94.14 46.66,94.14 46.75,94.05 UG1.BL15
  IN4 w0.086: v1(46.74,91.37) 46.74,91.08 46.48,90.81 46.27,90.81 46.07,90.62 46.07,90.23 46.72,89.58 46.72,88.51 48.88,86.35 48.88,84.19 50.18,82.89 51.66,82.89 52.62,81.93 56.76,81.93 57.17,81.53 58.45,81.53 58.88,81.1 83.04,81.1 89.17,87.23 94.66,87.23 99.23,82.66 99.23,81.29 99.95,80.57 99.95,80.12 102.36,77.71 103.34,77.71 103.6,77.45 103.6,76.75 103.3,76.45 103.12,76.45 v1(102.86,76.7)
  BOTTOM w0.14: C685.1 176.14,87.99 176.14,86.73 171.91,82.5 163.21,82.5 162.36,81.66 162.36,81.2 162.78,80.78 162.78,80.46 162.63,80.32 162.31,80.32 161.89,80.73 161.43,80.73 160.43,79.73 160.24,79.73 159.72,80.25 159.26,80.25 158.82,79.8 158.82,79.27 158.68,79.13 106.86,79.13 104.67,76.94 104.33,76.94 103.92,76.53 103.03,76.53 v1(102.86,76.7)
INT_EDP_TXN2_R: length 2
  BOTTOM w0.14: U41.16 176.33,90 176.37,89.96 176.37,89.74 176.16,89.54 176.16,88.91 C685.2
INT_EDP_TXN3: length 160.4
  TOP w0.102: v1(45.6,89.98) 45.6,89.74 45.74,89.6 45.87,89.6 46.12,89.86 46.12,91.25 45.87,91.5 45.87,92.3 46.42,92.85 46.42,93.05 46.32,93.15 UG1.BM14
  IN4 w0.086: v1(45.6,89.98) 45.5,89.88 45.5,89.76 45.62,89.63 45.98,89.63 46.25,89.36 46.25,88.28 48.41,86.12 48.41,84 49.99,82.42 51.47,82.42 52.44,81.45 56.43,81.45 57.25,80.63 83.24,80.63 89.35,86.74 94.48,86.74 98.32,82.9 98.32,82.14 98.76,81.7 98.76,81.1 99.15,80.71 99.15,79.34 98.94,79.12 98.94,78.19 99.12,78 99.37,78 99.45,78.09 v1(99.45,78.35)
  BOTTOM w0.14: C687.1 174.61,87.99 174.61,86.6 171.48,83.47 165.32,83.47 165.1,83.69 165.1,84.41 164.77,84.74 164.14,84.74 163.82,84.41 163.82,83.59 163.7,83.47 163.39,83.47 163.17,83.69 163.17,84.66 162.84,84.99 162.21,84.99 161.89,84.66 161.89,83.61 161.75,83.47 161.12,83.47 160.28,82.63 160.28,82.17 160.75,81.7 160.75,81.5 160.49,81.24 160.29,81.24 159.82,81.71 159.36,81.71 157.89,80.23 106.6,80.23 104.45,78.08 99.72,78.08 v1(99.45,78.35)
INT_EDP_TXN3_R: length 2.2
  BOTTOM w0.14: C687.2 174.61,88.87 174.61,89.31 175.17,89.87 175.17,89.96 175.13,90.01 U41.19
INT_EDP_TXP0: length 160.3
  TOP w0.102: UG1.BM18 48.75,93.05 48.75,92.59 49.61,91.73 49.61,89.97 49.14,89.5 48.76,89.5 v1(48.57,89.32)
  IN4 w0.086: v1(106.34,75) 106.34,75.19 106.23,75.3 105.97,75.3 105.23,76.05 105.23,78.56 104.76,79.03 102.89,79.03 101.26,80.67 101.26,81.12 100.54,81.84 100.54,83.3 95.27,88.58 88.53,88.58 82.36,82.41 60.34,82.41 59.48,83.27 53.32,83.27 52.37,84.22 50.74,84.22 50.25,84.71 50.25,88.67 49.27,89.65 48.9,89.65 v1(48.57,89.32)
  BOTTOM w0.14: C680.1 179.5,87.99 179.5,86.4 173.36,80.26 166.18,80.26 163.2,77.28 162.74,77.28 162.08,77.94 161.82,77.94 161.62,77.73 161.62,77.19 161.29,76.87 107.97,76.87 107.78,76.67 107.78,75.56 107.39,75.17 106.51,75.17 v1(106.34,75)
INT_EDP_TXP0_R: length 2.1
  BOTTOM w0.14: C680.2 179.5,88.88 179.5,89.41 179.09,89.83 179.09,89.96 179.13,90 U41.9
INT_EDP_TXP1: length 160.6
  TOP w0.102: v1(47.38,89) 47.38,89.04 47.63,89.3 47.68,89.3 48.05,89.67 48.05,92.57 47.84,92.78 47.84,93.44 48.15,93.75 UG1.BL17
  IN4 w0.086: v1(47.38,89) 47.71,89.33 47.79,89.33 47.91,89.21 47.91,88.27 49.54,86.64 49.54,84.49 50.48,83.55 52.11,83.55 53.05,82.61 59.22,82.61 60.07,81.75 82.74,81.75 88.91,87.92 95,87.92 99.88,83.03 99.88,81.56 100.6,80.84 100.6,80.39 102.63,78.37 103.65,78.37 104.26,77.77 104.26,76.43 103.51,75.68 103.51,74.87 103.79,74.6 104.07,74.6 104.29,74.39 v1(104.29,74.25)
  BOTTOM w0.14: C682.1 177.98,87.99 177.98,86.24 172.95,81.22 165.78,81.22 163.47,78.91 161.42,78.91 160.36,77.85 107.48,77.85 105.57,75.94 105.57,75.65 105.21,75.29 105.21,74.93 104.86,74.58 104.62,74.58 v1(104.29,74.25)
INT_EDP_TXP1_R: length 2
  BOTTOM w0.14: C682.2 177.9,88.95 177.9,89.92 177.93,89.94 U41.12
INT_EDP_TXP2: length 160.5
  TOP w0.102: UG1.BK15 46.75,94.34 47.1,93.99 47.1,93.69 47.33,93.46 47.33,92.43 47.49,92.27 47.49,91.12 47.23,90.86 47.09,90.86 v1(46.74,90.51)
  IN4 w0.086: v1(102.89,75.97) 103.18,76.26 103.37,76.26 103.79,76.67 103.79,77.53 103.41,77.9 102.44,77.9 100.14,80.2 100.14,80.65 99.42,81.37 99.42,82.74 94.73,87.42 89.1,87.42 82.96,81.28 58.96,81.28 58.53,81.71 57.25,81.71 56.84,82.12 52.7,82.12 51.74,83.08 50.26,83.08 49.07,84.27 49.07,86.43 46.91,88.59 46.91,89.65 46.26,90.3 46.26,90.54 46.34,90.63 46.63,90.63 v1(46.74,90.51)
  BOTTOM w0.14: v1(102.89,75.97) 102.89,76.06 103.04,76.22 104.06,76.22 104.46,76.62 104.8,76.62 107,78.81 158.81,78.81 159.13,79.14 159.13,79.67 159.39,79.93 159.59,79.93 160.1,79.41 160.57,79.41 161.57,80.41 161.76,80.41 162.18,80 162.77,80 163.1,80.33 163.1,80.91 162.68,81.33 162.68,81.53 163.34,82.19 172.05,82.19 176.45,86.59 176.45,87.99 C684.1
INT_EDP_TXP2_R: length 2
  BOTTOM w0.14: C684.2 176.48,88.85 176.48,89.41 176.69,89.61 176.69,89.95 176.73,89.99 U41.15
INT_EDP_TXP3: length 160.4
  TOP w0.102: v1(45.57,89.23) 45.57,89.24 45.73,89.4 45.95,89.4 46.32,89.77 46.32,91.33 46.07,91.58 46.07,92.22 46.62,92.77 46.62,93.02 UG1.BM15
  IN4 w0.086: v1(99.45,77.55) 99.45,77.68 99.32,77.81 99.05,77.81 98.75,78.11 98.75,79.2 98.96,79.41 98.96,80.63 98.57,81.02 98.57,81.62 98.13,82.06 98.13,82.83 94.41,86.55 89.43,86.55 83.31,80.44 57.17,80.44 56.35,81.26 52.37,81.26 51.39,82.23 49.91,82.23 48.22,83.92 48.22,86.04 46.06,88.2 46.06,89.28 45.9,89.44 45.78,89.44 v1(45.57,89.23)
  BOTTOM w0.14: v1(99.45,77.55) 99.66,77.77 104.58,77.77 106.73,79.92 158.02,79.92 159.49,81.39 159.69,81.39 160.16,80.93 160.62,80.93 161.07,81.37 161.07,81.83 160.6,82.3 160.6,82.5 161.25,83.15 161.88,83.15 162.2,83.48 162.2,84.53 162.34,84.67 162.71,84.67 162.85,84.53 162.85,83.54 163.24,83.15 163.83,83.15 164.13,83.46 164.13,84.28 164.27,84.42 164.64,84.42 164.78,84.28 164.78,83.56 165.19,83.15 171.61,83.15 174.93,86.47 174.93,87.99 C686.1
INT_EDP_TXP3_R: length 2.2
  BOTTOM w0.14: C686.2 174.92,88.89 174.92,89.17 175.49,89.74 175.49,89.94 175.53,89.98 U41.18
INT_ULT_DP_HPD: length 18.4
  TOP w0.14: R22.1 95.5,155.99 95.36,155.85 v1(95.36,155.69)
  IN1 w0.086: v1(85.09,152.52) 85.32,152.52 86.61,153.81 86.61,155.41 87.24,156.05 90.7,156.05 v1(91.2,156.55) 92.01,156.55 92.37,156.91 93.16,156.91 93.31,156.76 94.3,156.76 v1(95.36,155.69)
  BOTTOM w0.14: v1(85.09,152.52) 85.59,152.52 R670.2 ; R653.1 91.1,157.12 91.2,157.02 v1(91.2,156.55) 91.22,156.53 U39.32
INT_ULT_EDP_HPD: length 26.2
  IN1 w0.086: v1(170.91,86.46) 170.1,87.27 170.1,90.91 174.91,95.72 v1(174.91,96.28)
  BOTTOM w0.14: U41.32 175.93,95.2 174.91,96.22 v1(174.91,96.28) 174.91,96.5 R703.1 175.97,97.55 175.97,98.29 176.27,98.59 R702.1 ; v1(170.91,86.46) 170.87,86.5 168.8,86.5 167.48,87.83 167.48,90.52 168.35,91.38 R710.2
ITP_PMODE: length 1.3
  TOP w0.102: U14.AL3 205.13,31.11 v1(205.2,31.18)
  BOTTOM w0.14: TP99.1 204.84,31.54 v1(205.2,31.18)
JTAG_SEL: length 3.7
  TOP w0.102: v1(51.59,93.08) 51.59,93.3 52,93.71 52,94.04 52.35,94.39 52.35,94.55 UG1.BK23
  BOTTOM w0.102: RG164.2 52.47,93.26 TPG69.1 52.17,92.96 51.71,92.96 v1(51.59,93.08)
JTAG_TCK: length 9.7
  TOP w0.102: 51.21,90.2 51.21,90.6 52.57,91.96 52.57,92.88 52.66,92.97 52.66,94.16 UG1.BK24
  TOP w0.14: 51.21,90.2 51.21,87.89 50.25,86.94 TPG4.1
JTAG_TDI: length 8.5
  TOP w0.102: UG1.BM23 52.35,92.17 51.82,91.65
  TOP w0.14: 51.82,91.65 50.77,90.6 50.77,89.3 50.19,88.71 49.16,87.68 48.97,87.49 TPG3.1
JTAG_TDO: length 7.9
  TOP w0.102: UG1.BM24 53.05,93.07 52.77,92.79 52.77,91.61 51.49,90.32 51.49,89.84
  TOP w0.14: 51.49,89.84 51.49,86.31 TPG5.1
JTAG_TMS: length 10.4
  TOP w0.102: 50.3,90.35 50.3,90.61 52.15,92.45 52.15,92.92 52.04,93.02 52.04,93.34 52.35,93.65 52.35,93.85 UG1.BL23
  TOP w0.14: TPG6.1 47.83,87.17 50.3,89.64 50.3,90.35
JTAG_TRST#: length 8.7
  TOP w0.102: UG1.BL24 53.05,93.85 53.46,93.44 53.46,93.01 52.98,92.52 52.98,91.41 52.11,90.54 52.11,90.06
  TOP w0.14: RG42.2 52.47,86.51 52.47,88.21 52.11,88.56 52.11,90.06
KBL_DET#: length 8.4
  TOP w0.102: 219.98,20.62 219.98,20.89 219.22,21.64 219.22,22.5 218.97,22.75 218.97,23.54 218.79,23.73 U14.BF32
  TOP w0.14: 219.98,20.62 220.47,20.13 C441.1 219.94,19.3 219.94,18.33 220.09,18.19 TP52.1 219.81,17.69 219.65,17.69 219.1,17.14 R538.1
LAN_DIS#: length 3
  TOP w0.102: U14.BF41 223.23,23.77 223.23,22.98 223.52,22.69 223.52,22.09 223.49,22.06 v1(223.49,21.73)
  BOTTOM w0.102: v1(223.49,21.73) 223.49,21.65 TP119.1
LAN_PWR#: length 68.3
  TOP w0.14: v1(66.01,28.65) 66.01,27.81 R389.1
  IN1 w0.086: v1(66.01,28.65) 65.78,28.41 64.64,28.41 63.81,29.24 61.6,29.24 60.99,28.63 60.71,28.63 60.24,28.16 59.5,28.16 58.95,27.61 56.16,27.61 55.36,28.4 54.69,28.4 v1(54.64,28.45)
  BOTTOM w0.14: v1(54.64,28.45) 54.6,28.5 54.6,30.67 54.22,31.05 53.6,31.05 52.65,30.11 52.2,30.11 51.75,29.66 51.75,28.86 51.56,28.67 50.54,28.67 49.57,29.63 47.64,29.63 47.19,30.09 45.97,30.09 45.08,29.2 44.16,29.2 43.81,28.85 43.25,28.85 42.92,28.52 41.83,28.52 41.48,28.87 41.48,29.68 40.89,30.27 38.47,30.27 37.89,30.85 37.34,30.85 36.72,31.47 36.72,33.16 35.86,34.02 35.86,35.28 33.81,37.34 v1(33.76,37.34) 33.76,39.24 32.83,40.17 31.2,40.17 28.86,37.82 26.19,37.82 26.04,37.67 21.98,37.67 19.76,39.89 19.76,40.37 19.44,40.68 19.44,42.14 R824.2 19.02,42.56 18.41,42.56 R829.2
LANWAKE_N: length 7.3
  TOP w0.102: U14.BG44 224.8,23.04 225.15,22.7 225.15,22.32 224.89,22.06 224.89,21.7 226.31,20.28 R481.1
  TOP w0.14: R481.1 226.79,19.45 226.79,18.89 226.46,18.56 226.46,18.23 226.36,18.13 226.36,17.18 R543.1
LCD_BL_PWM: length 192.7
  TOP w0.102: v2(41.52,98.44) 41.46,98.44 UG1.BD7
  TOP w0.14: Q17.2 178.25,101.8 178.25,101.06 178.86,100.46 178.86,97.24 180.74,95.35 180.74,90.2 181.72,89.22 181.72,82.98 v1(182.14,82.57)
  IN2 w0.089: v1(98.21,78.22) 97.25,79.18 97.25,80.94 96.78,81.41 96.78,83.05 96.16,83.67 96.16,84.41 93.64,86.93 88.14,86.93 82.76,81.55 59.14,81.55 58.79,81.9 57.86,81.9 57.69,81.73 56.86,81.73 54.61,83.98 50.79,83.98 49.51,85.26 49.51,85.63 47.83,87.31 44.18,87.31 42.72,88.77 v1(42.26,88.77)
  IN4 w0.086: v1(42.26,88.77) 42.81,89.31 42.81,90.94 42.28,91.46 42.28,97.95 41.8,98.44 v2(41.52,98.44)
  BOTTOM w0.14: RG150.1 41.78,98.17 41.52,98.43 v2(41.52,98.44) ; v1(98.21,78.22) 98.21,77.82 99.64,76.39 100.74,76.39 103.55,73.58 107.8,73.58 109.5,71.89 112.5,71.89 113.35,72.73 164.12,72.73 167.68,76.29 176.91,76.29 179.58,78.97 179.58,80.01 v1(182.14,82.57)
LCD_BLEN: length 232.3
  TOP w0.135: UG1.BA5 40.03,100.57 40.13,100.57 40.13,100.54 v2(40.11,100.54)
  TOP w0.14: v1(176.56,112.53) 177.09,112.53 178.02,111.6 Q13.2
  IN2 w0.089: v1(98.71,76.67) 98.71,78.68 100.02,79.99 100.02,80.92 98.97,81.96 98.72,81.96 98.23,82.45 98.23,84.64 94.32,88.55 87.47,88.55 82.09,83.17 62.15,83.17 61.37,83.95 57.01,83.95 55.36,85.6 52.94,85.6 52.42,86.12 52.42,86.25 52.43,86.26 52.43,87.44 52,87.87 52,89.48 48.37,93.1 47.92,93.1 46.73,94.29 46.73,98.56 46.79,98.63 46.79,99.15 46.52,99.43 43.46,99.43 43.04,99.85 43.04,100.28 42.31,101.01 40.57,101.01 40.13,100.57 40.13,100.54 v2(40.11,100.54)
  IN3 w0.089: v1(176.56,112.53) 176.15,112.12 176.15,110.93 175.69,110.47 175.69,106.25 175.18,105.75 175.18,103.02 175.82,102.38 175.82,94.01 175.61,93.8 175.61,89.98 174.97,89.35 174.97,86.16 173.07,84.26 173.07,81.91 173.49,81.49 173.49,67.79 177.45,63.84 177.45,61.88 178.12,61.21 v1(178.29,61.21)
  IN4 w0.086: v1(98.71,76.67) 98.77,76.67 99.74,75.71 100.32,75.71 102.9,73.13 105.33,73.13 105.91,72.55 112.28,72.55 115.2,75.46 164.87,75.46 176.29,64.04 176.29,63.75 176.65,63.39 176.65,62.88 178.29,61.25 v1(178.29,61.21)
  BOTTOM w0.14: RG136.2 39.66,100.5 40.07,100.5 40.11,100.54 v2(40.11,100.54)
LCD_OD_EN#: length 148.4
  TOP w0.14: Q4.2 176.19,135.71 v1(176.03,135.55) ; R547.2 203.02,17.04 v1(203.55,17.57)
  IN2 w0.089: v1(203.55,17.57) 203.57,17.57 203.61,17.61 207.45,17.61 207.79,17.95 207.79,18.58 206.87,19.51 206.87,21.06 208.17,22.37 208.17,23.13 206.85,24.45 206.85,25.59 206,26.45 204.93,26.45 204.6,26.78 204.6,30.07 203.59,31.07 201.92,31.07 201.26,31.73 201.26,31.86 196.02,37.1 196.02,37.76 194.68,39.1 194.02,39.1 193.72,39.41 193.72,40.56 192.14,42.13 192.14,43.6 192.22,43.68 192.22,44.03 192.14,44.11 192.14,47.82 188.95,51.02 188.95,55.47 189.06,55.59 189.06,55.94 188.81,56.19 187.3,56.19 183.41,60.08 183.41,60.58 180.58,63.41 178.43,63.41 175.98,65.85 175.98,73.12 175.16,73.94 175.16,80.16 175.98,80.97 175.98,84.06 179.85,87.94 v1(180.37,87.94)
  IN3 w0.089: v1(180.37,87.94) 180.31,88 180.31,88.15 180.91,88.74 180.91,102.33 180,103.24 180,106 180.42,106.42 180.42,112.31 181.16,113.04 181.16,124.13 180.17,125.12 180.17,126.08 179.94,126.31 179.94,132.17 176.55,135.55 v1(176.03,135.55)
LCD_OD_EN_R: length 23.8
  TOP w0.14: R34.2 177.58,136.21 Q4.3 175,136.21 174.55,136.66 174.55,137.54 R33.1 174.1,138.61 173.4,139.31 v1(171.21,139.31)
  IN1 w0.086: v1(171.21,139.31) 171.21,138.17 170.54,137.49 170.54,131.41 171,130.95 175.51,130.95 v1(175.84,130.62)
  BOTTOM w0.14: v1(175.84,130.62) 175.46,130.25 CN10.37
LCD_VDD: length 186.4
  TOP w0.102: v2(38.69,95.64) 38.66,95.64 38.35,95.95 UG1.BH3
  TOP w0.14: v1(171.02,84.12) 167.39,84.12 165.55,85.96 105.46,85.96 105.26,86.17 100.76,86.17 v1(97.29,82.69)
  IN2 w0.089: v1(97.29,82.69) 97.29,84.25 93.93,87.61 87.86,87.61 82.48,82.23 61.76,82.23 60.98,83.01 56.55,83.01 54.89,84.66 52.41,84.66 51.68,85.39 50.72,85.39 48.12,87.99 45,87.99 44.56,88.44 44.56,91.16 45.08,91.68 45.08,93.24 45.12,93.27 45.12,93.4 44.27,94.25 44.27,96.31 43.92,96.66 43.49,96.66 43.49,96.65 42.66,96.65 42.21,97.1 42.21,97.64 41.77,98.09 41.41,98.09 41.17,97.84 41.17,97.53 41.01,97.37 40.67,97.37 40.2,96.9 40.2,96.33 39.82,95.95 39.08,95.95 38.76,95.64 v2(38.69,95.64)
  BOTTOM w0.14: R699.1 177.65,103.55 v1(177.45,103.34) 176.87,102.77 173.33,102.77 170.94,100.38 170.94,96.96 168.01,94.03 168.01,93.1 166.98,92.07 166.98,87.77 168.64,86.11 170.61,86.11 171.53,85.18 171.53,84.48 171.17,84.12 v1(171.02,84.12) ; RG160.2 38.08,94.89 38.69,95.5 v2(38.69,95.64)
LCDVCC: length 20.6
  TOP w0.508: 181.32,109.41 181.32,108.8 180.24,107.72 Q14.2 179.15,107.72 v1(178.76,108.12) ; R100.1 181.56,105.06 182.08,104.54 182.08,102.55 181.77,102.24
  IN1 w0.508: v1(174.9,110) 176.88,110 v1(178.76,108.12) 177.9,107.26 177.9,103.76 179.17,102.49 v1(180.14,102.49)
LID#: length 325
  TOP w0.14: v1(72.8,40.77) 73.04,40.77 R226.1 ; v1(176.41,119.37) 176.04,119.01 R80.2 176.36,118.67 176.53,118.84 177.17,118.84 D14.1
  IN2 w0.089: v1(118.43,133.36) 118.71,133.07 124.18,133.07 125.2,134.09 125.79,134.09 128.18,136.48 155.72,136.48 156.71,135.49 158.16,135.49 158.48,135.18 160.12,135.18 160.51,134.78 167.92,134.78 168.97,133.73 168.97,129.22 169.44,128.74 172.8,128.74 175.05,126.5 175.05,121.25 176.41,119.89 v1(176.41,119.37) ; v1(72.8,40.77) 72.89,40.68 80.73,40.68 82.03,41.97 83.55,41.97 84.14,42.56 85.12,42.56 85.79,41.88 87.49,41.88 88.36,42.75 88.36,44.96 89.09,45.69 89.09,46.36 92.91,50.19 93.68,50.19 94.3,50.8 94.3,51.48 95.1,52.28 95.73,52.28 96.8,53.34 96.8,56.18 96.87,56.25 96.87,61.51 96.45,61.93 96.45,67.52 96.67,67.73 96.67,68.61 101.17,73.12 101.65,73.59 101.65,75.42 102.17,75.94 102.17,77.14 102.96,77.93 104.07,77.93 106.86,80.72 106.86,83.33 107.47,83.94 107.47,86.9 107.9,87.32 107.9,88.38 106.93,89.35 105.7,89.35 105.1,89.95 105.1,92.88 105.22,93 105.22,97.38 106.32,98.49 106.32,110.61 107.26,111.54 107.26,126.42 108.56,127.73 108.56,130.55 107,132.11 107,134.45 v1(107.54,134.99) 107.52,134.99 107,135.51 107,145.16 105.8,146.37 105.8,149.95 104.07,151.67 104.07,157.02 105.8,158.75 105.8,159.82 105.27,160.35 103.71,160.35 103.55,160.18 97.62,160.18 97.12,160.68 84.54,160.68 82.01,163.21 79.24,163.21 77.49,161.47 76.48,161.47 76.06,161.89 75.98,161.89 75.58,162.29 75.58,162.55 75.16,162.97 72.61,162.97 71.86,162.22 71.45,162.22 70.45,161.22 69.54,161.22 69.15,161.61 68.64,161.61 66.84,159.81 64.74,159.81 62.95,161.6 61.05,161.6 61.01,161.64 57.19,161.64 56.66,161.11 47.54,161.11 46.49,162.15 45.19,162.15 43.8,160.76 42.02,160.76 41.76,161.02 38.35,161.02 37.65,160.32 31.62,160.32 30.55,159.25 v1(30.55,159.23)
  BOTTOM w0.14: v1(107.54,134.99) 107.53,135 107.53,135.85 108.27,136.59 v1(108.8,136.59) 112.56,136.59 115.79,133.36 v1(118.43,133.36) ; CN8.6 31.35,160.2 31.26,160.11 D86.1 30.79,159.47 v1(30.55,159.23)
LID#_EC_L: length 7.2
  TOP w0.14: U18.118 75.03,35.95 74.8,36.19 74.8,37.38 74.99,37.57 C245.2 74.88,38.04 74.37,38.54 73.56,38.54 73.12,38.98 D31.1 73.42,39.4 73.42,39.97 73.78,40.33 R226.2
LID#_MACRO: length 26.1
  TOP w0.14: R298.1 65.55,34.25 65.87,33.94 65.87,33.71 66.06,33.52 67.16,33.52 67.43,33.24 67.43,32.39 68.12,31.71 v1(68.12,30.73)
  IN3 w0.089: v1(68.12,30.73) 68.12,30.29 70.22,28.19 70.22,25.67 70.91,24.98 72.08,24.98 72.65,24.41 72.65,23.24 72.23,22.83 72.23,22.38 75.9,18.71 78.17,18.71 v1(78.68,18.2)
  BOTTOM w0.14: CN19.20 79.15,18.82 78.68,18.36 v1(78.68,18.2)
LPC_LAD0: length 214.3
  TOP w0.14: v1(54.63,47.32) 54.59,47.32 54.35,47.08 R179.2 ; U18.10 73.28,29.82 74.84,31.38 74.84,32.59 v1(74.77,32.66)
  IN2 w0.089: v1(54.63,47.32) 54.63,46.72 55.04,46.31 55.29,46.31 56.28,45.33 56.28,45.2 55.62,44.55 55.62,43.98 55.22,43.58 55.22,41.17 55.51,40.89 55.88,40.89 56.54,40.23 56.54,39.82 60.53,35.83 61.58,35.83 61.95,35.46 62.8,35.46 63.08,35.74 63.96,35.74 64.32,35.38 67.18,35.38 67.58,34.98 68.24,34.98 68.75,34.47 70.56,34.47 71.64,33.39 74.05,33.39 74.77,32.67 v1(74.77,32.66)
  IN3 w0.089: v1(74.77,32.66) 74.77,32.58 75.36,31.99 75.36,31.18 75.62,30.92 77.04,30.92 78.09,29.87 79.34,29.87 80.76,28.45 82.86,28.45 84.37,26.94 84.64,26.94 85.62,25.96 87.74,25.96 89.07,27.3 91.26,27.3 92.09,26.46 92.46,26.46 93.15,27.15 94.9,27.15 95.34,26.7 96.95,26.7 97.53,27.29 97.53,27.88 97.89,28.24 101.01,28.24 101.47,28.7 109.3,28.7 109.74,29.14 148.36,29.14 148.67,28.82 152.19,28.82 153.07,27.94 163.38,27.94 164.27,28.82 166.53,28.82 167.03,28.32 174.17,28.32 176.64,25.85 176.64,23.67 177.37,22.94 179.04,22.94 179.9,23.8 182.44,23.8 182.75,23.49 185.66,23.49 187.36,21.79 187.36,20.11 187.78,19.69 189.08,19.69 190.5,18.27 190.98,18.27 191.43,17.82 193.63,17.82 194.52,16.93 195.11,16.93 196.97,15.07 199.22,15.07 199.81,14.48 201.15,14.48 201.74,15.07 204.02,15.07 204.15,15.19 210.17,15.19 210.32,15.03 213.74,15.03 214.24,15.54 215.23,15.54 215.92,14.84 216.28,14.84 216.57,15.13 220.22,15.13 221.56,16.48 224.48,16.48 224.81,16.15 224.81,15.41 225.09,15.13 228.59,15.13 229.19,15.73 v1(229.63,15.73)
  BOTTOM w0.14: v1(229.63,15.73) 229.64,15.74 229.66,15.74 230.12,16.2 230.12,16.63 R1079.2
LPC_LAD0_C: length 6
  TOP w0.14: v1(51.83,45.3) 52.17,45.64 52.17,46.1 v1(52.4,46.34) R179.1
  BOTTOM w0.14: CN16.58 51.4,47 52.17,46.24 52.17,45.64 v1(51.83,45.3)
LPC_LAD1: length 217.7
  TOP w0.14: v1(54.66,49.15) 54.07,49.15 R173.2 ; v1(74.38,31.58) 73.02,30.22 U18.9
  IN2 w0.089: v1(54.66,49.15) 54.36,49.15 53.93,48.72 53.93,46.59 54.43,46.09 54.43,43.87 54.64,43.67 54.64,41.6 54.24,41.2 54.24,39.55 55.77,38.01 56.72,38.01 58.22,36.52 58.44,36.3 59.24,36.3 59.63,35.91 59.63,35.11 60.12,34.62 61.3,34.62 61.56,34.87 63.04,34.87 63.32,35.15 63.72,35.15 64.08,34.8 66.58,34.8 67.9,33.48 69.07,33.48 70.65,31.9 71.2,31.9 71.68,32.38 73.57,32.38 v1(74.38,31.58)
  IN3 w0.089: v1(74.38,31.58) 74.38,30.92 75.4,29.9 75.4,29.32 75.81,28.9 76.55,28.9 77.88,27.57 82.5,27.57 84,26.07 84.28,26.07 84.93,25.41 84.93,24.66 85.81,23.78 87.74,23.78 88,24.04 89.67,24.04 89.93,24.31 90.22,24.31 91.59,25.67 93.9,25.67 94.28,26.05 95.05,26.05 95.08,26.02 99.43,26.02 100.12,26.71 100.31,26.71 101.71,28.11 109.54,28.11 109.98,28.56 148.11,28.56 148.48,28.19 152,28.19 152.83,27.35 163.63,27.35 164.51,28.24 166.29,28.24 166.79,27.73 171.9,27.73 175.54,24.09 175.54,23.55 176.19,22.9 176.58,22.9 177.5,21.98 186.34,21.98 186.78,21.54 186.78,19.86 187.54,19.1 188.43,19.1 191.85,15.68 195.53,15.68 196.72,14.49 198.98,14.49 199.57,13.9 201.39,13.9 201.98,14.49 205.28,14.49 205.7,14.06 207.15,14.06 207.39,14.3 209.88,14.3 210.39,13.79 211.04,13.79 211.7,14.45 213.98,14.45 214.48,14.95 214.98,14.95 215.68,14.26 216.52,14.26 216.81,14.55 221.28,14.55 221.96,15.23 223.76,15.23 224.45,14.55 230.88,14.55 232.05,15.71 v1(232.05,16.22)
  BOTTOM w0.14: R1107.2 232.05,16.36 v1(232.05,16.22)
LPC_LAD1_C: length 3.7
  TOP w0.14: R173.1 52.64,48.51 v1(51.76,48.51)
  BOTTOM w0.14: CN16.66 51.26,49 v1(51.76,48.51)
LPC_LAD2: length 220.2
  TOP w0.14: v1(54.57,49.83) 54.27,50.13 R168.2 ; U18.8 72.71,30.62 73.45,31.36 v1(73.5,31.36)
  IN2 w0.089: v1(54.57,49.83) 54.34,49.83 53.64,49.13 53.64,46.47 54.14,45.97 54.14,43.75 54.34,43.54 54.34,41.72 53.95,41.32 53.95,39.43 55.65,37.72 56.49,37.72 59.89,34.33 61.42,34.33 61.68,34.58 63.16,34.58 63.36,34.78 63.68,34.78 63.95,34.5 66.46,34.5 67.78,33.19 68.95,33.19 70.79,31.35 71.78,31.35 72.11,31.67 72.45,31.67 72.76,31.36 v1(73.5,31.36)
  IN3 w0.089: v1(73.5,31.36) 73.5,31.36 73.54,31.32 73.54,30.93 73.84,30.63 73.84,29.17 74.9,28.11 76.52,28.11 77.79,26.84 79.9,26.84 80.62,26.13 81.19,26.13 81.5,26.44 81.5,26.66 81.83,26.99 82.25,26.99 83.76,25.48 84.03,25.48 84.35,25.17 84.35,24.41 85.57,23.19 87.7,23.19 88.21,22.68 90.47,22.68 91.15,23.36 94.35,23.36 95.74,24.74 97.6,24.74 97.78,24.92 99.16,24.92 100.37,26.13 100.55,26.13 101.96,27.53 109.78,27.53 110.14,27.89 118.94,27.89 119.02,27.97 147.87,27.97 148.24,27.6 151.76,27.6 152.59,26.77 163.87,26.77 164.75,27.65 166.04,27.65 166.55,27.15 171.65,27.15 174.96,23.85 174.96,23.31 175.95,22.32 176.34,22.32 177.26,21.4 183.12,21.4 184.36,20.15 185.66,20.15 187.3,18.52 188.18,18.52 191.61,15.1 195.29,15.1 196.48,13.9 198.73,13.9 199.32,13.31 201.64,13.31 202.23,13.9 204.93,13.9 205.35,13.48 207.4,13.48 207.63,13.71 208.78,13.71 209.19,13.3 209.19,12.92 209.48,12.63 209.85,12.63 210.31,13.1 211.17,13.1 211.94,13.87 213.54,13.87 214.21,13.2 215.05,13.2 215.52,13.68 222.01,13.68 223.16,14.82 223.75,14.82 224.32,14.25 231.5,14.25 v1(233.39,16.15)
  BOTTOM w0.14: v1(233.39,16.15) 233.83,16.58 R1087.2
LPC_LAD2_C: length 4.1
  TOP w0.14: v1(51.07,49.47) 51.53,49.01 52.37,49.01 52.97,49.61 R168.1
  BOTTOM w0.14: v1(51.07,49.47) 51.04,49.5 CN16.68
LPC_LAD3: length 219.4
  TOP w0.14: R167.2 52.52,50.66 54.57,50.66 v1(54.76,50.47) ; U18.7 72.03,31.02 72.22,31.2 v1(72.22,31.2)
  IN2 w0.089: v1(72.22,31.2) 72.22,31.2 72.07,31.06 70.67,31.06 68.86,32.86 67.69,32.86 66.34,34.21 63.83,34.21 63.63,34.42 63.41,34.42 63.28,34.29 61.8,34.29 61.55,34.03 59.77,34.03 56.37,37.43 55.53,37.43 53.66,39.31 53.66,41.01 53.41,41.26 53.41,42.52 53.85,42.96 53.85,45.85 53.34,46.35 53.34,49.35 54.46,50.47 v1(54.76,50.47)
  IN3 w0.089: v1(231.46,15.82) 230.49,14.84 224.57,14.84 223.22,16.18 221.68,16.18 220.34,14.84 216.69,14.84 216.4,14.55 215.8,14.55 215.1,15.24 214.36,15.24 213.86,14.74 211.58,14.74 210.91,14.08 210.51,14.08 209.69,14.9 204.27,14.9 204.15,14.78 201.86,14.78 201.27,14.19 199.69,14.19 199.1,14.78 196.84,14.78 195.65,15.97 191.97,15.97 188.55,19.4 187.66,19.4 187.07,19.98 187.07,21.66 185.53,23.2 182.62,23.2 182.31,23.51 180.02,23.51 179.16,22.65 177.25,22.65 176.46,23.44 176.07,23.44 175.84,23.67 175.84,24.21 172.02,28.03 166.91,28.03 166.41,28.53 164.39,28.53 163.5,27.65 152.95,27.65 152.07,28.53 148.55,28.53 148.24,28.85 109.86,28.85 109.42,28.41 101.59,28.41 100.19,27 100,27 99.31,26.31 95.32,26.31 94.77,26.86 93.27,26.86 92.58,26.17 91.67,26.17 90.52,25.01 87.3,25.01 87.12,24.83 87.12,24.83 85.67,24.83 85.22,25.28 85.22,25.53 84.4,26.36 84.13,26.36 82.62,27.87 78,27.87 76.67,29.2 75.93,29.2 75.69,29.44 75.69,30.02 74.78,30.94 74.78,31.74 74.54,31.98 74.06,31.98 73.98,32.06 73.07,32.06 v1(72.22,31.2)
  BOTTOM w0.14: R1078.2 231.47,15.82 v1(231.46,15.82)
LPC_LAD3_C: length 3.9
  TOP w0.14: v1(52.22,49.52) 51.7,49.52 51.25,49.97 R167.1
  BOTTOM w0.14: v1(52.22,49.52) 51.78,49.52 51.3,50 CN16.70
LPC_LFRAME#: length 214.5
  TOP w0.102: U14.BE38 221.7,24.04 222.28,23.45 222.28,22.08 222.14,21.94 222.14,21.69 222.37,21.46 222.37,20.56 222.83,20.1 222.83,19.5
  TOP w0.14: v1(71.13,32.4) 71.13,32.01 70.54,31.42 U18.6 ; v1(54.92,47.92) 54.53,47.92 54.17,47.57 53.44,47.57 53.15,47.85 R176.2 ; v1(221.78,14.32) 221.78,14.95 222.18,15.36 222.18,15.73 222.55,16.09 222.55,17.47 222.83,17.75 222.83,19.5
  IN2 w0.089: v1(71.13,32.4) 71.13,32.78 70.13,33.77 68.02,33.77 66.71,35.09 64.2,35.09 63.84,35.44 63.2,35.44 62.92,35.16 61.83,35.16 61.45,35.54 60.41,35.54 59.36,36.59 58.56,36.59 57.16,37.99 57.16,38.79 55.76,40.19 55.03,40.19 54.58,40.65 54.58,41.13 54.93,41.48 54.93,43.79 54.72,43.99 54.72,46.21 54.22,46.71 54.22,47.66 54.48,47.92 v1(54.92,47.92)
  IN3 w0.089: v1(221.78,14.32) 221.71,14.25 216.93,14.25 216.64,13.97 215.4,13.97 214.93,13.49 214.33,13.49 213.66,14.16 211.82,14.16 211.16,13.5 210.27,13.5 209.76,14.01 207.51,14.01 207.28,13.77 205.47,13.77 205.05,14.2 202.11,14.2 201.51,13.61 199.45,13.61 198.86,14.2 196.6,14.2 195.41,15.39 191.73,15.39 188.3,18.81 187.42,18.81 185.78,20.44 184.48,20.44 183.24,21.69 177.38,21.69 176.46,22.61 176.07,22.61 175.25,23.43 175.25,23.97 171.78,27.44 166.67,27.44 166.16,27.95 164.63,27.95 163.75,27.06 152.71,27.06 151.88,27.89 148.36,27.89 147.99,28.26 110.1,28.26 109.66,27.82 101.84,27.82 100.43,26.42 100.24,26.42 99.04,25.21 97.66,25.21 97.48,25.03 95.62,25.03 94.23,23.65 90.74,23.65 90.38,24.01 90.05,24.01 89.81,23.78 89.8,23.78 89,22.97 88.46,22.97 87.95,23.49 85.69,23.49 84.64,24.54 84.64,25.29 84.15,25.77 83.88,25.77 82.37,27.28 77.76,27.28 76.64,28.4 75.03,28.4 74.14,29.29 74.14,30.75 73.96,30.92 73.96,31.56 73.75,31.77 73.32,31.77 72.87,31.31 72.87,30.97 72.61,30.71 72.09,30.71 71.74,31.05 71.74,31.31 72.21,31.78 72.21,32.12 71.86,32.48 71.21,32.48 v1(71.13,32.4)
LPC_LFRAME#_C: length 5.7
  TOP w0.14: v1(54.54,48.51) 54.08,48.05 R176.1
  BOTTOM w0.14: v1(54.54,48.51) 54.04,48 CN16.62
LPC_PIRQAB: length 23.4
  TOP w0.14: U14.BA36 220.76,26.48 221.15,26.48 v1(221.17,26.5)
  IN1 w0.086: 226.68,15.97 226.3,16.35 225.12,16.35 224.9,16.13 224.9,15.73 224.39,15.22 223.68,15.22 223.33,15.58 223.33,17.58 223.89,18.14 223.89,22.04
  IN1 w0.102: v1(221.17,26.5) 221.02,26.35 221.02,25.66 221.52,25.16 221.52,24.41 223.89,22.04 ; 226.68,15.97 v1(226.68,15.71)
  BOTTOM w0.14: v1(226.68,15.71) 226.7,15.69 226.71,15.69 226.87,15.54 226.87,14.24 225.65,13.02 224.88,13.02 224.68,13.22 224.68,14.05 R1123.2
M_A_A0: length 82.5
  TOP w0.079: v1(140.26,100.45) 139.09,101.62 139.09,105.91 U3.AH3
  TOP w0.102: JDIM2.144 137.32,39.79 136.94,40.17 136.94,40.73 136.31,41.37 135.96,41.37 135.48,41.84 134.94,41.84 v1(134.82,41.73)
  IN2 w0.079: v1(140.26,100.45) 139.53,99.72 139.53,96.55
  IN2 w0.178: v1(134.82,41.73) 134.75,41.81 134.75,43.25 134.66,43.33 134.66,44.74 133.84,45.56 133.84,46.48 133.04,47.28 133.04,50.33 131.91,51.46 131.91,53.89 132.16,54.14 132.16,54.96 132.68,55.48 132.68,58.06 132.99,58.37 133.07,58.46 133.07,60.53 133.88,61.34 133.88,84.12 139.07,89.32 139.07,94.38 139.53,94.83 139.53,96.55
  BOTTOM w0.102: v1(134.82,41.73) 135.25,41.73 135.52,42 135.52,42.56 135.42,42.66 135.07,42.66 134.97,42.77 134.97,42.97 135.07,43.07 135.42,43.07 135.52,43.17 135.52,43.38 135.42,43.48 134.71,43.48 134.64,43.55 134.64,43.76 134.76,43.88 135.03,43.88 135.42,44.28 JDIM4.144
M_A_A1: length 80.9
  TOP w0.079: U3.AP4 144.11,106.55 144.11,104.7 143.63,104.22 143.63,103.28 v1(143.86,103.05)
  TOP w0.102: v1(137.46,41.44) 138.5,42.48 138.5,42.78 140.07,44.35 JDIM2.133
  IN2 w0.079: v1(143.86,103.05) 143.27,102.45 143.27,101.23 142.92,100.88 142.61,100.88 141.2,99.47 141.2,96.54
  IN2 w0.178: v1(137.46,41.44) 136.94,41.96 136.94,45.3 136.17,46.07 136.17,51.26 135.61,51.82 135.61,54.06 135.85,54.3 135.85,55.35 136.22,55.72 136.22,56.16 136.54,56.48 136.54,57.39 137.43,58.28 137.43,61.67 137.01,62.09 137.01,64.64 137.43,65.07 137.43,83.79 141.79,88.15 141.79,93.5 141.2,94.09 141.2,96.54
  BOTTOM w0.102: v1(137.46,41.44) 137.07,41.05 137.07,40.02 137.61,39.47 137.61,38.59 137.89,38.3 138,38.3 138.17,38.13 JDIM4.133
M_A_A2: length 80.8
  TOP w0.089: v1(143.17,106.51) 143.49,106.84 U3.AN4
  TOP w0.102: v1(137.47,42.75) 137.38,42.75 136.84,42.2 136.84,41.44 137.15,41.14 137.15,40.25 137.61,39.79 139.13,39.79 140.32,38.6 JDIM2.132
  IN2 w0.079: v1(143.17,106.51) 143.31,106.37 143.31,104.32 144.29,103.34 144.29,102.91 143.55,102.18 143.55,101.29 142.99,100.72 142.75,100.72 141.41,99.38 141.41,96.87 141.67,96.61 141.67,95.57
  IN2 w0.178: 141.67,95.57 141.67,94.17 142.31,93.53 142.31,87.94 137.95,83.58 137.95,73.34 138.25,73.05 138.25,68.74 137.95,68.45 137.95,58.06 137.06,57.17 137.06,56.26 136.74,55.94 136.74,54.97 136.78,54.93 136.78,50.15 136.69,50.06 136.69,46.29 137.47,45.51 v1(137.47,42.75)
  BOTTOM w0.102: JDIM4.132 138.42,44.38 137.47,43.42 v1(137.47,42.75)
M_A_A3: length 80.1
  TOP w0.079: v1(145.38,103.22) 145.34,103.22 144.76,103.79 144.76,104.19 145,104.43 145,106.88 U3.AP5
  TOP w0.102: JDIM2.131 140.57,44.53 140.92,44.18 140.92,43.67 140.1,42.85 140.1,41.7 139.91,41.51 v1(139.91,41.31)
  IN2 w0.079: v1(145.38,103.22) 145.35,103.22 144.97,102.84 144.97,102.65 144.11,101.79 144.11,96.66 144.29,96.48
  IN2 w0.178: 144.29,96.48 144.61,96.16 144.61,93.82 145.08,93.35 145.08,84.56 143.52,82.99 143.52,77.8 141.43,75.72 141.43,63.8 141.28,63.65 141.28,57.57 140.29,56.57 140.29,53.63 140.48,53.43 140.48,51.05 139.85,50.41 139.85,45.62 139.47,45.24 139.47,41.76 139.91,41.32 v1(139.91,41.31)
  BOTTOM w0.102: v1(139.91,41.31) 139.72,41.11 139.72,40.44 139.87,40.29 139.87,38.83 139.45,38.41 138.86,38.41 138.67,38.22 JDIM4.131
M_A_A4: length 79.9
  TOP w0.079: U3.AP2 144.69,105.25 144.69,104.62 144.2,104.13 v1(144.2,104.01)
  TOP w0.102: JDIM2.128 141.32,38.15 139.82,39.66 139.82,40.26 139.31,40.77 139.16,40.77 139.03,40.64 139.03,40.47 v1(139.35,40.15)
  IN2 w0.079: 143.89,96.32 143.89,102.03 144.6,102.73 144.6,103.62 v1(144.2,104.01)
  IN2 w0.178: v1(139.35,40.15) 139.33,40.17 139.33,41.16 138.95,41.54 138.95,45.46 139.33,45.84 139.33,50.63 139.96,51.26 139.96,53.17 139.76,53.38 139.76,56.78 140.76,57.78 140.76,63.92 140.91,64.08 140.91,75.93 143,78.02 143,83.21 144.56,84.78 144.56,93.35 143.89,94.02 143.89,96.32
  BOTTOM w0.102: JDIM4.128 139.42,44.57 139.27,44.42 139.27,40.22 v1(139.35,40.15)
M_A_A5: length 81.6
  TOP w0.079: v1(145.38,101.9) 145.08,101.9 144.32,102.65 144.32,103.33 143.79,103.86 143.79,104.16 144.4,104.77 U3.AP1
  TOP w0.102: JDIM2.126 141.82,38.12 140.97,38.98 140.31,39.89 139.6,40.98 139.46,41.31 139.46,41.99 139.78,43.35 140.42,43.99 140.49,43.99 v1(140.51,44.02)
  IN2 w0.079: v1(145.38,101.9) 145.05,101.9 144.49,101.33 144.49,97.46 145.13,96.82
  IN2 w0.178: v1(140.51,44.02) 140.51,44.81 140.89,45.19 140.89,49.98 141.71,50.8 141.71,54.07 142.24,54.6 142.24,56.1 142.37,56.23 142.62,56.23 142.85,56.46 142.85,75.35 144.56,77.06 144.56,82.56 146.13,84.13 146.13,93.57 145.6,94.1 145.6,96.35 145.13,96.82
  BOTTOM w0.102: v1(140.51,44.02) 140.51,44 140.35,43.84 140.35,43.44 140.45,43.34 140.45,43.23 140.35,43.13 140.07,43.13 139.99,43.06 139.99,42.83 140.81,42.01 140.81,41.84 140.69,41.72 140.52,41.72 140.16,42.08 139.7,42.08 139.59,42.19 139.59,44.25 139.92,44.59 JDIM4.126
M_A_A6: length 80
  TOP w0.079: v1(145.38,102.56) 145.1,102.56 144.6,103.06 144.6,104.26 144.84,104.51 144.84,105.74 U3.AP3
  TOP w0.102: v1(140.38,40.79) 140.56,40.98 140.56,42.45 140.88,42.76 141.45,42.76 141.79,43.1 141.79,44.12 141.57,44.33 JDIM2.127
  IN2 w0.079: 144.72,96.69 144.3,97.11 144.3,101.58 145.28,102.56 v1(145.38,102.56)
  IN2 w0.178: 144.72,96.69 145.21,96.2 145.21,93.79 145.6,93.39 145.6,84.35 144.04,82.78 144.04,77.28 142.33,75.57 142.33,57.88 141.19,56.73 141.19,51.01 140.37,50.2 140.37,45.4 139.99,45.03 139.99,41.99 140.43,41.55 140.43,40.85 v1(140.38,40.79)
  BOTTOM w0.102: JDIM4.127 139.67,38.14 140.17,38.64 140.17,39.25 140.5,39.58 140.5,39.73 140.17,40.06 140.17,40.31 139.94,40.54 139.94,40.82 140.05,40.92 140.27,40.92 140.38,40.82 v1(140.38,40.79)
M_A_A7: length 80
  TOP w0.089: U3.AN1 143.29,104.51 143.29,102.43 144.57,101.15 144.57,100.58 v1(145.22,99.93)
  TOP w0.102: v1(141.1,42.36) 141.04,42.3 141.04,39.45 142.13,38.36 142.67,38.36 142.82,38.2 JDIM2.122
  IN2 w0.079: v1(145.22,99.93) 144.86,99.58 144.86,98.31 145.9,97.28 145.9,97.22
  IN2 w0.178: 145.9,97.22 146.29,96.83 146.29,94.26 147.17,93.39 147.17,83.7 145.6,82.13 145.6,76.63 143.89,74.92 143.89,64.21 144.07,64.04 144.43,64.04 144.61,63.86 144.61,63.5 144.43,63.32 144.07,63.32 143.89,63.15 143.89,56.03 143.28,55.42 143.28,54.17 142.75,53.64 142.75,50.37 142.3,49.92 142.3,45.13 141.55,44.38 141.55,43.06 141.1,42.6 v1(141.1,42.36)
  BOTTOM w0.102: v1(141.1,42.36) 141.02,42.27 141.02,41.63 141.11,41.53 141.38,41.53 141.55,41.69 141.55,42.83 141.63,42.91 141.63,43.82 141.5,43.96 141.3,43.96 140.92,44.34 JDIM4.122
M_A_A8: length 82.9
  TOP w0.079: v1(145.37,100.59) 144.78,101.18 144.78,101.42 143.46,102.75 143.46,104.27 143.96,104.77 143.96,105.89 U3.AN3
  TOP w0.102: JDIM2.125 142.07,44.07 141.99,43.98 141.99,42.95 141.75,42.71 141.75,41.4 142.03,41.12 142.03,40.51 v1(141.65,40.12)
  IN2 w0.079: v1(145.37,100.59) 145.09,100.59 144.65,100.15 144.65,97.85 145.97,96.53
  IN2 w0.178: 145.97,96.53 145.97,94.22 146.65,93.54 146.65,83.91 145.08,82.35 145.08,76.85 143.37,75.14 143.37,56.25 142.76,55.64 142.76,54.38 142.23,53.85 142.23,50.58 141.41,49.76 141.41,44.97 141.03,44.6 141.03,43.79 140.58,43.34 140.58,42.14 140.97,41.74 140.97,40.8 v1(141.65,40.12)
  BOTTOM w0.102: v1(141.65,40.12) 141.38,40.39 141.38,40.45 141.19,40.64 141.19,41.07 141.11,41.15 140.91,41.15 140.81,41.05 140.81,40.58 141.03,40.36 141.03,39.75 140.45,39.17 140.45,38.51 140.17,38.23 JDIM4.125
M_A_A9: length 78.8
  TOP w0.089: U3.AT4 146.07,106.84 v1(145.73,106.5)
  TOP w0.102: JDIM2.121 143.07,44.18 142.6,43.71 142.6,41.95 v1(142.26,41.61)
  IN2 w0.079: 147.38,96.57 147.08,96.87 147.08,100.54 146.61,101 146.61,103.07 145.28,104.41 145.28,106.04 v1(145.73,106.5)
  IN2 w0.178: v1(142.26,41.61) 142.26,41.77 142.6,42.11 142.6,43.95 143.39,44.74 143.39,45.62 143.81,46.04 143.81,49.38 145.37,50.94 145.37,58.4 146.45,59.48 146.45,63.45 147.05,64.05 147.05,81.53 148.94,83.43 148.94,93.07 147.66,94.35 147.66,96.29 147.38,96.57
  BOTTOM w0.102: v1(142.26,41.61) 142.05,41.4 142.05,39.96 141.17,39.08 JDIM4.121
M_A_A10: length 79.5
  TOP w0.089: v1(140.26,102.39) 139.66,102.99 139.66,105.24 U3.AH2
  TOP w0.102: JDIM2.146 134.82,38.56 134.93,38.67 134.93,39.21 134.16,39.98 134.16,41.63 133.78,42.01 v1(133.78,42.04)
  IN2 w0.079: v1(140.26,102.39) 139.14,101.27 139.14,98.22 138.94,98.02 138.94,95.46
  IN2 w0.178: 138.94,95.46 138.03,94.55 138.03,89.78 132.84,84.59 132.84,77.71 131.85,76.72 131.85,60.97 132.03,60.79 132.03,58.89 131.95,58.81 131.95,58.8 131.64,58.5 131.64,55.91 131.12,55.39 131.12,54.57 130.87,54.32 130.87,53.64 130.5,53.27 130.5,51.39 131.99,49.9 131.99,46.85 132.8,46.05 132.8,45.13 133.62,44.31 133.62,42.2 v1(133.78,42.04)
  BOTTOM w0.102: v1(133.78,42.04) 133.74,42.08 133.74,42.77 134.02,43.05 134.02,43.24 133.92,43.34 133.73,43.34 133.64,43.25 133.49,43.25 133.33,43.42 133.33,43.58 133.49,43.73 133.49,43.87 133.35,44.01 133.03,44.01 132.92,44.12 JDIM4.146
M_A_A11: length 79.7
  TOP w0.089: v1(145.27,98.69) 144.29,99.66 144.29,101.05 143.12,102.21 143.12,105 U3.AN2
  TOP w0.102: JDIM2.120 143.32,38.23 142.89,38.66 142.16,38.66 141.24,39.58 141.24,40.57 v1(141.62,40.95)
  IN2 w0.178: v1(145.27,98.69) 145.72,98.69 146.61,97.8 146.61,94.34 147.69,93.27 147.69,83.48 146.12,81.91 146.12,76.41 145.23,75.52 145.23,63.6 145.52,63.31 145.52,59.86 144.41,58.75 144.41,55.81 143.8,55.2 143.8,50.68 142.82,49.7 142.82,44.91 142.08,44.16 142.08,42.84 141.66,42.43 141.66,41.15 141.62,41.11 v1(141.62,40.95)
  BOTTOM w0.102: v1(141.62,40.95) 141.74,41.07 141.74,41.21 141.75,41.22 141.75,42.74 141.83,42.83 141.83,43.91 141.42,44.32 JDIM4.120
M_A_A12: length 82.5
  TOP w0.079: U3.AU4 147.36,106.39 147.36,103.76 v1(148.16,102.96)
  TOP w0.102: v1(142.44,39.84) 142.44,40.54 142.9,41 142.9,43.53 143.57,44.21 JDIM2.119
  IN2 w0.079: v1(148.16,102.96) 147.25,102.05 147.25,97.21 147.67,96.79
  IN2 w0.178: 147.67,96.79 148.07,96.39 148.07,94.55 149.46,93.15 149.46,83.21 147.57,81.31 147.57,59.62 145.89,57.94 145.89,50.72 144.33,49.16 144.33,45.82 143.91,45.4 143.91,44.52 143.12,43.74 143.12,41 142.44,40.32 v1(142.44,39.84)
  BOTTOM w0.102: JDIM4.119 141.67,38.38 141.98,38.68 142.18,38.68 142.3,38.81 142.3,38.93 142.21,39.02 141.9,39.02 141.8,39.12 141.8,39.22 141.9,39.32 142.53,39.32 142.75,39.54 142.93,39.54 143,39.61 143,39.76 142.92,39.84 v1(142.44,39.84)
M_A_A13: length 83
  TOP w0.079: v1(136.97,100.36) v1(136.44,100.89) 135.96,101.37 135.96,104.13 135.81,104.29 135.81,105.66 136.05,105.9 136.57,105.9 U3.AE3
  TOP w0.102: JDIM2.158 131.82,39.07 131.37,39.52 131.37,41.34 v1(130.61,42.1)
  IN2 w0.079: 136.34,97.5 136.34,99.73 v1(136.97,100.36)
  IN2 w0.178: 136.34,97.5 133.69,94.85 133.69,91.58 127.51,85.4 127.51,65.75 125.24,63.48 125.24,59.35 123.68,57.79 123.68,51.33 126.97,48.04 126.97,47.62 129.61,44.98 129.61,43.32 130.03,42.9 130.03,42.37 130.29,42.1 v1(130.61,42.1)
  BOTTOM w0.102: JDIM4.158 129.92,43.55 130.27,43.2 130.27,42.44 v1(130.61,42.1)
M_A_A14: length 82.5
  TOP w0.089: U3.AG4 138.49,106.84 v1(138.19,107.14)
  TOP w0.102: JDIM2.151 133.57,44.26 133.62,44.21 133.62,43.66 133.52,43.56 133.41,43.56 133.34,43.63 133.21,43.63 133.12,43.54 133.12,43.35 133.31,43.16 133.52,43.16 133.62,43.05 133.62,42.86 132.41,41.64 v1(132.24,41.64)
  IN2 w0.079: v1(138.19,107.14) 137.73,106.68 137.73,105.61 138.56,104.78 138.56,98.54 138.15,98.13 138.15,96.34
  IN2 w0.178: v1(132.24,41.64) 131.61,42.28 131.61,44.11 131.24,44.48 131.24,45.4 130.01,46.63 130.01,49.67 128.44,51.24 128.44,55.95 130.08,57.59 130.08,62.34 129.81,62.61 129.81,64.12 130.29,64.6 130.29,78.06 131.28,79.05 131.28,85.24 136.47,90.43 136.47,94.66 138.15,96.34
  BOTTOM w0.102: JDIM4.151 131.67,38.2 131.77,38.3 131.77,41.05 131.81,41.09 131.81,41.28 132.17,41.64 v1(132.24,41.64)
M_A_A15: length 81.6
  TOP w0.089: v1(136.95,99.06) 137.38,99.49 137.38,100.53 136.19,101.73 136.19,104.29 136.12,104.35 U3.AD1
  TOP w0.102: v1(130.68,42.77) 131.04,42.77 131.57,42.23 131.57,39.72 132.2,39.09 132.2,38.36 132.32,38.23 JDIM2.156
  IN2 w0.079: 136.71,97.91 136.71,98.81 v1(136.95,99.06)
  IN2 w0.178: 136.71,97.91 136.71,97.39 134.21,94.9 134.21,91.37 128.03,85.18 128.03,65.54 125.76,63.27 125.76,59.14 124.74,58.12 124.74,54.7 124.77,54.68 124.77,50.97 127.49,48.25 127.49,47.84 130.13,45.19 130.13,43.54 130.68,42.99 v1(130.68,42.77)
  BOTTOM w0.102: JDIM4.156 130.42,44.51 130.13,44.22 130.13,43.63 130.49,43.27 131.47,43.27 131.6,43.14 131.6,42.96 131.41,42.77 v1(130.68,42.77)
M_A_A16: length 81.5
  TOP w0.089: U3.AH4 139.08,106.54 138.25,106.54 v1(138.19,106.49)
  TOP w0.102: v1(132.4,42.27) 132.04,42.27 131.78,42.01 131.78,40.01 132.62,39.17 133.02,39.17 133.32,38.87 JDIM2.152
  IN2 w0.079: v1(138.19,106.49) 138.74,105.93 138.74,98.38 138.39,98.03 138.39,96.07
  IN2 w0.178: 138.39,96.07 136.99,94.66 136.99,90.21 131.8,85.02 131.8,78.64 130.81,77.65 130.81,64.38 130.33,63.91 130.33,62.82 130.6,62.56 130.6,57.37 128.96,55.73 128.96,51.46 130.53,49.89 130.53,46.85 131.76,45.62 131.76,44.7 132.13,44.33 132.13,42.55 v1(132.4,42.27)
  BOTTOM w0.102: JDIM4.152 131.42,44.44 131.89,43.98 131.89,42.86 132.4,42.34 v1(132.4,42.27)
M_A_BG#0: length 77.4
  TOP w0.089: U3.AU1 146.91,101.92 147.82,101.01 v1(148.17,101.01)
  TOP w0.102: JDIM2.115 144.57,44.38 144.92,44.04 144.92,42.7 144.43,42.21 v1(144.16,42.21)
  IN2 w0.079: 148.09,97.45 147.59,97.96 147.59,100.43 v1(148.17,101.01)
  IN2 w0.178: 148.09,97.45 148.85,96.69 148.85,94.87 150.51,93.22 150.51,82.78 148.61,80.88 148.61,59.19 147.48,58.06 147.48,50.84 145.98,49.34 145.98,46 144.95,44.97 144.95,42.99 v1(144.16,42.21)
  BOTTOM w0.102: v1(144.16,42.21) 143.53,42.21 143.43,42.1 143.43,40.69 143.69,40.43 143.69,39.33 143.28,38.92 142.67,38.32 JDIM4.115
M_A_BG#1: length 79
  TOP w0.079: v1(148.19,99.69) 147.99,99.69 147.24,100.44 147.24,101.26 146.62,101.89 146.62,105.24 U3.AU2
  TOP w0.102: v1(144.17,41.56) 144.69,41.56 145.12,42 145.12,44.32 145.07,44.37 JDIM2.113
  IN2 w0.178: v1(144.17,41.56) 144.41,41.56 145.47,42.63 145.47,44.75 146.5,45.78 146.5,49.12 148.01,50.63 148.01,57.85 149.13,58.97 149.13,80.67 151.03,82.56 151.03,93.27 149.33,94.97 149.33,96.79 147.79,98.32 147.79,99.3 v1(148.19,99.69)
  BOTTOM w0.102: JDIM4.113 143.17,38.44 144.06,39.32 144.06,40.46 143.73,40.79 143.73,41.46 143.83,41.56 v1(144.17,41.56)
M_A_BS#0: length 84.3
  TOP w0.089: U3.AH5 139.87,106.99 139.87,104.1 v1(140.26,103.7)
  TOP w0.102: v1(133.71,40.66) 133.9,40.48 133.9,40.11 133.79,40.01 133.41,40.01 133.31,39.9 133.31,39.7 133.41,39.6 134,39.6 134.1,39.5 134.1,39.3 134,39.19 133.67,39.19 133.55,39.07 133.55,38.9 133.82,38.63 JDIM2.150
  IN2 w0.079: 138.65,95.79 138.65,98.06 138.94,98.34 138.94,102.39 v1(140.26,103.7)
  IN2 w0.178: 138.65,95.79 137.51,94.65 137.51,90 132.32,84.8 132.32,78.17 131.33,77.19 131.33,64.17 130.85,63.69 130.85,63.04 131.12,62.78 131.12,57.1 129.9,55.89 129.9,51.25 131.05,50.1 131.05,47.06 132.28,45.83 132.28,44.91 133.1,44.09 133.1,41.2 133.64,40.66 v1(133.71,40.66)
  BOTTOM w0.102: v1(133.71,40.66) 133.2,41.17 133.2,43.17 133.09,43.29 133.09,43.67 132.73,44.02 132.35,44.02 131.92,44.45 JDIM4.150
M_A_BS#1: length 79.7
  TOP w0.089: v1(140.26,101.75) 139.37,102.64 U3.AH1
  TOP w0.102: JDIM2.145 135.07,44.53 134.89,44.35 134.69,44.35 134.53,44.19 134.53,44.08 134.69,43.93 135.09,43.93 135.19,43.83 135.19,43.67 135.09,43.56 134.33,43.56 134.23,43.46 134.23,43.23 134.33,43.13 135.12,43.13 135.29,42.96 135.29,42.87 135.15,42.73 134.34,42.73 134.25,42.64 v1(134.19,42.64)
  IN2 w0.079: 139.21,95.16 139.21,97.99 139.34,98.12 139.34,100.83 v1(140.26,101.75)
  IN2 w0.178: v1(134.19,42.64) 134.14,42.69 134.14,44.52 133.32,45.35 133.32,46.26 132.51,47.07 132.51,50.11 131.39,51.24 131.39,54.1 131.64,54.35 131.64,55.17 132.16,55.69 132.16,58.28 132.47,58.59 132.47,58.59 132.55,58.67 132.55,61 132.37,61.18 132.37,76.1 133.36,77.09 133.36,84.34 138.55,89.53 138.55,94.49 139.21,95.16
  BOTTOM w0.102: v1(134.19,42.64) 134.19,40.38 133.42,39.6 133.42,38.4 133.17,38.16 JDIM4.145
M_A_CB0: length 79.6
  TOP w0.079: v1(150.58,101.35) 149.85,102.08 149.85,103.65 149.7,103.79 149.7,104.68 149.72,104.69 149.72,105.02 149.43,105.31 U3.BA2
  TOP w0.102: v1(150.06,39.39) 150.65,39.39 150.77,39.27 150.77,38.67 150.32,38.23 JDIM2.92
  IN3 w0.127: v1(150.06,39.39) 151.51,40.84 151.51,44.27 153.72,46.48 153.72,48.46 156.81,51.55 156.81,81.81 156.23,82.4 156.05,82.4 155.83,82.17 155.64,82.17 155.46,82.35 155.46,82.52 155.69,82.75 155.69,82.93 154.96,83.67 154.96,98.24 151.85,101.35 v1(150.58,101.35)
  BOTTOM w0.102: JDIM4.87 149.67,38.31 149.55,38.44 149.36,38.44 149.27,38.52 149.27,38.74 149.45,38.92 149.45,39.17 149.8,39.51 149.94,39.51 v1(150.06,39.39)
M_A_CB1: length 80.7
  TOP w0.089: v1(151.05,100.91) 150.29,100.91 149.43,101.77 U3.BA1
  TOP w0.102: v1(150.07,40.73) 150.19,40.85 150.9,40.85 151.32,40.42 JDIM2.88
  IN3 w0.127: v1(150.07,40.73) 151.16,41.82 151.16,44.42 153.37,46.63 153.37,48.61 156.46,51.7 156.46,80.62 155.51,81.57 155.33,81.57 155.19,81.43 155,81.43 154.82,81.61 154.82,81.79 154.97,81.93 154.97,82.11 154.6,82.48 154.6,98.09 151.7,100.99 151.14,100.99 v1(151.05,100.91)
  BOTTOM w0.102: v1(150.07,40.73) 149.94,40.86 149.44,40.86 149.17,40.59 149.17,39.83 148.48,39.14 148.48,38.74 148.67,38.54 JDIM4.91
M_A_CB2: length 82.3
  TOP w0.089: U3.AY4 148.57,106.84 v1(148.25,106.51)
  TOP w0.102: v1(146.9,41.69) 148.07,42.86 JDIM2.101
  IN3 w0.127: v1(148.25,106.51) 149.08,105.67 149.08,95.06 150.19,93.95 150.19,90.46 151.68,88.97 151.68,73.1 151.81,72.98 152.73,72.98 152.86,72.85 152.86,72.6 152.73,72.47 151.81,72.47 151.68,72.34 151.68,72.09 151.81,71.96 152.73,71.96 152.86,71.83 152.86,67.66 152.65,67.45 152.65,66.57 152.86,66.36 152.86,61.74 153.3,61.3 153.3,59.14 153.17,59.01 153.04,59.01 152.92,58.89 152.92,58.63 153.04,58.51 153.17,58.51 153.3,58.38 153.3,58.13 153.17,58 153.04,58 152.92,57.87 152.92,57.62 153.04,57.49 153.17,57.49 153.3,57.36 153.3,55.01 152.62,54.34 152.62,51.93 150.06,49.36 150.06,46.9 147.76,44.6 147.76,43.08 147.44,42.75 147.44,42.33 146.9,41.8 v1(146.9,41.69)
  BOTTOM w0.102: v1(146.9,41.69) 146.87,41.68 146.69,41.81 145.7,43.66 145.42,44.2 JDIM4.104
M_A_CB3: length 82.4
  TOP w0.089: v1(148.25,107.16) 148.57,107.49 U3.AY5
  TOP w0.102: v1(146.97,40.01) 147.88,40.01 148.48,39.42 148.48,38.38 148.32,38.22 JDIM2.100
  IN3 w0.127: v1(146.97,40.01) 147.32,40.37 147.32,41.71 147.79,42.18 147.79,42.6 148.12,42.93 148.12,44.45 150.44,46.77 150.44,49.24 152.98,51.78 152.98,54.19 153.65,54.86 153.65,61.45 153.25,61.85 153.25,73.39 153.12,73.52 152.16,73.52 152.04,73.64 152.04,74 152.16,74.13 152.56,74.13 152.68,74.25 152.68,74.49 152.54,74.63 152.16,74.63 152.04,74.76 152.04,89.11 150.54,90.61 150.54,94.1 149.44,95.2 149.44,105.97 v1(148.25,107.16)
  BOTTOM w0.102: JDIM4.105 145.17,38.22 146.03,39.08 146.03,39.87 146.33,40.17 146.81,40.17 v1(146.97,40.01)
M_A_CB4: length 81.2
  TOP w0.079: U3.BA5 149.95,106.96 149.95,105.35 150.03,105.27 150.03,104.72 150.13,104.62 150.13,104.15 150.36,103.92 150.36,103.65 150.76,103.25 v1(150.76,103.23)
  TOP w0.102: v1(149.97,43.37) 150.04,43.3 150.19,43.3 150.35,43.47 150.35,43.66 150.45,43.76 150.65,43.76 150.8,43.91 150.8,44.25 150.57,44.47 JDIM2.91
  IN3 w0.127: v1(149.97,43.37) 150.2,43.37 150.45,43.63 150.45,44.71 152.66,46.92 152.66,48.9 155.72,51.97 155.72,77.38 155.59,77.5 154.02,77.5 153.89,77.63 153.89,77.89 154.02,78.01 154.98,78.01 155.1,78.14 155.1,78.39 154.98,78.52 154.02,78.52 153.89,78.65 153.89,78.9 154.02,79.03 154.98,79.03 155.1,79.16 155.1,79.41 154.98,79.54 154.02,79.54 153.89,79.66 153.89,97.37 151.6,99.66 150.9,99.66 149.79,100.76 149.79,102.27 v1(150.76,103.23)
  BOTTOM w0.102: JDIM4.88 149.42,44.45 149.2,44.23 149.2,43.77 149.65,43.32 149.92,43.32 v1(149.97,43.37)
M_A_CB5: length 82.5
  TOP w0.079: U3.BA4 149.72,106.54 149.72,105.34 149.87,105.19 149.87,104.46 149.87,104.45 149.87,104.03 150.13,103.77 150.13,103.22 v1(150.76,102.59)
  TOP w0.102: JDIM2.87 151.57,44.43 151.35,44.21 151.35,42.32 151.1,42.07 v1(150.04,42.07)
  IN3 w0.127: v1(150.76,102.59) 150.15,101.97 150.15,100.91 151.05,100.01 151.75,100.01 154.25,97.51 154.25,81.22 154.37,81.09 154.9,81.09 155.04,80.95 155.04,80.71 154.91,80.58 154.37,80.58 154.25,80.46 154.25,80.2 154.37,80.08 155.95,80.08 156.08,79.95 156.08,51.82 153.01,48.76 153.01,46.78 150.8,44.57 150.8,42.44 150.43,42.07 v1(150.04,42.07)
  BOTTOM w0.102: JDIM4.92 148.42,44.19 148.26,44.02 148.26,43.29 149.48,42.07 v1(150.04,42.07)
M_A_CB6: length 79.5
  TOP w0.079: v1(150.68,98.02) 150.28,98.02 148.82,99.47 148.82,104.76 U3.AY1
  TOP w0.102: JDIM2.104 147.32,38.46 147.54,38.68 147.54,39.31 147.32,39.53 147.12,39.53 v1(146.95,39.37)
  IN3 w0.127: v1(146.95,39.37) 147.68,40.09 147.68,41.56 148.15,42.04 148.15,42.45 148.48,42.78 148.48,44.31 150.8,46.63 150.8,49.09 153.33,51.63 153.33,54.04 154.01,54.72 154.01,61.86 153.65,62.22 153.65,75.07 153.52,75.2 152.52,75.2 152.39,75.32 152.39,75.58 152.52,75.7 153.47,75.7 153.62,75.85 153.62,76.09 153.49,76.21 152.52,76.21 152.39,76.34 152.39,89.26 150.9,90.75 150.9,94.24 150.68,94.46 v1(150.68,98.02)
  BOTTOM w0.102: JDIM4.101 146.17,38.59 146.37,38.78 146.37,39.43 146.5,39.57 146.75,39.57 v1(146.95,39.37)
M_A_CB7: length 79.3
  TOP w0.089: U3.AY2 148.57,105.54 v1(148.25,105.21)
  TOP w0.102: v1(146.98,43.21) 147.05,43.14 147.34,43.14 147.52,43.32 147.52,44.13 147.31,44.34 147.17,44.34 147.07,44.44 JDIM2.105
  IN3 w0.127: v1(148.25,105.21) 148.6,105.21 148.73,105.08 148.73,94.91 149.83,93.8 149.83,90.31 151.32,88.82 151.32,71.51 151.46,71.37 152.08,71.37 152.21,71.25 152.21,70.99 152.08,70.87 151.45,70.87 151.32,70.74 151.32,70.5 151.46,70.36 152.08,70.36 152.21,70.23 152.21,69.98 152.08,69.85 151.45,69.85 151.32,69.72 151.32,69.48 151.46,69.34 152.08,69.34 152.21,69.21 152.21,68.96 152.08,68.83 151.45,68.83 151.32,68.71 151.32,68.47 151.46,68.33 152.08,68.33 152.21,68.2 152.21,67.94 152.08,67.82 151.45,67.82 151.32,67.69 151.32,67.35 152.49,66.18 152.49,57.28 152.94,56.84 152.94,55.25 152.27,54.57 151.91,54.57 151.64,54.3 151.64,51.46 149.7,49.52 149.7,47.04 147.41,44.75 147.41,43.59 147.03,43.21 v1(146.98,43.21)
  BOTTOM w0.102: v1(146.98,43.21) 146.7,43.21 146.5,43.4 146.5,43.92 146.38,44.04 146.28,44.04 146.2,44.11 146.2,44.37 146.27,44.44 146.36,44.44 146.43,44.51 146.43,45.49 JDIM4.100
M_A_CKE0: length 77.5
  TOP w0.089: v1(145.73,105.15) 145.92,105.15 U3.AT1
  TOP w0.102: JDIM2.109 146.07,46.42 146.58,46.92 147.05,46.92 147.55,47.43 v1(147.94,47.43)
  IN2 w0.079: 148.95,101.53 148.62,101.86 148.62,103.13 148.05,103.7 147.16,103.7 145.73,105.13 v1(145.73,105.15)
  IN2 w0.14: v1(147.94,47.43) 148.28,47.43 148.45,47.25 148.45,46.31 148.67,46.09 149.21,46.09 149.37,46.26 149.37,47.73 149.81,48.17 149.81,50.58 150.64,51.42 150.64,57.96 151.62,58.94 151.62,59.39 151.48,59.53 151.16,59.53 151.02,59.67 151.02,59.95 151.16,60.09 151.48,60.09 151.62,60.23 151.62,60.5 151.48,60.64 151.16,60.64 151.02,60.78 151.02,61.06 151.16,61.2 151.48,61.2 151.62,61.34 151.62,61.62 151.35,61.89 151.35,62.19 151.62,62.46 151.62,76.23 151.76,76.37 152.31,76.37 152.45,76.51 152.45,76.79 152.31,76.92 151.76,76.92 151.62,77.06 151.62,77.34 151.76,77.48 152.31,77.48 152.45,77.62 152.45,77.9 152.31,78.04 151.76,78.04 151.62,78.18 151.62,78.46 151.76,78.6 152.31,78.6 152.45,78.74 152.45,79.02 152.31,79.16 151.76,79.16 151.62,79.3 151.62,79.58 151.76,79.72 152.31,79.72 152.45,79.86 152.45,80.14 152.31,80.28 151.76,80.28 151.62,80.42 151.62,80.72 151.84,80.93 152.23,80.93 152.45,81.16 152.45,93.37 150.72,95.1 150.72,96.8 148.95,98.57 148.95,101.53
M_A_CKE1: length 75.4
  TOP w0.089: U3.AT2 145.86,105.85 v1(145.73,105.85)
  TOP w0.102: JDIM2.110 145.82,39.42 v1(145.59,39.66)
  IN2 w0.079: v1(145.73,105.85) 145.92,105.85 147.39,104.39 147.6,104.39 148.95,103.03 148.95,101.98 149.22,101.72
  IN2 w0.14: 149.22,101.72 149.22,98.83 151.08,96.97 151.08,95.29 152.9,93.47 152.9,76.32 152.07,75.49 152.07,58.76 151.09,57.78 151.09,51.23 150.25,50.4 150.25,46.9 148.04,42.18 148.04,41.68 146.9,40.53 146.46,40.53 v1(145.59,39.66)
