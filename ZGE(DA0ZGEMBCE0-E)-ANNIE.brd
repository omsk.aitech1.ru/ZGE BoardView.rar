# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_RXP0_CN: length 14.2
  BOTTOM w0.14: C914.1 40.75,19.45 40.75,19.67 40.54,19.89 38.61,19.89 37.33,18.61 28.67,18.61 28.53,18.47 28.53,18.31 28.65,18.2 CN20.15
SATA_RXP_IN: length 2.6
  BOTTOM w0.14: U43.5 47.94,20.76 48.06,20.88 48.28,20.88 48.63,20.53 49.15,20.53 C910.1
SATA_RXP_OUT: length 3.1
  BOTTOM w0.14: C914.2 41.85,19.77 42.23,19.77 42.61,20.15 42.61,20.7 42.75,20.84 42.95,20.84 43.03,20.76 U43.11
SATA_TXN0: length 204.6
  TOP w0.089: U14.B38 221.72,45.37 221.72,45.77 222.08,46.12 222.08,46.9 221.93,47.05 221.79,47.05 v1(221.69,46.95)
  IN1 w0.086: v1(51.75,23.53) 51.54,23.53 51.34,23.33 51.34,23.06 52.04,22.37 52.04,21.94 52.2,21.77 52.81,21.77 53.37,22.34 53.37,28.89 54.29,29.81 56.05,29.81 56.36,29.49 57.99,29.49 59.32,30.82 61.57,30.82 61.93,30.46 62.71,30.46 63.38,31.13 66.92,31.13 67.09,31.3 68.34,31.3 69.05,30.59 73.53,30.59 74.06,31.11 75.79,31.11 76.35,31.67 83.92,31.67 85.7,29.9 86.51,29.9 86.61,30 90.62,30 91.01,30.38 95.64,30.38 96.12,29.9 97.96,29.9 98.87,28.99 100.76,28.99 101.97,27.78 110.38,27.78 112.62,30.02 148.2,30.02 148.95,29.27 152.58,29.27 152.77,29.46 168.03,29.46 168.26,29.23 172.19,29.23 173.02,30.05 175.82,30.05 181.59,35.83 186.08,35.83 187.2,36.95 197.88,36.95 199.52,38.59 203.99,38.59 204.68,39.27 207.53,39.27 207.86,38.94 209.73,38.94 211.26,40.47 216.74,40.47 217.36,39.85 219.86,39.85 219.98,39.97 220.49,39.97 220.9,40.39 222.87,40.39 223.5,41.02 223.5,42.81 223.26,43.06 222.7,43.06 222.32,43.43 222.32,46.9 221.99,47.23 221.81,47.23 221.69,47.11 v1(221.69,46.95)
  BOTTOM w0.14: C891.2 50.12,22.34 49.97,22.49 49.97,22.72 50.11,22.85 51.1,22.85 51.4,23.15 51.4,23.29 51.63,23.53 v1(51.75,23.53)
SATA_TXN0_CN: length 16.7
  BOTTOM w0.14: C902.1 40.74,21.47 40.74,21.76 40.6,21.9 40.05,21.9 39.05,20.9 38.51,20.9 36.93,19.32 27.66,19.32 27.03,18.69 27.03,18.37 27.15,18.25 CN20.18
SATA_TXN_IN: length 2.4
  BOTTOM w0.14: C891.1 49.2,22.66 48.67,22.66 48.39,22.38 48.03,22.38 47.92,22.26 U43.2
SATA_TXN_OUT: length 2.7
  BOTTOM w0.14: C902.2 41.8,21.75 42.07,21.75 42.37,22.05 42.37,22.21 42.54,22.38 42.96,22.38 43.08,22.26 U43.14
SATA_TXP0: length 204.6
  TOP w0.089: v1(221.69,47.61) 221.69,47.54 222.25,46.98 222.25,46.05 221.9,45.69 221.9,45.11 221.7,44.91 U14.C38
  IN1 w0.086: v1(221.69,47.61) 221.9,47.39 222.06,47.39 222.48,46.97 222.48,43.5 222.76,43.22 223.33,43.22 223.67,42.88 223.67,40.95 222.94,40.22 220.97,40.22 220.55,39.81 220.05,39.81 219.93,39.68 217.3,39.68 216.68,40.3 211.33,40.3 209.8,38.78 207.79,38.78 207.46,39.11 204.75,39.11 204.06,38.42 199.59,38.42 197.95,36.78 187.27,36.78 186.15,35.67 181.66,35.67 175.88,29.89 173.09,29.89 172.26,29.06 168.19,29.06 167.97,29.29 152.83,29.29 152.65,29.11 148.88,29.11 148.13,29.86 112.69,29.86 110.45,27.61 101.9,27.61 100.69,28.82 98.81,28.82 97.9,29.73 96.06,29.73 95.57,30.22 91.08,30.22 90.69,29.83 86.68,29.83 86.58,29.73 85.63,29.73 83.85,31.51 76.42,31.51 75.86,30.95 74.13,30.95 73.6,30.42 68.99,30.42 68.27,31.14 67.16,31.14 66.99,30.97 63.45,30.97 62.78,30.29 61.86,30.29 61.5,30.66 59.39,30.66 58.06,29.33 56.29,29.33 55.98,29.64 54.36,29.64 53.54,28.82 53.54,22.27 52.88,21.61 52.13,21.61 51.87,21.87 51.87,22.3 51.18,22.99 51.18,23.34 v1(51,23.53)
  BOTTOM w0.14: v1(51,23.53) 51.13,23.39 51.13,23.26 50.99,23.12 50.47,23.12 C883.2
SATA_TXP0_CN: length 16.6
  BOTTOM w0.14: CN20.19 26.65,18.14 26.77,18.26 26.77,18.8 27.55,19.59 36.82,19.59 38.4,21.16 38.93,21.16 39.94,22.17 40.42,22.17 C889.1
SATA_TXP_IN: length 2.4
  BOTTOM w0.14: U43.1 47.96,22.76 48.08,22.64 48.28,22.64 48.56,22.92 49.11,22.92 C883.1
SATA_TXP_OUT: length 2.7
  BOTTOM w0.14: C889.2 41.8,22.02 41.96,22.02 42.11,22.16 42.11,22.32 42.43,22.64 42.94,22.64 43.06,22.76 U43.15
SENSEA: length 44.1
  TOP w0.203: v1(14.62,20.11) 14.62,18.15 13.73,17.25 13.17,17.25 13.06,17.36 12.51,17.36 12.21,17.05 12.21,15.04 11.7,14.53 R594.2 ; U17.48 35.48,29.16 35.68,29.36 v1(35.68,29.38)
  IN4 w0.203: v1(35.68,29.38) 35.86,29.2 37.2,29.2 37.99,28.41 37.99,27.73 38.22,27.5 38.22,26.76 35.27,23.82 31.11,23.82 28.64,21.35 24.05,21.35 23.69,21 18.36,21 16.99,22.37 15.49,22.37 14.45,21.33 14.45,20.29 v1(14.62,20.11)
  BOTTOM w0.203: R911.1 35.7,29.4 v1(35.68,29.38)
SENSEA_EC: length 3.7
  TOP w0.14: R587.1 9.35,13.53 v1(10.4,12.48) 11.06,11.81 Q54.3
SENSEB: length 2.2
  TOP w0.203: R373.1 36.36,29.4 35.89,29.87 35.46,29.87 35.15,29.56 U17.49
SERIRQ: length 190.6
  TOP w0.14: U14.AW35 220.88,27.05 v1(220.9,27.07) ; U18.5 70.46,31.82 70.62,31.99 70.62,33.94 70.3,34.26 69.35,34.26 68.71,34.9 68.71,35.64 68.57,35.78 68.57,36.34 68.8,36.56 68.8,37.78 v1(68.65,37.92)
  IN3 w0.089: v1(220.9,27.07) 220.48,27.07 219.99,27.56 219.62,27.56 219.23,27.17 219.23,26.37 216.72,23.87 216.31,23.46 214.61,23.46 214.4,23.67 213.2,23.67 212.8,23.27 211.83,23.27 211.49,23.61 210.76,23.61 210.64,23.5 209,23.5 207.05,21.55 204.52,21.55 203.21,22.86 198.01,22.86 197.75,23.13 197.75,23.63 197.22,24.15 197.22,29.55 195.43,31.35 194.54,31.35 192.83,33.06 191.82,33.06 191.12,33.76 191.12,34.01 187.92,37.21 178.25,37.21 176.96,35.91 98.82,35.91 98.67,35.77 96.73,35.77 96.16,36.33 94.49,36.33 94.07,35.91 93.46,35.91 92.18,37.19 90.28,37.19 89.66,37.81 87.94,37.81 87.66,37.53 85.55,37.53 85.06,38.02 83.98,38.02 81.8,35.84 80,35.84 78.77,37.07 76.12,37.07 76.05,37.14 72.54,37.14 71.83,37.85 70.69,37.85 70.46,38.08 68.81,38.08 v1(68.65,37.92)
  BOTTOM w0.102: 225.7,23.11 225.3,23.11 224.54,23.87 224.03,23.87 223.57,24.32 222.71,24.32 222.18,24.85 221.78,24.85 221.32,25.31 221.32,25.58 220.62,26.28 220.62,26.78 v1(220.9,27.07)
  BOTTOM w0.14: 225.7,23.11 225.98,23.11 226.41,22.67 226.41,21.17 226.69,20.89 R1047.2
SIO_EXT_SCI#: length 182.8
  TOP w0.14: v1(211.55,30.65) 210.81,30.65 210.51,30.96 U14.AL15 ; v1(72.15,23.99) 71.53,24.62 U18.23
  IN3 w0.089: v1(211.55,30.65) 211.21,30.31 211.21,29.62 210.59,29 208.11,29 207.87,29.24 206.5,29.24 206.08,29.65 205.28,29.65 204.67,29.05 204.67,27.85 203.56,26.74 202.54,26.74 201.71,27.56 200.96,27.56 199.5,29.03 199.5,31.31 197.72,33.09 197.72,33.92 194.92,36.71 193.34,36.71 190.35,39.7 178.48,39.7 176.29,37.51 100.19,37.51 99.86,37.85 94.5,37.85 94.35,38 94.1,38 93.31,38.79 91.99,38.79 91.83,38.63 90.57,38.63 90.17,39.02 87.41,39.02 87.17,38.79 86.49,38.79 85.34,39.95 82.28,39.95 80.52,38.18 79.54,38.18 79.43,38.29 78.53,38.29 77.75,39.07 75.18,39.07 v1(74.69,39.56)
  BOTTOM w0.14: v1(74.69,39.56) 75.68,38.57 77.82,38.57 79.01,37.38 79.01,36.18 77.78,34.95 76.04,34.95 74.99,33.9 71.1,33.9 70.27,33.07 70.27,25.35 71.26,24.36 71.76,24.36 72.13,23.99 v1(72.15,23.99) ; v1(211.55,30.65) 211.89,30.31 R907.2
SIO_RCIN#: length 185.5
  TOP w0.102: U14.BE39 222.16,23.86 222.49,23.54 222.49,21.96 v1(222.63,21.81) 222.63,20.66 R474.2
  TOP w0.14: v1(68.33,36.75) 68.29,36.72 68.29,35.66 68.43,35.52 68.43,34.79 69.23,33.99 70.18,33.99 70.34,33.82 70.34,32.36 70.2,32.22 U18.4
  IN3 w0.089: v1(68.33,36.75) 68.36,36.75 69.07,37.47 71.02,37.47 72.59,35.9 75.32,35.9 75.53,35.7 79.34,35.7 79.76,35.27 82.33,35.27 83.12,36.06 85.2,36.06 85.7,36.55 87.94,36.55 89.39,35.1 92.04,35.1 92.87,34.27 95.82,34.27 96.19,33.9 96.89,33.9 97.21,34.21 97.21,34.58 97.64,35.01 98.99,35.01 99.13,35.15 111.45,35.15 112.14,34.46 165.72,34.46 166.21,34.95 177.08,34.95 178.5,36.37 185.99,36.37 187.35,35.02 189.03,35.02 190.35,33.7 190.35,33.25 191.53,32.07 191.78,32.07 192.53,31.33 192.53,31.01 191.2,29.69 191.2,27.26 193.9,24.57 195.72,24.57 196.72,23.57 196.72,22.2 198.15,20.77 207.35,20.77 208.24,21.67 208.72,21.67 209.35,21.04 210.06,21.04 210.24,21.23 212.74,21.23 212.97,21 213.89,21 214.95,22.06 216.15,22.06 217.45,23.37 218.39,23.37 219.16,22.59 219.16,22.04 219.78,21.43 220.41,21.43 220.69,21.71 222.53,21.71 v1(222.63,21.81)
SKTOCC_N: length 5.9
  TOP w0.089: 162.4,129.56 161.07,128.23 159.92,128.23 U3.BR33
  TOP w0.14: 162.4,129.56 164.15,129.56 R53.2
SKTOCC_N_R: length 161.8
  TOP w0.14: v1(222.73,29.3) 222.95,29.53 U14.AP41 ; v1(170.92,129.9) 169.03,129.9 168.5,129.38 165.91,129.38 R53.1
  IN2 w0.089: v1(222.73,29.3) 222.6,29.18 220.41,29.18 220.19,29.4 220.19,31.58 219.12,32.65 219.12,33.5 219.45,33.84 219.45,34.36 219.65,34.55 219.65,35.16 219.78,35.29 219.78,37.32 219.34,37.76 219.07,37.76 218.54,38.28 216.38,38.28 213.19,41.47 213.19,44.22 212.12,45.29 212.12,47.47 207.17,52.43 205.32,52.43 201.49,56.26 199.83,56.26 196.83,59.26 195.17,59.26 193.64,60.8 192.41,60.8 191.86,61.34 191.07,61.34 189.96,62.45 188.53,62.45 186.12,64.85 186.12,65.08 180.4,70.8 180.4,83.45 183.63,86.68 183.63,89.07 182.13,90.57 182.13,105.02 181.2,105.95 181.2,111.54 182.32,112.66 182.32,131.35 181.39,132.28 180.68,132.28 179.41,131.02 177.99,131.02 177.09,130.12 174.38,130.12 174.16,129.9 v1(170.92,129.9)
  BOTTOM w0.14: R900.2 232.16,31.33 231.55,31.33 231.12,30.9 231.12,30.77 230.1,29.75 226.85,29.75 226.72,29.88 225.39,29.88 224.68,29.18 223.67,29.18 223.54,29.3 v1(222.73,29.3)
SLP_A#: length 8.6
  TOP w0.14: CN5.6 226.61,13.91 226.59,13.88 226.59,13.4 225.83,12.64 224.65,12.64 223.85,13.44 223.15,13.44 222.66,13.93 222.66,14.53 222.73,14.6 222.73,15.39 v1(222.78,15.45) 223.03,15.7 R540.2
SLP_A#_L: length 8.3
  TOP w0.102: 223.84,20.62 223.06,21.4 223.06,21.91 223.32,22.17 223.32,22.6 223.03,22.89 223.03,23.57 222.96,23.64 222.96,24.17 U14.BE40
  TOP w0.14: R540.1 223.03,17.36 223.33,17.66 223.33,17.92 223.84,18.43 223.84,20.62
SLP_LAN#: length 2.4
  TOP w0.102: U14.BF40 222.52,23.79 222.69,23.62 222.69,22.64 v1(222.89,22.44)
  BOTTOM w0.14: v1(222.89,22.44) 222.91,22.45 TP112.1
SLP_S3#_L: length 4.5
  TOP w0.102: R480.1 225.3,20.72 224.79,21.23 224.58,21.23 224.3,21.5 224.3,22.11 224.13,22.27 224.13,23.13 223.86,23.4 U14.BF42
SLP_S4#_L: length 8.1
  TOP w0.102: 225.78,19.5 225.78,20.53 224.88,21.43 224.71,21.43 224.5,21.63 224.5,22.19 224.33,22.36 224.33,23.22 224.09,23.46 224.09,23.86 223.89,24.05 U14.BE42
  TOP w0.14: R541.1 225.29,17.7 225.43,17.84 225.43,18.62 225.78,18.96 225.78,19.5
SLP_S5#: length 10.3
  TOP w0.14: R479.2 224.3,18.27 v1(224,17.96) 224,17.63 223.51,17.15 223.51,16.08 223.38,15.94 223.38,15.16 223.08,14.86 223.08,14.46 223,14.39 223,14.12 223.34,13.78 224,13.78 224.76,13.02 225.47,13.02 225.77,13.33 225.77,13.83 225.61,13.99 CN5.4
SLP_S5#_L: length 5.6
  TOP w0.102: R479.1 224.06,20.17 224.06,20.85 223.89,21.02 223.89,21.94 223.72,22.11 223.72,22.77 223.44,23.06 223.44,23.77 223.56,23.88 223.56,25.11 U14.BC42
SLP_WLAN_N: length 3.3
  TOP w0.102: U14.BD42 224.14,24.35 224.14,24.09 224.29,23.94 224.29,23.55 224.54,23.3 224.54,22.72 v1(224.74,22.53)
  BOTTOM w0.14: TP113.1 224.24,23.03 v1(224.74,22.53)
SM_INTRUDER#: length 3.2
  TOP w0.14: U14.BB44 225.03,25.79 v1(225.05,25.81)
  BOTTOM w0.14: R967.2 226.83,24.94 225.84,25.93 225.16,25.93 v1(225.05,25.81)
SM_RCOMP_0: length 10
  TOP w0.254: 119.45,105.02 119.61,105.02 120.53,104.11 122.14,104.11 122.51,104.47 122.92,104.89 U3.G1
  TOP w0.381: 119.45,105.02 119.11,105.02 118.64,105.49 115.86,105.49 115.46,105.9 v1(115.45,105.9) 114.52,105.9 R99.1
SM_RCOMP_1: length 11.1
  TOP w0.254: 118.58,103.85 119.36,103.85 120.12,103.09 122.42,103.09 123.73,104.4 124.03,104.7 U3.H1
  TOP w0.381: 118.58,103.85 116.22,103.85 115.69,103.32 v1(115.37,103.32) 115.28,103.42 R105.2
SM_RCOMP_2: length 12.6
  TOP w0.254: U3.J2 124.42,105.45 124.42,104.56 122.4,102.53 119.96,102.53 119.49,103 118.43,103
  TOP w0.381: R109.1 114.56,102.05 v1(115.2,102.05) 115.54,102.05 116.49,103 118.43,103
SMB1ALERT#: length 9.8
  TOP w0.102: U14.BD33 219.73,24.37 219.73,24.2 219.89,24.04 219.89,23.67 219.99,23.57 v1(219.99,23.27)
  BOTTOM w0.102: 220.89,20.77 220.89,20.99 221.07,21.17 221.07,21.67 220.73,22.02 220.73,22.72 220.18,23.27 v1(219.99,23.27)
  BOTTOM w0.14: 220.89,20.77 220.89,19.27 221.34,18.83 222,18.83 222.27,18.56 R1071.1 221.28,17.26 R1103.1
SMB_ME0_CLK: length 7
  TOP w0.102: 214.9,21 215.03,21.13 215.03,22.62 215.17,22.76 215.17,23.47 U14.BF25
  TOP w0.14: 214.9,21 214.9,18.26 214.4,17.76 R537.2
SMB_ME0_DAT: length 8.2
  TOP w0.102: 214.62,20.95 214.62,21.2 214.83,21.41 214.83,22.71 214.97,22.84 214.97,23.6 215.11,23.74 215.11,24.04 U14.BE24
  TOP w0.14: R535.2 214,17.78 214.02,17.78 214.62,18.38 214.62,20.95
SMB_ME1_CLK: length 26.5
  TOP w0.102: U14.BF27 216.65,23.76 216.65,22.96 216.68,22.92 216.68,21.99 217.05,21.62 217.05,21.08 216.9,20.94 216.9,20.63 217.42,20.1
  TOP w0.14: v1(211.5,11.8) 211.98,11.32 R1157.1 ; 217.42,20.1 217.42,18.71 v1(216.62,17.91) 215.85,17.14 215.85,15.67 215.47,15.28 215.47,15.03 215.24,14.8 215.24,13.57 214.47,12.8 R606.2 214.47,12.37 214.97,11.87 216.13,11.87 216.38,11.62 216.38,10.5 v1(216.99,9.9) 216.86,9.77 215.97,9.77 215.66,10.08 Q55.1
  IN4 w0.086: v1(216.99,9.9) 214.72,9.9 212.82,11.8 v1(211.5,11.8)
SMB_ME1_DAT: length 19.7
  TOP w0.102: U14.BE27 216.36,24.09 216.36,23.52 216.44,23.44 216.44,22.87 216.47,22.84 216.47,21.91 216.84,21.54 216.84,21.17 216.7,21.02 216.7,20.51 217.14,20.07
  TOP w0.14: 217.14,20.07 217.14,18.99 216.84,18.68 216.69,18.68 215.36,17.35 215.36,15.87 214.97,15.49 214.97,15.23 214.75,15.01 214.49,15.01 214.14,14.66 v1(214.14,13.7) 214.14,13.42 R603.2 214.01,11.93 214.01,11.6 213.79,11.38 Q55.4 212.97,11.38 212.59,11.75 212.29,11.75 211.73,12.31 211.25,12.31 210.97,12.03 R1156.1
SMB_ME2_CLK: length 4.6
  TOP w0.14: U14.AE48 226.58,33.9 228.66,33.9 229.65,34.88 230.09,34.88 230.49,34.48 R303.2
SMB_ME2_DAT: length 4.8
  TOP w0.102: 230.04,35.52 229.24,35.52 228.91,35.19 228.31,35.19 228.16,35.04 227.07,35.04 226.79,34.76 226.46,34.76 U14.AD47
  TOP w0.14: R288.2 230.55,35.52 230.04,35.52
SMB_ME3_CLK: length 4
  TOP w0.14: v1(228.97,32.63) 228.5,33.11 227.04,33.11 227,33.06 226.43,33.06 226.19,33.31 U14.AF47
  BOTTOM w0.14: R891.2 228.79,32.81 v1(228.97,32.63)
SMB_ME3_DAT: length 7.4
  TOP w0.102: U14.AD48 226.82,34.5 227.15,34.84 228.28,34.84 228.43,34.98 229.04,34.98 229.25,35.19 230.1,35.19 230.33,34.95 230.51,34.95
  TOP w0.14: R289.2 232.89,34.95 230.51,34.95
SMB_ME4_CLK: length 12.9
  TOP w0.14: U14.AE43 224.01,33.53 v1(224.12,33.42)
  BOTTOM w0.14: v1(224.12,33.42) 224.47,33.76 226.12,33.76 226.56,34.21 226.56,34.53 226.9,34.88 226.9,35.69 227.45,36.24 228.03,36.24 228.25,36.46 229.89,36.46 230.33,36.01 231.49,36.01 231.72,36.24 232.26,36.24 R863.1 232.64,36.83 R849.2
SMB_ME4_DAT: length 5.7
  TOP w0.102: U14.AJ46 225.64,32.37 226.44,32.37 226.64,32.17 227.89,32.17 v1(228.32,32.61)
  BOTTOM w0.14: R879.2 228.32,33.7 v1(228.32,32.61)
SMB_PCH_CLK: length 95.1
  TOP w0.102: U14.BE26 216.16,24.37 216.16,23.44 216.24,23.36 216.24,22.79 216.27,22.76 216.27,22.12 216.05,21.9 216.05,21.47 215.92,21.34 v1(215.92,21)
  TOP w0.14: R478.2 216.34,19.93 215.92,20.36 v1(215.92,21)
  IN2 w0.089: v1(183.32,64.23) 183.32,64.21 187.96,59.57 189.24,59.57 189.9,58.91 190.9,58.91 191.44,58.37 191.76,58.37 195.04,55.08 195.61,55.08 196.48,54.22 196.48,53.03 196.57,52.94 197.08,52.94 197.17,52.85 197.17,52.58 197.08,52.49 196.57,52.49 196.48,52.41 196.48,52.14 196.57,52.05 197.08,52.05 197.17,51.96 197.17,51.69 197.08,51.61 196.57,51.61 196.48,51.52 196.48,51.25 196.57,51.16 196.91,51.16 197.01,51.06 197.01,50.81 196.92,50.72 196.57,50.72 196.48,50.63 196.48,49.9 196.7,49.69 198.06,49.69 198.33,49.96 198.33,52.23 198.57,52.47 199.58,52.47 199.94,52.11 200.28,52.11 200.86,51.53 200.86,50.31 198.85,48.3 198.05,48.3 197.35,47.6 197.35,44.05 197.66,43.73 197.66,42.85 199.04,41.46 199.04,40.23 200.98,38.29 203.35,38.29 204.63,37.01 206.49,37.01 206.62,36.88 206.91,36.88 207.23,36.57 207.52,36.57 208.63,35.46 209.43,35.46 209.96,34.93 209.96,34.07 210.17,33.86 210.17,32.23 210.51,31.89 210.51,30.81 209.62,29.91 209.62,29.08 210.53,28.17 210.53,26.55 211.05,26.02 211.05,23.94 211.25,23.74 211.7,23.74 211.78,23.65 211.78,22.18 211.91,22.05 212.18,22.05 212.26,22.14 212.26,23.65 212.35,23.74 212.59,23.74 212.71,23.62 212.71,22.14 212.8,22.05 213.06,22.05 213.15,22.14 213.15,23.65 213.24,23.74 213.89,23.74 214.61,23.02 214.61,22.54 214.53,22.45 214.15,22.45 214.06,22.36 214.06,22.1 214.15,22.01 214.53,22.01 214.61,21.92 214.61,21.65 214.53,21.56 214.15,21.56 214.06,21.47 214.06,21.21 214.15,21.12 214.53,21.12 214.61,21.03 214.61,20.58 214.76,20.44 215.8,20.44 215.92,20.56 v1(215.92,21)
  BOTTOM w0.14: v1(183.32,64.23) 182.55,64.23 181.69,65.08 Q66.6
SMB_PCH_DAT: length 78.4
  TOP w0.102: v1(215.65,21.64) 215.65,21.79 216.07,22.21 216.07,22.67 216.04,22.7 216.04,23.28 215.93,23.38 U14.BF26
  TOP w0.14: R477.2 215.49,20.11 215.49,21.49 v1(215.65,21.64)
  IN2 w0.089: v1(179.83,67.24) 181.17,67.24 184.02,64.39 184.02,64.13 188.14,60.01 189.42,60.01 190.08,59.35 191.09,59.35 191.63,58.81 191.94,58.81 195.23,55.53 195.8,55.53 196.94,54.38 196.94,53.88 197.92,52.91 199.77,52.91 200.12,52.56 200.46,52.56 201.3,51.72 201.3,50.07 199.09,47.86 198.23,47.86 197.79,47.42 197.79,44.23 198.1,43.92 198.1,43.03 199.48,41.65 199.48,40.41 201.16,38.74 203.54,38.74 204.82,37.46 206.67,37.46 206.8,37.33 207.1,37.33 207.41,37.01 207.7,37.01 208.81,35.91 209.62,35.91 210.41,35.12 210.41,34.26 210.62,34.05 210.62,32.42 210.96,32.07 210.96,30.62 210.06,29.73 210.06,29.26 210.98,28.35 210.98,26.73 211.5,26.21 211.5,24.73 212.05,24.18 214.08,24.18 215.06,23.2 215.06,21.83 215.25,21.64 v1(215.65,21.64)
  BOTTOM w0.14: Q66.3 v1(179.83,67.24)
SMBALERT#: length 12.1
  TOP w0.102: U14.BE25 215.66,23.94 215.66,23.36 215.83,23.19 215.83,22.62 215.86,22.59 215.86,22.29 215.63,22.05 215.34,22.05 215.24,21.95 215.24,20.98 215.16,20.9
  TOP w0.14: 215.16,20.9 215.16,17.85 214.86,17.55 214.86,16.08 214.48,15.69 v1(214.48,15.51) 214.3,15.51 213.46,14.67 R574.1 213.33,14.67 R575.2
SMDDR_VREF_CA: length 79.6
  TOP w0.254: v1(158.59,112.52) 158.59,112.59 U3.BN13
  IN3 w0.508: v1(173.83,55.74) 173.83,56.67 172.92,57.58 172.92,58.11 169.97,61.05 169.97,63.82 167.48,66.31 167.48,82.01 166.44,83.05 166.44,93.51 169.06,96.14 169.06,106.22 165.16,110.12 165.16,111.3 164.11,112.36 161.74,112.36 161.24,112.86 160.52,112.86 160.18,112.52 v1(158.59,112.52)
  BOTTOM w0.508: v1(173.83,55.74) 173.83,57.98 175.44,59.59 175.44,61.04 176.74,62.33 C694.1 177.3,61.24 177.69,60.85 R730.1
SMDDR_VREF_DQ0_M3: length 7.8
  TOP w0.114: U3.BP13 159.3,112.53 160.36,112.53 160.51,112.68 161.58,112.68 162.63,111.63 164.07,111.63 164.68,111.02 164.68,110.25 TP9.1
SMDDR_VREF_DQ1_M3: length 78.9
  TOP w0.254: 161.1,113.41 161.01,113.32 159.97,113.32 U3.BR13
  TOP w0.508: v1(175.91,58.98) 175.91,55.05 178.44,52.52 C151.1 179.19,52.52 179.95,51.76 R164.1 ; v1(162.78,113.41) 161.1,113.41
  IN1 w0.508: v1(162.78,113.41) 163.59,113.41 164.35,114.17 166.63,114.17 169.55,111.26 171.01,111.26 171.93,110.34 171.93,109.2 173.43,107.69 173.43,105.97 175.79,103.62 175.79,95.78 176.96,94.61 176.96,90.55 176.46,90.04 176.46,78.7 177.12,78.03 177.12,76.47 176.46,75.8 176.46,65.63 176.98,65.11 176.98,60.4 175.91,59.33 v1(175.91,58.98)
SML0ALERT#: length 11
  TOP w0.102: U14.BF24 214.76,23.79 214.76,22.93 214.63,22.79 214.63,21.56 214.14,21.08 R476.2
  TOP w0.14: R476.2 213.71,19.5 213.71,18.17 213.24,17.69 213.01,17.69 212.85,17.53 212.85,16.37 212.43,15.96 212.43,15.49 211.55,14.6 R577.2
SML2ALERT#: length 8.7
  TOP w0.102: U14.AB47 226.31,35.92 226.73,35.92 226.95,35.71 227.88,35.71 228.2,36.02 228.28,36.02 229.3,37.05 230.47,37.05
  TOP w0.14: R270.1 233.01,37.15 232.28,37.15 231.9,37.53 R271.1 230.95,37.05 230.47,37.05
SNN_FBA_RFU_G5: length 2.6
  TOP w0.102: VRAM6.G5 94.27,123.68 v2(93.89,124.06)
  BOTTOM w0.14: v2(93.89,124.06) 93.33,123.49 92.2,123.49 TPG46.1
SNN_FBA_RFU_G5_1: length 1.4
  TOP w0.102: VRAM8.G5 90.52,103.93 90.23,104.22 v2(90.14,104.31)
  BOTTOM w0.14: v2(90.14,104.31) 90.14,104.45 TPG64.1
SNN_FBA_RFU_M5: length 1.4
  TOP w0.102: VRAM6.M5 90.59,123.68 v2(90.89,123.38)
  BOTTOM w0.14: v2(90.89,123.38) 90.93,123.41 90.93,124.22 TPG45.1
SNN_FBA_RFU_M5_1: length 1.7
  TOP w0.102: v2(94.29,104.65) 94.27,104.63 VRAM8.M5
  BOTTOM w0.14: v2(94.29,104.65) 94.29,105.33 TPG62.1
SNN_FBA_TCK0: length 1.4
  TOP w0.102: VRAM6.N5 89.77,123.31 v2(89.67,123.21)
  BOTTOM w0.14: TPG47.1 90.09,122.79 v2(89.67,123.21)
SNN_FBA_TCK1: length 1.6
  TOP w0.102: VRAM8.N5 v2(94.64,103.56)
  BOTTOM w0.14: v2(94.64,103.56) 94.64,104.05 TPG65.1
SNN_FBA_TDI0: length 1.3
  TOP w0.102: v2(95.33,120.35) 95.02,120.04 VRAM6.F10
  BOTTOM w0.14: TPG51.1 94.84,120.84 v2(95.33,120.35)
SNN_FBA_TDI1: length 1.3
  TOP w0.102: VRAM8.F10 89.75,107.68 v2(89.4,107.34)
  BOTTOM w0.14: v2(89.4,107.34) 89.4,106.83 TPG60.1
SNN_FBA_TDO0: length 1.5
  TOP w0.102: v2(89.35,120.49) 89.35,120.36 VRAM6.N10
  BOTTOM w0.14: v2(89.35,120.49) 89.35,121.17 TPG50.1
SNN_FBA_TDO1: length 1.3
  TOP w0.102: VRAM8.N10 v2(95.39,107.31)
  BOTTOM w0.14: v2(95.39,107.31) 95.39,106.55 TPG61.1
SNN_FBA_TMS0: length 1.6
  TOP w0.102: v2(94.77,123.05) 95.02,123.3 VRAM6.F5
  BOTTOM w0.14: TPG49.1 94.77,122.72 v2(94.77,123.05)
SNN_FBA_TMS1: length 1.3
  TOP w0.102: v2(89.34,104.29) 89.39,104.29 89.75,103.93 VRAM8.F5
  BOTTOM w0.14: TPG63.1 89.34,104.83 v2(89.34,104.29)
SNN_FBB_RFU_G5: length 1.7
  TOP w0.102: VRAM3.G5 60.67,150.41 v2(61.22,149.86)
  BOTTOM w0.14: TPG20.1 61.71,149.86 v2(61.22,149.86)
SNN_FBB_RFU_G5_1: length 1.3
  TOP w0.102: v2(80,146.28) VRAM4.G5
  BOTTOM w0.14: TPG23.1 80,147.05 v2(80,146.28)
SNN_FBB_RFU_M5: length 1.5
  TOP w0.102: VRAM3.M5 61.14,146.66 v2(61.29,146.81)
  BOTTOM w0.14: TPG28.1 61.68,146.43 v2(61.29,146.81)
SNN_FBB_RFU_M5_1: length 2.4
  TOP w0.102: VRAM4.M5 79.39,150.41 78.52,149.54 v2(78.52,149.42)
  BOTTOM w0.14: TPG22.1 78.52,149 v2(78.52,149.42)
SNN_FBB_TCK1: length 1.6
  TOP w0.102: VRAM4.N5 79.44,151.16 v2(79.07,151.53)
  BOTTOM w0.14: v2(79.07,151.53) 78.68,151.91 TPG13.1
SNN_FBB_TDI1: length 3
  TOP w0.102: VRAM4.F10 76.23,145.56 v2(76.23,144.78)
  BOTTOM w0.14: v2(76.23,144.78) 76.23,146.18 TPG26.1
SNN_FBB_TDO1: length 1.6
  TOP w0.102: VRAM4.N10 75.88,151.16 v2(76.25,151.53)
  BOTTOM w0.14: TPG17.1 76.25,151.48 v2(76.25,151.53)
SNN_FBB_TMS1: length 1.3
  TOP w0.102: VRAM4.F5 79.63,145.9 v2(79.26,145.53)
  BOTTOM w0.14: TPG29.1 79.26,146 v2(79.26,145.53)
SNN_FBC_RFU_G5: length 2.5
  TOP w0.102: v2(29.58,150.03) VRAM1.G5
  BOTTOM w0.14: TPG19.1 31.08,150.34 30.4,150.34 30.1,150.03 v2(29.58,150.03)
SNN_FBC_RFU_G5_1: length 1.2
  TOP w0.102: v2(48.68,146.3) 48.68,146.32 VRAM2.G5
  BOTTOM w0.14: TPG24.1 48.19,146.78 v2(48.68,146.3)
SNN_FBC_RFU_M5: length 1.7
  TOP w0.102: VRAM1.M5 30.53,146.66 v2(30.62,146.75)
  BOTTOM w0.14: TPG25.1 31.53,146.75 v2(30.62,146.75)
SNN_FBC_RFU_M5_1: length 1.6
  TOP w0.102: v2(48.29,150.43) 48.99,150.43 VRAM2.M5
  BOTTOM w0.14: TPG18.1 48.26,150.47 v2(48.29,150.43)
SNN_FBC_TCK0: length 1.5
  TOP w0.102: VRAM1.N5 29.99,145.91 30.36,145.54 v2(30.36,145.54)
  BOTTOM w0.14: TPG27.1 30.36,146.06 30.36,145.54 v2(30.36,145.54)
SNN_FBC_TCK1: length 1.4
  TOP w0.102: v2(49.39,150.78) 49.01,151.16 VRAM2.N5
  BOTTOM w0.14: TPG15.1 48.85,151.32 v2(49.39,150.78)
SNN_FBC_TDI0: length 1.5
  TOP w0.102: v2(33.09,151.27) 33.2,151.16 VRAM1.F10
  BOTTOM w0.14: TPG16.1 32.84,151.02 v2(33.09,151.27)
SNN_FBC_TDI1: length 1.3
  TOP w0.102: v2(45.62,145.49) 45.62,145.53 45.26,145.88 VRAM2.F10
  BOTTOM w0.14: v2(45.62,145.49) 45.62,145.95 TPG30.1
SNN_FBC_TDO0: length 1.8
  TOP w0.102: v2(33.11,145.44) 33.58,145.91 VRAM1.N10
  BOTTOM w0.14: v2(33.11,145.44) 33.11,144.9 TPG34.1
SNN_FBC_TDO1: length 1.3
  TOP w0.305: VRAM2.N10 45.46,151.35 v2(45.75,151.35)
  BOTTOM w0.14: TPG14.1 46.29,151.35 v2(45.75,151.35)
SNN_FBC_TMS0: length 1.8
  TOP w0.102: VRAM1.F5 30.16,151.16 v2(30.68,151.68)
  BOTTOM w0.14: TPG12.1 31.05,151.68 v2(30.68,151.68)
SNN_FBC_TMS1: length 1.4
  TOP w0.102: v2(48.64,145.53) 48.64,145.54 VRAM2.F5
  BOTTOM w0.14: v2(48.64,145.53) 48.12,145 TPG32.1
SNN_FBD_RFU_G5: length 1.7
  TOP w0.102: v2(15.76,111.66) 15.38,112.03 VRAM7.G5
  BOTTOM w0.14: TPG58.1 16.51,112.41 v2(15.76,111.66)
SNN_FBD_RFU_G5_1: length 1.6
  TOP w0.102: v2(19.45,129.97) 19.45,129.97 19.13,130.29 VRAM5.G5
  BOTTOM w0.14: TPG40.1 19.66,129.76 19.46,129.97 v2(19.45,129.97)
SNN_FBD_RFU_M5: length 1.7
  TOP w0.102: v2(18.76,111.66) 19.13,112.03 VRAM7.M5
  BOTTOM w0.14: TPG57.1 18.76,112.11 v2(18.76,111.66)
SNN_FBD_RFU_M5_1: length 1.4
  TOP w0.102: VRAM5.M5 15.49,130.23 v1(15.49,129.74)
  BOTTOM w0.14: TPG35.1 15.71,129.91 15.54,129.74 v1(15.49,129.74)
SNN_FBD_TCK0: length 1.4
  TOP w0.102: VRAM7.N5 19.88,112.3 20.07,112.49 v2(20.14,112.49)
  BOTTOM w0.14: v2(20.14,112.49) 20.54,112.89 TPG56.1
SNN_FBD_TCK1: length 1.9
  TOP w0.102: v1(14.88,129.52) 14.74,129.52 14.63,129.62 VRAM5.N5
  BOTTOM w0.14: v1(14.88,129.52) 15.49,128.9 TPG41.1
SNN_FBD_TDI0: length 1.3
  TOP w0.102: v2(14.52,115.24) 14.63,115.36 VRAM7.F10
  BOTTOM w0.14: TPG53.1 14.84,114.93 v2(14.52,115.24)
SNN_FBD_TDI1: length 1.3
  TOP w0.102: v2(20.26,126.93) 19.91,126.58 VRAM5.F10
  BOTTOM w0.225: TPG43.1 20.26,127.66 v2(20.26,126.93)
SNN_FBD_TDO0: length 1.6
  TOP w0.102: v2(20.31,115.13) 20.31,115.36 VRAM7.N10
  BOTTOM w0.14: v2(20.31,115.13) 20.31,114.79 TPG54.1
SNN_FBD_TDO1: length 1.3
  TOP w0.102: v2(14.26,126.95) VRAM5.N10
  BOTTOM w0.14: TPG44.1 14.42,127.12 v2(14.26,126.95)
SNN_FBD_TMS0: length 2.1
  TOP w0.102: VRAM7.F5 14.63,112.33 v2(14.1,112.86)
  BOTTOM w0.14: TPG55.1 13.91,113.05 v2(14.1,112.86)
SNN_FBD_TMS1: length 1.8
  TOP w0.102: VRAM5.F5 19.88,130.29 20.2,129.97 v2(20.31,129.97)
  BOTTOM w0.14: TPG38.1 20.31,129.72 v2(20.31,129.97)
SPDIF_OUT: length 63.6
  TOP w0.14: R344.2 36.63,32.07 36.24,32.07 35.84,31.67 v1(35.84,31.27)
  IN3 w0.089: v1(35.84,31.27) 37.05,31.27 38.48,29.84 39.27,29.84 40.19,28.91 41.32,28.91 41.99,28.24 42.85,28.24 43.21,27.88 44.21,27.88 44.95,27.14 44.95,24.46 42.99,22.5 40.2,22.5 37.01,19.31 20.75,19.31 18.41,16.97 17.35,16.97 15.42,15.04 14.58,15.04 12.18,12.64 10.5,12.64 9.76,13.38 9.76,15.64 9.84,15.72 9.84,18.4 v1(9.7,18.54)
  BOTTOM w0.14: v1(9.7,18.54) 10.16,19 CN17.11
SPI1_IO2: length 24.3
  TOP w0.102: 228.87,27.17 228.58,27.17 228.12,26.71 227.64,26.71 227.51,26.84 226.91,26.84 226.79,26.72 U14.AY48
  TOP w0.14: R455.2 240.16,20.81 R456.1 240.92,20.33 v1(240.76,20.17) ; v1(234.87,29.35) 234.45,29.77 233.23,29.77 R377.1 232.55,29.59 230.89,29.59 R378.2 229.94,28.64 229.94,28.23 228.87,27.17
  IN1 w0.086: v1(234.87,29.35) 236.09,28.13 236.09,26.79 236.52,26.35 236.77,26.35 237,26.12 237,24.3 238.77,22.54 239.58,22.54 239.78,22.34 239.78,21.84 240.81,20.81 240.81,20.22 v1(240.76,20.17)
SPI1_IO3: length 19.5
  TOP w0.102: U14.BA46 226.14,26.46 226.82,26.46 227,26.64 227.43,26.64 227.56,26.51 228.2,26.51 228.53,26.84 228.72,26.84
  TOP w0.14: 228.72,26.84 229.13,26.84 R385.1 230.94,27.71 231.53,27.71 232.15,28.33 R382.1 233.35,28.87 234.38,28.87 v1(234.94,28.31) ; R320.2 239.71,34.2 v1(239.19,34.2)
  IN3 w0.089: v1(234.94,28.31) 238.75,32.12 238.75,33.6 239.19,34.03 v1(239.19,34.2)
SPI_CS0#_UR_ME: length 187.3
  TOP w0.14: v1(236.52,19.62) 236.52,19.72 237.09,20.29 237.25,20.29 R453.1 ; v1(81.74,33.31) 81.74,33.82 81.83,33.91 U18.101
  IN3 w0.089: v1(236.52,19.62) 236.52,19.9 236.82,20.2 236.82,20.87 237.1,21.15 238.09,21.15 238.6,21.66 238.6,22.96 238.45,23.11 238.03,23.11 237.94,23.02 237.94,21.89 237.8,21.75 237.39,21.75 237.27,21.87 237.27,22.93 237.09,23.11 236.85,23.11 236.61,22.88 236.61,21.82 236.35,21.56 232.19,21.56 231.48,22.27 229.66,22.27 227.87,20.49 225.65,20.49 224.91,19.75 219.96,19.75 219.35,19.15 216.43,19.15 216.19,18.91 204.91,18.91 204.51,19.3 200.68,19.3 200.11,18.73 200.11,18.29 199.61,17.79 198.09,17.79 197.58,18.3 197.58,18.71 195.17,21.12 193.37,21.12 192.38,22.11 191.41,22.11 190.61,22.91 190.61,23.99 189.81,24.79 189.81,25.94 188.75,27 187.85,27 187.29,27.56 185.65,27.56 185.36,27.85 185.36,28.46 186.59,29.68 186.59,32.67 184.54,34.71 181.3,34.71 179.47,32.88 166.5,32.88 166.41,32.8 111.45,32.8 110.76,33.49 99.87,33.49 98.74,32.36 97.73,32.36 97.37,32 95.67,32 95.33,31.66 91.47,31.66 91.35,31.78 87.02,31.78 86.64,32.15 85.5,32.15 84.64,33.01 82.04,33.01 v1(81.74,33.31)
SPI_TPM_CS#: length 10.5
  IN1 w0.086: v1(236.92,28.62) 236.92,27.7 237.09,27.54 237.09,26.83 237.39,26.52 237.39,24.47 238.93,22.93 239.74,22.93 240.31,22.36 v1(240.31,21.96)
  BOTTOM w0.14: R921.1 236.46,29.08 v1(236.92,28.62) ; v1(240.31,21.96) 240.59,21.69 R1017.1
SPI_TPM_CS#_L: length 15.8
  TOP w0.14: U14.AT40 222.5,28.64 v1(222.5,28.11)
  BOTTOM w0.14: R921.2 235.59,29.32 235.04,29.86 234.64,29.86 234.56,29.79 232.6,29.79 232.31,29.49 231.51,29.49 231.2,29.18 231.2,28.68 230.95,28.43 229.45,28.43 228.93,27.91 227.07,27.91 v1(226.42,28.55) 223.88,28.55 223.44,28.11 v1(222.5,28.11)
SRTC_RST#: length 38.3
  TOP w0.14: v1(225.73,25.38) 225.87,25.24 225.87,24.52 U14.BD46 ; R618.2 201.21,12.47 201.21,13.32 201.05,13.48 C476.1 201.05,15.25 v1(200.79,15.51) 200.55,15.76 Q41.3
  IN2 w0.089: v1(225.73,25.38) 225.94,25.17 225.94,24.58 225.5,24.13 225.2,24.13 224.94,23.87 221.53,23.87 220.88,23.23 220.88,21 219.62,19.74 216.64,19.74 216.02,19.12 211.91,19.12 211.44,18.64 211.44,17.38 209.08,15.02 205.11,15.02 204.86,15.28 201.03,15.28 v1(200.79,15.51)
STRAP0: length 9.8
  TOP w0.102: UG1.BL3 v2(38.01,93.51)
  TOP w0.14: RG159.1 30.88,91.86 31.66,91.86 RG158.2 33.12,92.31 v1(33.48,92.31)
  IN1 w0.086: v2(38.01,93.51) 38.01,93.43 37.57,92.99 37.57,92.66 37.37,92.46 36.99,92.46 36.84,92.61 34.21,92.61 33.91,92.31 v1(33.48,92.31)
STRAP1: length 14.7
  TOP w0.102: UG1.BL4 39.05,93.82 v2(38.74,93.51)
  TOP w0.14: v1(27.83,90.34) 27.84,90.33 RG153.1 28.6,90.34 RG154.2
  IN1 w0.089: v2(38.74,93.51) 38.36,93.13 38.04,93.13 37.78,92.88 37.78,92.6 37.45,92.27 36.83,92.27 36.7,92.39 36.14,92.39 34.85,91.11 33.84,91.11 33.49,90.76 29.53,90.76 29.1,90.34 v1(27.83,90.34)
STRAP2: length 26.6
  TOP w0.102: UG1.BM4 38.27,92.37 37.16,92.37 36.65,92.88 36.04,92.88
  TOP w0.14: v1(32.86,91.43) 32.86,91.44 33.27,91.85 34.51,91.85 35.54,92.88 36.04,92.88
  BOTTOM w0.14: v1(32.86,91.43) 32.28,90.85 32.28,90.47 31.64,89.83 27.58,89.83 27.07,89.32 17.62,89.32 17.37,89.07 16.42,89.07 RG174.2 16.8,89.88 RG173.1
STRAP3: length 31.6
  TOP w0.102: UG1.BM5 39.48,93.15 38.5,92.17 37.08,92.17 36.75,92.5 35.55,92.5 35.45,92.4
  TOP w0.14: v1(33.51,91.41) 33.65,91.55 34.6,91.55 35.45,92.4
  BOTTOM w0.14: v1(33.51,91.41) 33.51,91.3 31.76,89.55 27.69,89.55 27.18,89.04 17.95,89.04 17.67,88.76 15.01,88.76 14.87,88.9 14.87,89.85 15.34,90.31 15.34,90.73 15.63,91.02 RG172.2 16.29,91.49 16.71,91.49 16.71,91.49 17.47,91.49 RG171.1
STRAP4: length 20.9
  TOP w0.102: UG1.BK5 39.75,94.52 v2(39.44,94.21)
  IN1 w0.086: v2(39.44,94.21) 39.08,94.56 38.54,94.56 38.45,94.66 37.38,94.66 36.77,94.05 36.1,94.05
  IN1 w0.089: 36.1,94.05 35.97,94.17 32.63,94.17 31.65,93.2 27.45,93.2 26.87,93.78 26.11,93.78 v1(25.77,93.44)
  BOTTOM w0.14: RG162.1 25.54,98.48 RG161.2 25.54,93.68 v1(25.77,93.44)
STRAP5: length 19.9
  TOP w0.102: UG1.BJ5 v2(39.43,94.93)
  TOP w0.14: v1(24.5,97.43) 24.5,98.14 24.8,98.44 RG146.2 24.58,98.95 RG145.1
  IN2 w0.089: v2(39.43,94.93) 39.06,94.56 38.5,94.56 38.11,94.95 35.69,94.95 35.42,94.67 31.5,94.67 29.38,96.8 26,96.8 25.67,97.13 24.8,97.13 v1(24.5,97.43)
STRP1: length 1.9
  TOP w0.14: R119.1 10.91,70.68 U4.6
STRP2: length 1.9
  TOP w0.14: R120.1 11.31,70.64 U4.7
SURR_L_SPK: length 7.2
  TOP w0.203: v1(26.49,28.34) 26.51,28.36 U17.25
  TOP w0.381: C385.2 22.65,25.21 v1(23.29,24.58)
  IN2 w0.381: v1(23.29,24.58) 23.29,24.95 26.49,28.15 v1(26.49,28.34)
SURR_R_SPK: length 7.9
  TOP w0.203: v1(25.81,28.37) 25.86,28.37 26.28,28.79 26.83,28.79 26.87,28.76 U17.24
  TOP w0.381: v1(21.99,24.63) 22.38,24.24 C399.2
  IN2 w0.381: v1(25.81,28.37) 22.07,24.63 v1(21.99,24.63)
SUSACK#: length 16
  TOP w0.102: R486.1 221.65,19.07 221.35,19.37 221.35,20.65 220.97,21.03 220.97,22.3 220.81,22.46 220.81,23.62 220.76,23.67 220.76,24.17 U14.BE35
  TOP w0.14: R486.1 221.82,18.82 221.86,18.77 221.86,18.06 221.1,17.29 220.9,17.29 220.74,17.12 220.74,13.84 220.23,13.33 219.96,13.33 219.12,12.49 v1(218.08,12.49) 217.85,12.26 R617.1
SUSB#: length 173.6
  TOP w0.14: U18.119 74.63,34.07 74.78,33.92 75.43,33.92 77.06,32.3 77.06,30.64 76.69,30.27 v1(76.69,30.21) ; R480.2 225.29,19.15 225.01,18.87 v1(225.01,18.46) 225.01,17.91 224.84,17.73 224.84,15.49 224.61,15.27 CN5.2
  IN3 w0.089: v1(76.69,30.21) 77.25,29.66 77.25,29.05 78.14,28.16 82.74,28.16 84.25,26.65 84.52,26.65 85.5,25.67 87.86,25.67 88.93,26.74 89.46,26.74 v1(89.66,26.54)
  IN4 w0.086: v1(89.66,26.54) 89.77,26.54 89.95,26.73 91.95,26.73 92.88,25.8 94.07,25.8 94.31,26.04 97.88,26.04 98.15,26.31 99.17,26.31 99.28,26.2 110.67,26.2 112.46,27.99 135.34,27.99 135.37,27.96 147.88,27.96 148.44,27.4 163.25,27.4 164.57,28.72 172.71,28.72 173.09,29.1 177.16,29.1 177.83,29.76 179.55,29.76 181.58,27.73 186.1,27.73 189.84,23.98 189.84,22.74 190.82,21.77 192.26,21.77 193.36,20.68 195.48,20.68 196.19,19.96 196.19,18.29 197.6,16.88 203.83,16.88 204.24,17.29 219.39,17.29 219.98,17.87 220.94,17.87 221.38,18.3 221.38,18.71 222.04,19.38 223.63,19.38 224.01,19 224.47,19 v1(225.01,18.46)
SUSC#: length 186.7
  TOP w0.14: CN5.5 226.11,15.36 226,15.47 v1(226,15.71) 225.98,15.74 225.98,15.84 225.46,16.36 R541.2 ; v1(74.78,26.76) 73.31,25.3 70.98,25.3 70.69,25.58 70.69,26.19 70.27,26.62 U18.18
  IN3 w0.089: v1(81.63,25.01) 81.39,25.25 80.34,25.25 79.86,24.77 77.56,24.77 76.84,25.48 76.84,26.55 76.34,27.05 75.07,27.05 v1(74.78,26.76)
  IN4 w0.086: v1(226,15.71) 227.86,17.57 227.86,18.58 227.44,19 225.7,19 225.44,18.74 225.44,18.2 225.17,17.93 224.66,17.93 223.51,19.09 222.16,19.09 221.67,18.59 221.67,18.18 221.06,17.58 220.1,17.58 219.51,17 204.36,17 203.95,16.59 197.48,16.59 195.9,18.17 195.9,19.84 195.36,20.39 190.87,20.39 189.55,21.71 189.55,23.86 185.98,27.44 181.46,27.44 179.43,29.47 177.95,29.47 177.28,28.81 173.21,28.81 172.83,28.43 164.69,28.43 163.37,27.11 149.94,27.11 147.28,24.45 140.05,24.45 138.66,25.83 134.24,25.83 132.38,27.7 123.55,27.7 122.97,27.12 112,27.12 110.79,25.91 99.16,25.91 99.05,26.02 98.27,26.02 97.93,25.68 96.22,25.68 94.66,24.12 92.15,24.12 90.93,25.34 90.64,25.34 89.84,26.14 89.51,26.14 89.44,26.08 88.8,26.08 88.43,25.71 86.07,25.71 85.07,24.71 85.07,23.86 84.49,23.28 82.59,23.28 82.1,23.77 82.1,24.54 v1(81.63,25.01)
SUSCLK: length 212.9
  IN3 w0.089: v1(51.12,44.33) 50.52,44.93 50.52,47.75 50.87,48.1 52.8,48.1 54.62,46.28 54.62,43.01 54.84,42.79 54.84,41.92 54.54,41.63 54.54,40.58 54.2,40.25 54.2,38.93 54.74,38.39 63.93,38.39 64.54,37.79 66.67,37.79 67.02,37.44 68.77,37.44 69,37.66 71.1,37.66 72.67,36.1 75.4,36.1 75.61,35.89 79.42,35.89 79.84,35.46 82.25,35.46 83.72,36.93 84.67,36.93 84.89,37.15 85.12,37.15 85.32,36.95 87.81,36.95 88.87,35.89 89.97,35.89 90.52,36.44 92.09,36.44 93.24,35.29 94.26,35.29 94.73,35.76 95.93,35.76 96.49,35.2 98.91,35.2 99.06,35.34 177.19,35.34 178.42,36.57 186.07,36.57 187.42,35.21 189.11,35.21 190.54,33.77 190.54,33.33 191.59,32.29 191.84,32.29 192.47,31.66 192.98,31.66 193.83,30.81 193.83,30.52 193.28,29.98 191.76,29.98 191.4,29.61 191.4,27.34 193.97,24.76 195.8,24.76 196.94,23.62 196.94,22.47 197.76,21.66 199,21.66 199.02,21.68 200.42,21.68 201.11,20.98 207.29,20.98 208.16,21.86 208.8,21.86 209.43,21.23 209.98,21.23 210.76,22.01 211.02,22.01 211.7,22.7 213.04,22.7 213.44,23.1 214.16,23.1 214.37,22.88 216.7,22.88 217.71,23.89 220.19,23.89 220.54,23.54 224.73,23.54 225.25,23.02 v1(227.5,23.02)
  BOTTOM w0.14: v1(227.5,23.02) 227.1,23.42 R983.2 ; CN16.50 50.63,45 51.12,44.52 v1(51.12,44.33)
SUSCLK32: length 5.8
  TOP w0.14: v1(225.45,24.8) 225.37,24.71 U14.BE45
  BOTTOM w0.14: v1(225.45,24.8) 225.6,24.8 v1(226.25,24.15) 226.54,24.15 226.71,24.32 227.4,24.32 R983.1 228.05,23.67 228.05,22.82 227.86,22.63 227.86,21.78 R1011.1
SUSD: length 297.6
  TOP w0.14: v1(183.35,58.02) 183.72,58.02 184.55,58.84 PR178.2 185.17,58.44 PC168.1 185.17,56.92 184.8,56.56 PQ21.3 185.12,56.16 186.14,57.18 v1(186.14,57.55) 186.48,57.89 PQ20.2 ; PQ56.2 12.45,36.28 9.52,39.21 9.52,40.78 v1(9.65,40.91)
  IN2 w0.089: v1(9.56,55.97) 9.56,55.21 10.65,54.12 10.65,50.6 10.16,50.11 10.16,44.5 10.28,44.38 10.28,41.54 v1(9.65,40.91) ; v1(23.87,93.29) 24,93.29 26.59,90.7 26.59,90.01 27.55,89.05 32.7,89.05 32.98,88.77 37.21,88.77 39.76,86.21 47.47,86.21 48.48,85.21 48.48,84.83 50.36,82.95 53.2,82.95 55.95,80.2 82.87,80.2 88.57,85.9 93.22,85.9 95.13,83.98 95.13,82.84 95.6,82.37 v1(95.6,79.62)
  IN3 w0.089: v1(95.6,79.62) 96.03,80.05 96.03,87.56 100.85,92.38 103.35,92.38 103.87,91.87 103.87,90.29 104.6,89.55 104.6,87.57 104.37,87.34 104.37,84.38 104.69,84.07 105.46,84.07 105.93,83.59 105.93,80.47 105.11,79.66 105.11,74.68 105.43,74.36 v1(105.63,74.36) ; v1(183.35,58.02) 183.35,58.7 184.19,59.54 184.19,61.38 182.32,63.25 182.32,64.43 181.56,65.19 179.98,65.19 175.83,69.34 175.83,77.38 v1(176.05,77.6)
  IN4 w0.086: v1(9.56,55.97) 9.87,55.97 11.03,57.13 11.03,59.94 13.07,61.97 13.07,70.58 14.26,71.77 14.26,76.91 13.91,77.26 13.91,83.61 14.37,84.07 14.37,84.7 18.95,89.28 18.95,92.41 19.82,93.28 22.46,93.28 22.97,93.79 23.37,93.79 v1(23.87,93.29)
  BOTTOM w0.14: v1(176.05,77.6) 175.13,76.68 167.51,76.68 163.96,73.12 113.18,73.12 112.34,72.28 109.66,72.28 107.97,73.98 106.02,73.98 v1(105.63,74.36)
SUSON: length 270.1
  TOP w0.14: PR163.1 v1(92.28,69.69) ; v1(212.03,55.44) 212.03,54.8 211.12,53.89 203.09,53.89 202.1,54.88 199.96,54.88 199.35,55.5 199.35,56 198.61,56.73 192.36,56.73 191.89,57.2 190.52,57.2 189.99,57.74 189.25,57.74 188.15,56.64 187,56.64 186.5,56.14 186.5,55.84 185.18,54.53 185.18,53.61 185.11,53.53 185.11,52.94 184.22,52.05 184.22,51.73 183.95,51.46 PQ23.2 182.99,51.46 182.03,50.51 182.03,47.24 182.14,47.13 182.14,46 181.59,45.45 181.59,43.33 180.81,42.56 180.81,38.72 176.08,33.99 167.98,33.99 164.85,30.86 160.68,30.86 159.86,30.04 156.99,30.04 156.36,29.41 PR365.1 156.03,29.18 v1(155.7,28.85) ; v1(75.52,25.96) 75.3,26.17 75.3,27.54 75.79,28.02 75.79,30.01 76.71,30.94 76.71,32.16 75.29,33.58 74.4,33.58 74.23,33.75 U18.120 74.23,35.98 74.45,36.2 74.45,37.98 74.23,38.2 73.41,38.2 73.03,38.58 72.75,38.58 72.54,38.8 72.54,39.49 R231.1 71.95,40.6 v1(72.12,40.77)
  IN2 w0.089: v1(58.85,50.13) 57.35,51.62 57.35,52.79 58.2,53.63 63.14,53.63 64,54.49 65.04,54.49 65.31,54.76 69.51,54.76 70.47,53.8 71.74,53.8 72.84,54.9 78.93,54.9 79.05,55.02 89.68,55.02 90.35,55.68 90.35,58.42 90.93,59.01 90.93,60.69 91.29,61.05 91.29,63.43 92.69,64.83 92.69,69.28 v1(92.28,69.69) ; v1(75.52,25.96) 75.78,25.96 76.09,25.65 79.55,25.65 80.03,26.12 80.03,26.52 80.94,27.44 84.1,27.44 85.52,26.02 86.88,26.02 87.19,26.33 v1(87.19,26.56)
  IN3 w0.089: v1(72.12,40.77) 72.12,41.14 71.54,41.71 65.95,41.71 61.6,46.07 58.74,46.07 57.6,47.21 57.6,49.09 58.59,50.08 58.8,50.08 v1(58.85,50.13)
  IN4 w0.086: v1(155.7,28.85) 155.11,28.26 148.8,28.26 148.18,28.89 112.13,28.89 110.31,27.07 102.2,27.07 101.07,28.2 98,28.2 97.26,27.46 97.26,26.87 97.01,26.62 95.57,26.62 95.04,27.15 93.66,27.15 93.58,27.06 92.63,27.06 92.11,27.59 88.9,27.59 87.88,26.56 v1(87.19,26.56)
  BOTTOM w0.14: v1(212.03,55.44) 212.03,55.35 v1(213.07,54.31) 213.43,53.95 220.15,53.95 220.54,54.35 221.71,54.35 222.3,54.93 PR495.1
SUSWARN#: length 15.9
  TOP w0.102: U14.BC37 221.4,24.85 221.36,24.82 221.36,24.72 221.26,24.62 221.26,24.02 221.23,23.99 221.23,23.61 221.01,23.39 221.01,22.55 221.18,22.39 221.18,21.11 221.69,20.6 221.69,19.98 R486.2 222.02,19.85 222.27,19.6
  TOP w0.14: 222.27,19.6 222.27,18.75 222.21,18.69 222.21,18.01 221.51,17.31 221.51,17.08 v1(221.23,16.8) 221.01,16.59 221.01,13.72 220.34,13.05 220.07,13.05 219.28,12.25 219.28,12.05 R615.1
SW1_4PH_A: length 14.9
  TOP w0.203: PR98.1 165.45,152.29 166.08,151.65 168.55,151.65 169.71,152.81 v1(169.71,159.14) PR73.1 169.74,160.78 PR68.1
SW2_4PH_A: length 33.7
  TOP w0.203: PR96.1 154.65,152.23 v1(155.27,151.61) ; PR31.1 PR30.1 v1(166.36,169.33)
  IN2 w0.203: v1(166.36,169.33) 157.45,169.33 155.19,167.07 155.19,163.64 157.63,161.2 157.63,153.08 156.16,151.61 v1(155.27,151.61)
SW3_4PH_A: length 46.4
  TOP w0.203: v1(143.76,151.98) 143.41,152.33 143.41,152.83 143.4,152.84 PR99.1 ; PR24.1 167.04,170.87 167.07,170.9 PR18.1 167.07,171.88 v1(166.9,172.05)
  IN2 w0.203: v1(143.76,151.98) 145.36,151.98 146.07,152.7 146.07,165.83 145.46,166.44 145.46,169.43 149.42,173.4 165.55,173.4 v1(166.9,172.05)
SW4_4PH_A: length 55.7
  TOP w0.203: PR97.1 132.3,152.39 132.51,152.19 v1(132.68,152.19) ; v1(168.67,172.06) 168.67,171.6 PR19.1 PR20.2
  IN2 w0.203: v1(168.67,172.06) 166.96,173.78 149.12,173.78 141.12,165.78 136.54,165.78 135.78,165.01 135.78,153.08 134.89,152.19 v1(132.68,152.19)
SW_1PH: length 64.2
  TOP w0.203: PR94.1 v1(122.9,152.92) ; v1(170.57,174.24) 170.65,174.31 PR9.2
  IN2 w0.203: v1(170.57,174.24) 170.52,174.29 148.86,174.29 141.7,167.12 136.37,167.12 134.18,164.94 128.16,164.94 125.49,162.27 125.49,152.95 124.86,152.31 123.07,152.31 122.9,152.48 v1(122.9,152.92)
SYS_HWPG: length 93.9
  TOP w0.14: U18.124 72.63,34.32 73.72,33.24 75.15,33.24 76.37,32.02 76.37,31.08 75.44,30.16 75.44,29.08 v1(73.3,26.93) ; D37.1 56.41,36.11 55.54,35.24 v1(55.54,34.94) ; v1(112.74,26.08) 112.74,26.28 113.15,26.69 115.91,26.69 116.17,26.43 116.17,25.27 PR397.2
  IN3 w0.089: v1(55.54,34.94) 55.54,32.92 56.27,32.19 59.55,32.19 60.45,31.29 61.81,31.29 62.36,30.73 62.73,30.73 63.49,31.49 65.67,31.49 65.79,31.36 66.4,31.36 66.5,31.47 67.18,31.47 67.66,31.94 69.21,31.94 70.07,31.08 70.07,30.42 73.3,27.2 v1(73.3,26.93) 73.3,25.59 74.14,24.75 74.14,23.71 74.39,23.46 75.87,23.46 76.92,22.41 77.55,22.41 78.54,23.4 82.15,23.4 82.75,22.8 83.05,22.8 83.61,22.24 84.21,22.24 84.32,22.13 87.03,22.13 87.59,21.58 87.59,21.12 88.31,20.39 90.96,20.39 91.6,21.04 94.28,21.04 95.88,19.44 99.18,19.44 99.83,20.09 99.83,21.84 100.46,22.47 100.46,24.23 102.69,26.46 112.36,26.46 v1(112.74,26.08)
SYS_PWROK: length 5.3
  BOTTOM w0.14: R1068.1 230.52,18.93 R1037.2 230.7,19.97 R1023.1 229.78,20.76 R1019.1 230.47,21.84 U42.4
SYS_PWROK_R: length 60.7
  TOP w0.102: v1(201.73,28.61) 202.32,29.2 203.53,29.2 204.04,28.69 204.1,28.69 U14.AU3
  IN4 w0.086: v1(201.73,28.61) 202.2,29.08 203.17,29.08 203.54,28.71 203.54,28.35 203.21,28.02 202.53,28.02 202.15,27.63 201.65,27.63 201.59,27.58 201.06,27.58 200.01,26.53 200.01,25.84 199.09,24.92 198.32,24.92 197.84,24.44 197.84,23.18 198.1,22.92 199.14,22.92 200.64,21.42 201.43,21.42 201.8,21.05 207.29,21.05 209.73,23.49 214.12,23.49 214.63,22.98 214.63,21.25 215.83,20.05 218.82,20.05 219.19,20.43 224.07,20.43 224.45,20.05 232.48,20.05 232.63,20.21 233.19,20.21 v1(233.62,19.78)
  BOTTOM w0.14: R1037.1 231.76,20.26 232.83,20.26 R1024.1 233.45,20.73 233.62,20.57 v1(233.62,19.78) 233.86,19.78 234,19.92 234.92,19.92 R1032.2
SYS_SHDN#: length 284.3
  TOP w0.14: v1(114.7,34.89) 114.7,31.39 115.9,30.19 119.25,30.19 120.69,28.74 v1(120.69,27.53) 120.49,27.33 PR381.2 ; PR103.2 172.35,152.66 v1(172.66,152.66) ; v1(113.09,134.82) 110.4,132.13 Q5.3 ; PR403.2 v1(124.58,24.04) ; v1(82.37,28.97) 82.37,29.34 83.02,30 83.67,30 84.12,29.55 84.12,29.23 84.32,29.02 U18.85 ; PU28.6 118.5,24.06 117.85,24.7 117.85,25.46 117.71,25.6 v1(117.68,25.6)
  IN1 w0.086: v1(113.09,134.82) 113.09,133.36 114.57,131.88 114.57,106.91 112.82,105.17 112.41,105.17 111,103.76 111,103.08 110.39,102.48 110.39,85.53 106.69,81.83 106.69,78.2 105.12,76.63 105.12,73.33 106.53,71.92 106.53,64.21 105.52,63.2 103.96,63.2 v1(103.83,63.33) ; v1(82.37,28.97) 82.36,28.97 82.36,28.77 83.11,28.02 83.86,28.02 86.11,25.77 88.32,25.77 89.49,26.94 90.97,26.94 92.26,25.66 92.26,22.67 92.53,22.39 92.53,21.6 94.56,19.57 100.34,19.57 101.36,20.59 101.36,21.62 105.68,25.94 111.53,25.94 112.15,25.33 116.76,25.33 117.03,25.6 v1(117.68,25.6) 118.02,25.6 118.29,25.33 118.74,25.33 120.69,27.28 v1(120.69,27.53)
  IN2 w0.089: v1(172.66,152.66) 172.66,152.53 173.48,151.71 173.48,148.95 172.23,147.71 172.23,145.9 168.94,142.61 168.94,138.09 166.93,136.08 161.05,136.08 160.64,136.49 159.1,136.49 157.59,138.01 141.41,138.01 140.93,138.49 139.56,138.49 138.88,139.17 133.71,139.17 133.1,138.55 126.53,138.55 123.5,135.53 114.71,135.53 114.01,134.82 v1(113.09,134.82) ; v1(117.68,25.6) 117.76,25.6 117.85,25.51 117.85,24.97 118.45,24.38 124.25,24.38 v1(124.58,24.04)
  IN4 w0.086: v1(103.83,63.33) 103.83,62.25 103.75,62.17 103.75,58.71 104.04,58.43 104.04,57.44 104.46,57.02 104.46,56.48 103.86,55.88 102.87,55.88 102.21,55.22 102.21,50.99 100.57,49.35 100.57,44.04 99.81,43.27 99.81,40.89 v1(98.51,39.6)
  BOTTOM w0.14: v1(98.51,39.6) 99.1,39.6 100.72,37.98 100.72,37.52 102.18,36.06 113.57,36.06 114.7,34.93 v1(114.7,34.89)
SYSTEM_AGND: length 15.1
  TOP w0.14: v1(124.17,26.47) 123.85,26.16 PR391.2 124.07,25.48 PR398.2 ; v1(118.53,25.89) 118.11,25.89 117.68,26.33 117.24,26.33 117.03,26.54 117.03,28.02 116.82,28.22 116.64,28.22 PR369.1 117.01,28.58 117.49,28.1 PR378.2 PR379.2
  IN2 w0.089: v1(124.17,26.47) 123.92,26.71 119.27,26.71 118.53,25.98 v1(118.53,25.89)
TBT1_PCIE_RBIAS: length 1.3
  TOP w0.14: U7.N16 v2(262.05,48.81)
  BOTTOM w0.14: R804.1 261.51,48.27 v2(262.05,48.81)
TBT2_DP_HPD: length 6.1
  TOP w0.089: v2(259.46,53.37) U7.Y6
  BOTTOM w0.14: v2(259.46,53.37) 259.46,53.08 v1(259.14,52.76) 258.92,52.54 257.79,52.54 257.39,52.14 256.75,52.14 256.65,52.23 255.54,52.23 255.03,51.72 R784.1
TBT_BATLOW#: length 5.5
  TOP w0.089: 265.33,57.9 265.33,56.81 265.58,56.57 265.58,56.33 265.57,56.32 265.57,55.99 265.58,55.99 265.58,55.92 U7.F2
  TOP w0.14: 265.33,57.9 265.33,58.61 265.18,58.76 265.18,58.93 v1(264.91,59.2)
  BOTTOM w0.14: R738.2 264.69,58.98 v1(264.91,59.2) 264.91,58.88 265.06,58.73 R736.1
TBT_CIO_PLUG_EVENT#: length 6.6
  TOP w0.089: U7.W2 259.58,55.93 259.58,56.49 258.55,57.52 258.55,57.72 258.73,57.9
  TOP w0.14: D18.1 256.92,59.22 256.95,59.19 R134.1 R135.1 258.41,59.19 258.64,58.96 R129.2 258.96,58.14 v1(258.8,57.98) 258.73,57.9
TBT_DP_HPD: length 360.5
  TOP w0.089: 258.67,56.29 258.67,55.92 U7.AA2 ; 256.56,56.73 v1(256.69,56.73)
  TOP w0.102: 258.67,56.29 258.67,56.34 258.5,56.52 257.54,56.52 257.32,56.73 v1(256.69,56.73)
  TOP w0.14: v1(16.22,92.6) 16.71,93.08 16.71,94 CG66.1 17.04,93.72 17.04,93.39 RG32.2 ; 256.56,56.73 256.28,56.73 255.42,55.87 254.99,55.87 R147.1
  IN1 w0.086: v1(16.22,92.6) 16.57,92.25 16.57,91.51 16.95,91.14 16.95,90.07 17.56,89.46 17.56,86.62 14.54,83.6 14.54,81.32 14.59,81.27 14.59,78.24 14.97,77.86 14.97,68.41 14.77,68.21 14.77,66.21 15.86,65.13 15.86,61.12 17.95,59.02 19.22,59.02 21.18,57.06 22.55,57.06 23.77,55.85 26.36,55.85 27.68,54.52 28.72,54.52 29.05,54.19 29.05,53.31 29.22,53.13 29.22,48.83 30.08,47.97 31.32,47.97 31.99,47.29 31.99,46.92 32.38,46.53 v1(32.38,46.42)
  IN2 w0.089: v1(256.69,56.73) 256.65,56.7 254.59,56.7 253.99,56.09 253.15,56.09 251.62,54.56 250.9,54.56 250.16,53.82 250.01,53.82 249.28,53.1 249.28,52.05 248.67,51.43 248.46,51.43 248.26,51.24 248.26,48.12 v1(248.82,47.55) 247.43,46.16 247.43,44.67 244.96,42.2 244.96,40.82 242.58,38.44 238.29,38.44 238.04,38.19 238.04,37.58 238.18,37.44 238.18,35.64 237.74,35.2 237.74,34.5 237.43,34.19 236.64,34.19 236.3,33.85 236.3,32.27 236.61,31.97 236.61,30.8 237.55,29.86 237.55,27.92 237.77,27.7 237.77,25.28 237.22,24.73 237.22,21.73 236.68,21.18 235.28,21.18 235.17,21.07 224.12,21.07 223.27,20.23 221.38,20.23 220.22,19.07 217.26,19.07 215.39,17.2 215.39,13.96 214.93,13.49 214.6,13.49 213.83,14.26 211.29,14.26 210.79,13.76 205.96,13.76 204.73,14.98 200.76,14.98 199.61,16.13 v1(199.61,18.43)
  IN3 w0.089: v1(32.38,46.42) 32.38,45.25 34.65,42.98 34.65,41.36 36.67,39.33 38.21,39.33 38.82,38.72 41.54,38.72 41.66,38.84 43.96,38.84 44.85,39.73 47.22,39.73 47.47,39.98 48.31,39.98 50.22,38.07 53.66,38.07 54.33,37.4 59.01,37.4 60.21,36.21 61.49,36.21 61.85,35.85 63.26,35.85 64.02,36.61 66.18,36.61 67.37,35.41 67.95,35.41 68,35.36 68.69,35.36 69.01,35.05 71.5,35.05 72.03,34.52 74.73,34.52 74.93,34.33 78.77,34.33 79.35,33.74 82.74,33.74 83.69,34.69 85.77,34.69 86.27,35.18 87.37,35.18 88.83,33.72 89.97,33.72 90.79,32.9 95.17,32.9 95.77,32.3 97.26,32.3 97.61,32.65 98.62,32.65 99.75,33.78 110.88,33.78 111.57,33.09 166.29,33.09 166.47,33.27 179.44,33.27 181.18,35 184.67,35 189.3,30.37 189.3,27.22 192.19,24.34 192.19,22.71 193.49,21.41 195.29,21.41 198.06,18.64 199.4,18.64 v1(199.61,18.43)
  BOTTOM w0.14: v1(248.82,47.55) 248.3,47.03 R807.2 ; R1004.1 199.3,22.21 198.82,21.73 198.39,21.73 198.14,21.48 198.14,19.46 198.83,18.77 199.27,18.77 v1(199.61,18.43)
TBT_DPSNK0_DDC_CLK: length 3.5
  TOP w0.089: v2(258.85,54.66) 258.85,54.64 U7.Y5
  BOTTOM w0.14: R762.1 257.2,54.4 257.71,54.4 R763.1 258.6,54.91 v2(258.85,54.66)
TBT_DPSNK0_DDC_DATA: length 5.2
  TOP w0.089: U7.R4 v2(261.43,55.3)
  BOTTOM w0.14: v2(261.43,55.3) 261.05,55.68 R752.1 260.83,55.84 260.59,56.08 260.59,57.23 260.24,57.58 259.81,57.58 R741.1
TBT_DPSNK1_DDC_CLK: length 4.7
  TOP w0.089: v2(258.87,53.37) 258.87,53.31 U7.Y8
  BOTTOM w0.14: v2(258.87,53.37) 258.68,53.18 258.6,53.1 R772.1 257.95,53.1 257.27,52.42 256.86,52.42 256.53,52.75 255.3,52.75 R777.1
TBT_DPSNK1_DDC_DATA: length 5.8
  TOP w0.089: U7.N4 262.11,55.27 v2(262.06,55.27)
  BOTTOM w0.14: R740.1 259.72,58.24 260.1,57.86 260.35,57.86 261.13,57.08 261.93,57.08 262.09,56.92 262.09,56.39 R751.1 262.61,55.82 v2(262.06,55.27)
TBT_DPSRC_HPD: length 3.2
  TOP w0.089: U7.G1 265.34,56.55 265.15,56.74 265.15,56.95 264.46,57.63 264.46,57.9
  TOP w0.14: 264.46,57.9 264.46,58.76 R127.1
TBT_EE_CLK: length 18.5
  TOP w0.089: 256.41,54.8 256.46,54.8 256.61,54.65 257.7,54.65 257.8,54.55 258.21,54.55 U7.AB4
  TOP w0.14: v1(250.67,42.71) 250.67,43.01 250.84,43.19 U9.6 ; 256.41,54.8 255.97,54.8 255.59,54.42 255.42,54.42 254.79,53.8 R154.2 254.79,53.42 254.47,53.09 254.37,53.09 v1(254.02,52.74)
  IN2 w0.089: v1(250.67,42.71) 250.72,42.76 250.72,44.09 252.57,45.94 252.57,51.29 v1(254.02,52.74)
TBT_EE_CS_N: length 12.4
  TOP w0.089: v1(256.89,55.72) 256.89,55.52 257.22,55.19 257.93,55.19 U7.AC3
  TOP w0.14: 253.38,51.62 253.38,52.59 v1(253.17,52.81)
  IN2 w0.089: v1(253.17,52.81) 252.75,53.23 252.75,54.46 253.15,54.86 253.99,54.86 254.58,55.44 256.61,55.44 v1(256.89,55.72)
  BOTTOM w0.14: v1(253.17,52.81) 252.64,53.34 252.25,53.34 252.05,53.14 R775.1 251.65,53.56 251.69,53.6 R768.2
TBT_EE_DI: length 20.9
  TOP w0.089: U7.AB3 258.21,55.01 256.89,55.01 256.51,55.39 256.41,55.39
  TOP w0.14: 256.41,55.39 255.26,55.39 255.06,55.19 253.65,55.19 253.61,55.14 253.27,55.14 R153.2 252.56,54.08 v1(252.29,53.81) ; v1(249.98,42.69) 249.57,43.09 U9.5
  IN2 w0.089: v1(249.98,42.69) 249.98,44.09 251.99,46.09 251.99,53.18 252.29,53.48 v1(252.29,53.81)
