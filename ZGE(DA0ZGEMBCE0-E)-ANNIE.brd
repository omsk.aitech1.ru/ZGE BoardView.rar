# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Nets (continued)
VMD_DQ6: UG1.AK9 VRAM7.E3
VMD_DQ7: UG1.AK7 VRAM7.E2
VMD_DQ8: UG1.AG4 VRAM7.B12
VMD_DQ9: UG1.AF9 VRAM7.F13
VMD_DQ10: UG1.AG6 VRAM7.E12
VMD_DQ11: UG1.AG7 VRAM7.G13
VMD_DQ12: UG1.AJ4 VRAM7.B13
VMD_DQ13: UG1.AJ5 VRAM7.B11
VMD_DQ14: UG1.AJ6 VRAM7.A12
VMD_DQ15: UG1.AG5 VRAM7.E13
VMD_DQ16: UG1.Y6 VRAM7.N13
VMD_DQ17: UG1.Y5 VRAM7.P12
VMD_DQ18: UG1.V5 VRAM7.M13
VMD_DQ19: UG1.Y4 VRAM7.P13
VMD_DQ20: UG1.AA6 VRAM7.U13
VMD_DQ21: UG1.AA5 VRAM7.V12
VMD_DQ22: UG1.AC5 VRAM7.U12
VMD_DQ23: UG1.AC4 VRAM7.U11
VMD_DQ24: UG1.AD7 VRAM7.M2
VMD_DQ25: UG1.AC6 VRAM7.P3
VMD_DQ26: UG1.AF6 VRAM7.U3
VMD_DQ27: UG1.AD6 VRAM7.P2
VMD_DQ28: UG1.AF7 VRAM7.V3
VMD_DQ29: UG1.AF8 VRAM7.N2
VMD_DQ30: UG1.AF2 VRAM7.U4
VMD_DQ31: UG1.AF3 VRAM7.U2
VMD_DQ32: UG1.F4 VRAM5.B3
VMD_DQ33: UG1.E1 VRAM5.A3
VMD_DQ34: UG1.F3 VRAM5.E3
VMD_DQ35: UG1.F5 VRAM5.B4
VMD_DQ36: UG1.D2 VRAM5.F2
VMD_DQ37: UG1.D1 VRAM5.B2
VMD_DQ38: UG1.C3 VRAM5.G2
VMD_DQ39: UG1.C2 VRAM5.E2
VMD_DQ40: UG1.J5 VRAM5.B13
VMD_DQ41: UG1.J4 VRAM5.A12
VMD_DQ42: UG1.L8 VRAM5.B12
VMD_DQ43: UG1.J2 VRAM5.B11
VMD_DQ44: UG1.F1 VRAM5.E13
VMD_DQ45: UG1.F2 VRAM5.G13
VMD_DQ46: UG1.H4 VRAM5.E12
VMD_DQ47: UG1.H5 VRAM5.F13
VMD_DQ48: UG1.V7 VRAM5.V12
VMD_DQ49: UG1.V8 VRAM5.U11
VMD_DQ50: UG1.V6 VRAM5.U13
VMD_DQ51: UG1.V9 VRAM5.N13
VMD_DQ52: UG1.U4 VRAM5.U12
VMD_DQ53: UG1.R5 VRAM5.P13
VMD_DQ54: UG1.R6 VRAM5.M13
VMD_DQ55: UG1.U8 VRAM5.P12
VMD_DQ56: UG1.P6 VRAM5.U4
VMD_DQ57: UG1.R9 VRAM5.P3
VMD_DQ58: UG1.P4 VRAM5.U3
VMD_DQ59: UG1.P5 VRAM5.V3
VMD_DQ60: UG1.L7 VRAM5.U2
VMD_DQ61: UG1.L6 VRAM5.N2
VMD_DQ62: UG1.L4 VRAM5.P2
VMD_DQ63: UG1.L5 VRAM5.M2
VMD_WCK01: UG1.AJ8 VRAM7.D4
VMD_WCK01#: UG1.AJ7 VRAM7.D5
VMD_WCK23: UG1.AD8 VRAM7.R11
VMD_WCK23#: UG1.AD9 VRAM7.R10
VMD_WCK45: UG1.J6 VRAM5.D4
VMD_WCK45#: UG1.J7 VRAM5.D5
VMD_WCK67: UG1.P8 VRAM5.R11
VMD_WCK67#: UG1.P7 VRAM5.R10
VMD_WCKB01: UG1.AG8 VRAM7.D11
VMD_WCKB01#: UG1.AG9 VRAM7.D10
VMD_WCKB23: UG1.AC7 VRAM7.R4
VMD_WCKB23#: UG1.AC8 VRAM7.R5
VMD_WCKB45: UG1.H7 VRAM5.D11
VMD_WCKB45#: UG1.H6 VRAM5.D10
VMD_WCKB67: UG1.M7 VRAM5.R4
VMD_WCKB67#: UG1.M8 VRAM5.R5
VR_SVID_ALERT#: C48.1 PR17.2 PR435.2 R35.2 R36.1
VR_SVID_CLK: PR13.1 PR431.2 R38.2 R39.2
VR_SVID_CLK_R: R38.1 U3.BH32
VR_SVID_DATA: PR14.2 PR434.2 R41.2
VRON: PR438.2 R429.1 U18.69
VSN_1PH: PC12.2 PR15.2 PU2.51
VSN_4PH_A: PC14.2 PR23.2 PU2.2
VSP_1PH: PC11.2 PR437.2 PU2.52
VSP_4PH_A: PC15.2 PR129.2 PU2.1
VSTBY_FSPI: R221.2 R235.2 R236.2
WIGIG_LED: CN16.6 TP91.1
WLAN_CLKREQ#: CN16.53 Q28.1(S) R220.1
WLAN_RST#: CN16.52 R200.1
WLAN_WAKE_R#: CN16.55 Q26.1(S) R204.1
WLANPWR#: R300.2 U18.83
WOOFER_SPK: C864.2 U17.20
WP#_3: RG48.2 UG2.3(W\P\)
WRST#: C282.1 D44.2 Q30.6 R287.1 U18.14(WRST#)
XCLK_RBIAS: R218.2 U14.T3
XDP_BPM0: TP7.1 U3.BR27
XDP_BPM1: TP8.1 U3.BT27
XDP_BPM2: TP4.1 U3.BM31
XDP_BPM3: TP5.1 U3.BT30
XDP_DBRESET#: CN5.13 R935.1 U14.AU2
XTAL24_IN: L32.3 R820.2 U14.U10
XTAL24_IN_L: C771.2 L32.4 R814.1 R820.1 Y5.1
XTAL24_OUT: L32.2 R821.2 U14.U9
XTAL24_OUT_L: C778.2 L32.1 R814.2 R821.1 Y5.3
XTALOUT_RC: CG77.1 RG41.2 RG44.1
XTALOUTBUFF: RG167.2 UG1.BK6(XTAL_OUTBUFF)
XTALSSIN: RG37.1 UG1.BJ6
N16787949: C866.2 R939.1
N16788300: C334.1 U18.12
N16788450: R326.1 U18.3
N16788484: C426.1 R450.2 U18.66
N16788554: C344.2 R374.2 U18.82
N16788625: C253.1 R227.1 U18.98
N17045084: R297.1 U18.2
N17045098: C275.1 R284.2 U18.128
N17086720: RG177.2 RG182.2 UG7.4
N17086723: CG893.2 RG181.1 UG7.5(VCC)
N17327231: Q5.2 R55.1
N17914278: PC6.1 PC12.1 PR15.1 PR119.2
N17914320: PC6.2 PC11.1 PR121.2 PR437.1
N17914416: PR71.2 PR75.1 PU2.24
N17914428: PC68.2 PR454.1 PR458.1 PU2.16
N17914498: PC299.2 PR443.2 PU2.3
N17914678: PR25.1 PU2.39
N17914704: PC295.1 PR431.1 PR433.1 PR434.1 PR435.1
N17915153: PC4.2 PC9.1 PR9.1 PR432.1 PU2.47
N17915219: PC298.2 PR440.2 PU2.46
N17915331: PC67.2 PR457.1 PU2.15
N17915365: PR452.2 PU2.22
N17915469: PR114.1 PR432.2
N17915487: PR72.2 PR77.1 PR78.2
N17915542: PC296.2 PR441.2 PU2.49
N17915544: PC7.1 PR10.2
N17915546: PC5.2 PC7.2 PU2.50
N17915609: PR436.1 PU2.45
N17915654: PC297.2 PR438.1 PU2.43
N17915810: PC8.2 PR430.2 PU2.48
N17915949: PC18.1 PR29.2
N17916003: PC22.2 PR33.2
N17916033: PC14.1 PC15.1 PR23.1 PR128.2
N17916345: PR40.2 PR49.2 PR117.1
N17988049: C694.2 R727.2
N17989426: C151.2 R151.1
N18332322: TP118.1 U14.BE33
N18828625: PR60.2 PU4.1
N18828828: PR59.2 PU6.1
N18847325: PL7.1 PR98.2 PR465.1 PU4.16(VSW) PU4.24
N18849314: PR42.1 PU4.5
N18849316: PC31.2 PU4.7
N18849320: PC31.1 PR42.2
N18865779: PC63.1 PR37.1 PR47.2 PR52.1 PU4.29
N18869413: PR52.2 PU4.2
N18869846: PC316.1 PR465.2
N18873454: PC41.1 PR50.1 PU6.3
N18873473: PC62.1 PR38.1 PR50.2 PR54.1 PU6.29
N18873491: PR54.2 PU6.2
N18875415: PL6.1 PR96.2 PR463.1 PU6.16(VSW) PU6.24
N18875431: PR81.1 PR112.1
N18875461: PC34.2 PU6.7
N18875463: PC34.1 PR44.2
N18875619: PC315.1 PR463.2
N18875958: PR44.1 PU6.5
N18877550: PC40.1 PR48.1 PU3.3
N18877577: PC60.1 PR36.1 PR48.2 PR53.1 PU3.29
N18877595: PR53.2 PU3.2
N18877670: PL5.1 PR99.2 PR462.1 PU3.16(VSW) PU3.24
N18877682: PR83.1 PR113.1
N18877704: PC32.2 PU3.7
N18877706: PC32.1 PR43.2
N18877832: PC314.1 PR462.2
N18877926: PR43.1 PU3.5
N18877936: PR63.2 PU3.30
N18877948: PR58.2 PU3.1
N18879612: PC42.1 PR51.1 PU5.3
N18879633: PC61.1 PR39.1 PR51.2 PR55.1 PU5.29
N18879659: PR55.2 PU5.2
N18879722: PL4.1 PR97.2 PR460.1 PU5.16(VSW) PU5.24
N18879742: PR82.1 PR110.1
N18879764: PC37.2 PU5.7
N18879766: PC37.1 PR46.2
N18879884: PC313.1 PR460.2
N18879983: PR46.1 PU5.5
N18879988: PR64.2 PU5.30
N18879992: PR57.2 PU5.1
N18886111: PR89.2 PU8.30
N18886117: PL3.1 PR94.2 PR468.1 PU8.16(VSW) PU8.24
N18886141: PR79.1 PR108.1
N18886171: PR106.1 PU8.5
N18886173: PC85.2 PU8.7
N18886175: PC85.1 PR106.2
N18886322: PC82.1 PR100.1 PU8.3
N18886341: PC78.1 PR86.1 PR100.2 PU8.29
N18886385: PR90.2 PU8.1
N18886387: PR93.2 PU8.2
N18886423: PC321.1 PR468.2
N19092935: R543.2 TP122.1
N19453152: C198.2 C205.2 R177.2 U14.D1 U14.E1
N19940934: PC264.2 PR410.2
N19940984: PC277.1 PR422.2
N19941004: PR564.2 PU28.14
N19941046: PR392.2 PR397.1 PR402.1 PU28.7
N19941188: PC291.1 PR423.2
N19941230: PC263.2 PR409.1
N20974305: PC132.1 PR148.2 PU13.4(VIN)
N20974309: PR152.1 PR164.1
N20974323: PR161.1 PR162.2 PR163.2
N20974337: PR151.1 PR152.2 PU13.6
N20974353: PC135.2 PR161.2 PU13.1
N20974362: PR150.2 PU13.5
N21715610: PC429.1 PC430.1 PR561.1 PR565.1 PU31.8 PU31.9
N21715630: PC438.1 PR566.1 PU31.4
N21715632: PC425.1 PU31.12
N21715634: PC426.1 PU31.10
N21715657: PC427.1 PC428.1 PR560.2 PR562.2 PU31.13 PU31.14(VOUT1#2)
N21715675: PC441.1 PR567.1 PU31.5
N21715683: PC437.1 PR569.2 PU31.3
N21716560: PC234.1 PC242.1 PR355.1 PR356.1 PU26.8 PU26.9
N21716580: PC251.1 PR395.1 PU26.4
N21716582: PC252.1 PU26.12
N21716584: PC249.1 PU26.10
N21716605: PC254.1 PC261.1 PR411.2 PR412.2 PU26.13 PU26.14(VOUT1#2)
N21716627: PC245.1 PR371.1 PU26.5
N21716633: PC260.1 PR406.2 PU26.3
N22707794: TP48.1 U14.BC1
N23148426: Q16.2 Q16.3 R101.1
N23148930: Q6.1(S) R55.2 R62.2
N23334321: PC256.1 PR393.2 PU27.4
N23334329: PC266.2 PR414.1
N23334507: PR404.2 PU27.3
N23334555: PC293.1 PR425.2
N23796258: Q8.2 Q8.3 R83.1
N23796391: LED1.2 R85.1
N24995566: PC93.1 PR116.2 PU9.5(VCC)
N24995570: PR101.1 PU9.1
N24995581: PR103.1 PU9.3
N25255287: PR179.1 PU23.20
N25255291: PR180.1 PU23.19
N25255301: PC73.1 PQ4.1 PQ4.2 PQ4.3(S3) PQ5.1 PQ5.2 PQ5.3(S3) PR269.1
N25255306: PC209.1 PL20.2 PQ32.1 PQ32.2 PQ32.3(S3) PR175.1 PR296.1 PR302.2
N25255314: PC72.2 PC73.2 PQ4.4 PQ5.4 PR270.1
N25255394: PC207.1 PR310.2
N25255413: PC183.2 PR243.2
N25255423: PQ4.5 PR67.1 PR70.1
N25255465: PC209.2 PQ32.4 PR303.1
N25255510: PR497.2 PU23.11
N25255512: PR498.2 PU23.12
N25255513: PR254.2 PU23.7
N25255515: PR252.2 PU23.9
N25255534: PR263.2 PU23.5
N25255538: PR183.2 PR184.2 PU23.15
N25255547: PR253.2 PU23.8
N25272043: PC271.1 PR418.2
N25430953: PQ9.3 PR91.2
N25430988: PQ8.3 PR80.2
N25430994: PQ51.3 PR496.2
N25431520: PQ11.3 PR109.2
N25506822: PC278.1 PR421.2
N25506978: PQ19.2 PQ21.2 PQ23.3 PQ57.2 PR195.2 PR217.1
N25507004: PQ19.3 PR172.2
N25507051: PR382.2 PR420.2
N25932926: TP97.1 U14.AL37
N25932929: TP102.1 U14.AN35
N27414743: Q10.2 R88.1 R90.1
N27414752: Q10.3 Q12.2 R96.2
N28089072: PR66.2 PU4.30
N28585230: PR65.2 PU6.30
N28673613: PR76.1 PR111.1
N31399389: C276.1 Q30.2 Q30.3 R290.1
N31399469: R260.1 R286.1 R290.2
N31810763: Q15.2 Q17.3 R106.1
N31810778: Q11.2 Q13.3 R94.1
N32113508: CN15.56 TP72.1
N32113521: CN15.58 TP76.1
N32686297: R401.1 U18.20
N32913947: R432.1 U14.BD1 U14.BE1 U14.BE2
N32915328: R978.1 U14.BE5
N32915331: R990.1 U14.BE4
N33266977: R389.2 R925.2 U18.16
N33344868: R43.2 U3.A37(VSS_A37)
N33344911: TP10.1 U3.BT2
N33344918: TP11.1 U3.BR1
N33344928: R48.2 U3.A36
N33355782: TP104.1 U14.AW48
N33357387: TP107.1 U14.BB24
N33880211: C450.1 R508.1 U14.BE48 U14.BE49
N33880969: C887.2 U14.BG5
N35021669: C256.1 R235.1 U18.106
N36113444: PQ28.2 PQ31.3 PR529.2 PR536.1
N36113446: PC193.2 PC202.1 PC204.1 PR284.1 PR506.1 PR513.1
N36113486: PC194.1 PC197.1 PR262.1 PR514.1
N36113506: PC221.1 PR315.1 PR317.1 PR319.1
N36113657: PR255.1 PR273.2
N36113663: PR329.1 PR334.1
N36113681: PC411.1 PR275.2 PR511.1
N36113701: PC194.2 PR274.1
N36113708: PC193.1 PR260.1
N36119320: PC112.1 PU11.12
N36119321: PC335.2 PR479.1 PU11.4
N36119343: PC334.1 PR477.1 PU11.3
N36119360: PD2.2 PQ16.3 PR142.1
N36119368: PQ14.2 PQ15.3 PQ16.2 PR139.2 PR140.1
N36119381: PR136.1 PU10.3
N36119386: PQ14.3 PR132.2
N36119389: PC122.1 PQ15.2 PR138.1 PU10.4
N36119409: PC121.1 PR135.2
N36196173: R420.1 U18.24
N36196312: R395.1 U18.77
N36202008: C259.2 D40.1 R298.2 R326.2
N36430440: R195.2 U14.F3
N36430441: R202.2 U14.G3
N36765623: R694.2 U40.3
N36980981: R458.1 U18.28
N37464977: C404.1 R421.2 U18.70
N37522596: PC356.1 PC387.1 PC443.1 PL19.1 PQ47.3 PR185.2 PR251.2 PU22.8
N37522685: PC180.2 PR218.1
N37551635: PC379.2 PQ47.2 PR485.2 PR491.1
N37551639: PC379.1 PQ47.1(S) PR483.2 PR485.1
N37551712: PQ48.3 PR491.2
N37551735: PQ48.2 PR494.2 PR495.2
N37571887: R430.1 U18.25
N41128552: R365.2 U18.87
N41320915: R367.2 U18.15
N45447309: R259.2 U18.126
N45637747: PQ44.3 PR474.2
N45637749: PQ44.2 PQ45.3 PR475.2 PR476.1
N46045575: PQ50.2 PQ52.3 PR493.1
N46045583: PQ50.3 PR484.1
N46625301: R746.1 TP66.1
N46636605: T6.1 U10.27
N46636606: T7.1 U10.26
N46636609: R813.1 R818.1 U10.29
N46636612: T5.1 U10.35
N46636613: T15.1 U10.3
N46636614: T4.1 U10.38
N47097166: PQ25.2 PQ53.3 PR277.1
N47097174: PQ25.3 PR291.1
N47371767: CN18.58 TP124.1
N47371769: CN18.56 TP123.1
N48020127: TP87.1 U14.AE44
N48033744: R1094.2 U14.AU26
N48064173: PR442.1 PU2.38(VSP_3PH_B)
N48064421: PR445.1 PU2.37
N48064522: PR446.1 PU2.36
N48064592: PR450.1 PU2.29
N48064619: PR449.1 PU2.30
N48064646: PR448.1 PU2.34
N48066678: PR56.1 PU2.28
N48066698: PR61.1 PU2.27
N48067217: PR451.1 PU2.25
N48072604: PC39.1 PR47.1 PU4.3
N48095174: Q73.3 R869.2
N48597124: PQ54.3 PR282.1
N48623264: PD6.3(COMMON ANODE) PR259.2
N48777312: PR377.2 PR563.2
N48782284: PR380.1 PR396.2
N48825927: Q16.5 R103.2 R104.2
N49080261: R925.1 TP103.1
N49312089: PQ24.4 PR285.2 PR289.2
N49317148: CN16.64 R175.1
N49321163: R565.1 R587.2 R594.1
N49321219: Q53.3 Q54.2 R604.2
N49355730: CN16.38 TP128.1
N49355733: CN16.40 TP129.1
N49355736: CN16.42 TP130.1
N49704554: R500.2 U18.35
N49976193: LED1.1 Q8.6
N51039131: Q35.2 Q35.3 R460.1
N51040469: Q38.2 Q38.3 R498.1
N52895575: PR292.1 PR293.2 PR304.2
N52967177: QG18.2 QG18.5 RG155.1
N52967400: QG22.3 QG24.2 QG25.2 RG188.2
N52967406: QG10.2 QG10.5 RG43.1
N52973214: CG900.2 RG191.1 RG192.1 UG9.5
N52973339: CG83.2 QG16.2 QG16.3 RG79.2
N52973345: DG4.3(COMMON ANODE) QG16.5 RG77.2
N53198850: CN8.7 R645.2
N53212830: C285.1 C287.1 R296.1 U17.1
N53212844: R344.1 U17.53
N53212868: R302.2 U17.2
N53212870: R301.2 U17.3
N53212886: R886.2 U17.7
N53212904: C279.1 C280.1 R280.2 U17.9
N53212908: C398.1 U17.42
N53213011: C370.2 U17.27
N53213017: C371.2 C396.2 U17.28(VREF)
N53213083: C420.1 C421.1 R439.1 U17.41
N53213106: C398.2 U17.43
N53213110: C355.2 U17.44
N53213208: R294.1 U17.13
N53213261: C331.1 C336.1 U17.52
N53213275: C879.1 C880.1 U17.39
N53214493: C389.2 R419.2 R427.1
N53214499: C381.1 R419.1
N53214581: C389.1 U20.10
N53214870: C361.1 R407.1
N53217570: C401.2 R423.2 R428.2
N53217572: C388.2 R409.1 R415.2
N53217576: C385.1 R415.1
N53217580: L20.1 U22.6
N53217584: L12.1 U22.1
N53217761: C399.1 R423.1
N53218533: C417.2 R973.2 R1003.1
N53218537: C864.1 R973.1
N53218545: L22.1 U25.1
N53218575: C418.1 U25.9
N53218614: L25.1 U25.5
N53218722: C863.1 R974.1
N53255970: R1072.2 U44.29
N53256180: R1067.2 U44.19
N53256182: R1066.2 U44.21
N53257589: R352.2 U13.16
N53257617: TP77.1 U13.31
N53257780: TP94.1 U13.54
N53257796: TP98.1 U13.55
N53257902: R916.1 R920.2 U13.10
N53257904: R917.1 R918.2 U13.6
N53276765: RG127.1 UG1.AT9 UG1.AT10 UG1.AV10 UG1.AV11
N53276791: RG120.1 UG1.AM10 UG1.AM11 UG1.AN9 UG1.AN10 UG1.AN11 UG1.AR11
N53276837: RG123.1 UG1.AM6
N53276839: RG121.1 UG1.AM5
N53327588: R569.1 U28.3
N53369186: C243.1 C804.2 C805.2 R254.2 R255.2 U16.40
N53388643: PR338.2 PR550.1 PU25.20
N53388645: PR339.2 PR549.1 PU25.19
N53388683: PC417.1 PR550.2
N53388705: PC416.1 PR549.2
N53389227: PQ33.2 PR557.2
N53389243: PQ33.3 PR337.2
N53564514: C707.1 CN12.2 Q68.3 R747.2 R748.1
N53564570: Q67.2 R733.2
N53565581: Q25.2 R174.2
N53565628: C697.1 CN11.2 Q24.3 R731.1 R735.2
N53620392: R163.1 U5.14
N53620394: R155.1 U5.12
N53638085: CN22.2 R504.2
N53716064: PQ22.2 PR510.1 PR512.1
N53716068: PQ18.3 PR176.2
N53716070: PQ18.2 PQ22.3 PR508.1 PR509.2
N53720378: PC129.1 PR146.2
N53720386: PR144.2 PR145.2
N53728040: T10.1 U41.38
N53728042: T11.1 U41.35
N53728044: T14.1 U41.3
N53728285: T12.1 U41.27
N53728287: T13.1 U41.26
N53788150: PQ1.2 PQ38.3 PR1.1 PR2.2
N53788267: PQ38.2 PR12.1 PR16.1
N53788269: PC38.1 PR32.2 PR45.2
N53788361: PC23.1 PC29.2 PR34.2 PR459.1 PR464.2
N53788407: PQ1.3 PR21.2
N53788559: PQ39.3 PQ40.2 PR426.1 PR427.2
N53788585: PC1.1 PR4.1
N53788806: PC95.1 PR115.1
N53789031: PQ40.3 PR444.2
N53789209: PQ39.2 PR428.1
N53799610: PQ42.3 PR469.2
N54130914: R1145.1 U44.1(VSB)
N54133206: R652.1 U34.36
N54133596: C23.2 R16.2 R17.2 U2.3
N54227218: TP59.1 U30.6
N54227279: TP60.1 U30.7
N54443582: T1.1 U39.27
N54443594: T3.1 U39.26
N54443678: T8.1 U39.38
N54443680: T9.1 U39.35
N54443682: T2.1 U39.3
N55927396: PC139.2 PR167.1
N55927404: PR244.1 PU15.31(ZCSET)
N55927441: PC408.1 PR211.2
N55927461: PR222.2 PU15.35
N55927578: PR223.2 PU15.36
N55927589: PR200.2 PU15.39
N55927593: PR224.2 PU15.37
N55927597: PU15.6 PU15.41 TP15.1
N55927792: PC386.1 PR186.2 PU15.3
N55928956: PC142.2 PR171.1
N55928964: PR209.1 PU14.31(ZCSET)
N55929001: PC184.1 PR257.2
N55929021: PR219.2 PU14.35
N55929149: PR207.2 PU14.39
N55929153: PR221.2 PU14.37
N55929157: PU14.6 PU14.41 TP14.1
N55929352: PC355.1 PR177.2 PU14.3
N55940902: PC144.2 PR173.1
N55940967: PC403.1 PR216.2
N55940969: PC380.1 PR192.2 PU21.3
N55940971: PR240.1 PU21.35
N55940973: PR241.1 PU21.36
N55940977: PR242.2 PU21.37
N55940983: PU21.6 PU21.41 TP21.1
N55940988: PR250.1 PU21.31(ZCSET)
N55941017: PR249.1 PU20.31(ZCSET)
N55941021: PC138.2 PR170.1
N55941039: PC404.1 PR215.2
N55941042: PR237.1 PU20.35
N55941044: PR238.1 PU20.36
N55941048: PR239.2 PU20.37
N55941050: PR205.1 PU20.39
N55941056: PU20.6 PU20.41 TP20.1
N55941092: PR248.1 PU19.31(ZCSET)
N55941096: PC137.2 PR169.1
N55941113: PC402.1 PR210.2
N55941116: PR234.1 PU19.35
N55941118: PR235.1 PU19.36
N55941122: PR236.2 PU19.37
N55941124: PR204.1 PU19.39
N55941130: PU19.6 PU19.41 TP19.1
N55941168: PR247.1 PU18.31(ZCSET)
N55941172: PC141.2 PR166.1
N55941190: PC405.1 PR214.2
N55941193: PR231.1 PU18.35
N55941195: PR232.1 PU18.36
N55941199: PR233.2 PU18.37
N55941201: PR203.1 PU18.39
N55941207: PU18.6 PU18.41 TP18.1
N55941243: PR246.1 PU17.31(ZCSET)
N55941247: PC143.2 PR165.1
N55941265: PC406.1 PR213.2
N55941268: PR228.1 PU17.35
N55941270: PR229.1 PU17.36
N55941274: PR230.2 PU17.37
N55941276: PR202.1 PU17.39
N55941282: PU17.6 PU17.41 TP17.1
N55941318: PR245.1 PU16.31(ZCSET)
N55941322: PC140.2 PR168.1
N55941340: PC407.1 PR212.2
N55941343: PR225.1 PU16.35
N55941345: PR226.1 PU16.36
N55941347: PR227.2 PU16.37
N55941349: PR201.1 PU16.39
N55941355: PU16.6 PU16.41 TP16.1
N55941374: PC381.1 PR191.2 PU20.3
N55941387: PC382.1 PR190.2 PU19.3
N55941398: PC383.1 PR189.2 PU18.3
N55941409: PC384.1 PR188.2 PU17.3
N55941420: PC385.1 PR187.2 PU16.3
N55953939: PQ29.2 PR332.1
N55953943: PQ26.2 PQ29.3 PR301.2 PR306.1
N55953959: PQ26.3 PR521.2
N56077694: C508.1 C522.1 Q2.3 Q56.3 Q57.2 Q57.5 Q60.2 Q60.5 R641.2
N56077756: Q2.2 Q3.3 R21.2
N56077770: Q57.1(S) Q57.4
N56077935: Q56.2 Q58.3 R642.2
N56085154: C500.2 R633.2 U36.4 U36.5
N56085203: C511.2 R651.1 U36.1(VOUT)
N56197477: C453.2 C858.2 C921.2 R514.2 U43.6 U43.16(VDD#2)
N56199005: R1070.1 U43.10
N56202137: CN20.13 R1111.2
N56214175: PR206.1 PU21.39
N56249919: Q60.1(S) Q60.4
N56249956: R646.2 U36.3
N56249990: CN2.14 R643.2
N56253576: PR220.2 PU14.36
N56276780: C757.2 Q71.2 R824.1
N56281109: Q74.3 R958.2 R997.2
N56281163: Q74.6 R948.2 R996.2
N56382763: Q48.3 R599.1 R600.2
N56382839: Q48.6 R558.1 R585.2
N56383035: Q42.3 R584.1 R597.2 R598.2
N56390078: CN19.12 TP120.1
N56406548: C873.1 Q75.2 Q77.3 R1159.2
N56481431: C366.2 R392.2 R407.2
N56481770: C366.1 U20.9
N56482049: C358.2 U20.8
N56482348: L10.1 U20.5
N56482351: L9.1 U20.6
N56482420: L16.1 U20.2
N56482438: L18.1 U20.1
N56543786: C409.2 U22.8
N56543890: C401.1 U22.9
N56544006: C388.1 U22.10
N56544277: C418.2 R974.2 R1002.2
N56544490: C417.1 U25.10
N56544498: C419.2 U25.8
N56545499: L19.1 U22.5
N56545754: L15.1 U22.2
N56546274: L23.1 U25.6
N56546363: L24.1 U25.2
N56753045: PC439.1 PR568.1 PU32.4
N56753133: PC423.1 PU32.12
N56753135: PC424.1 PU32.10
N56849590: C266.2 Q31.2 R282.2 R300.1
N56881941: R7.1 U1.1 U1.5(VCC)
N56914265: PQ43.1 PR472.1 PR473.1
N56915153: PR105.1 PU7.8
N56915158: PR92.1 PU7.5
N56915160: PR95.1 PU7.6
N56980326: PQ13.2 PR130.1
N57000372: C424.1 U17.38
N57158778: R518.2 R1162.2 U18.56
N57158785: R517.2 U18.57
N57203085: RG68.2 UG3.1 UG6.1 UG11.4
N57219273: RG175.1 RG176.1 UG5.5(VCC)
N57227413: RG73.1 RG75.1 UG3.5
N57230212: RG63.1 RG64.1 UG6.5
N57230715: RG193.1 RG194.1 UG8.5(VCC)
N57233291: RG186.1 RG187.1 UG11.5(VCC)
N57517898: QG5.1(S) RG25.2
N57587352: PC30.2 PR572.2
N57588964: PC29.1 PR574.2
N58187744: TP131.1 U18.64
N58187751: TP132.1 U18.65
N58349202: R1149.2 U17.56
N58457890: PC444.1 PR575.2 PU11.6 PU11.7
N58458180: PC447.1 PR578.2 PU11.5
N58458766: PC448.1 PU11.10
N58459581: PQ57.3 PR579.2
N58530481: R1151.1 R1152.1 U6.1
N59529757: C945.1 Q79.2 R1161.2
N59747615: PQ58.3 PQ59.2 PR580.2 PR582.1
N59747617: PQ59.3 PR581.2
N59809104: Q80.3 Q81.2 R1166.2 R1168.1
N59809106: Q81.3 R1167.2
N62406391: CG81.1 QG11.6 QG12.2 QG12.5 RG61.2
N62406446: QG11.2 QG11.3 RG60.2
N62406461: QG11.5 RG69.2
N597246311: PC292.1 PR424.2

Pads without a net: CN1 13 14; CN5 16 17 18; CN8 2 4 8 10 13; CN9 3; CN10 38; CN15 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 67 68; CN16 16; CN18 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 67 68 69; CN19 3 5 21 23 26; CN20 2 7 11 12; HOLE3 1; HOLE31 1; JDIM1 162 165; JDIM2 162 165; JDIM3 162 165; JDIM4 162 165; NOREF#4 1; NOREF#8 1; NOREF#9 1; NOREF#15 1; NOREF#17 1; NOREF#18 1; PQ2 2; PQ3 2; PQ6 2; PQ7 2; PU1 5 6; PU2 23 31 32 33 35; PU3 6 27 31 33; PU4 6 27 31 33; PU5 6 27 31 33; PU6 6 27 31 33; PU8 6 27 31 33; PU25 8 10 17 18 21 31; PU28 19; U3 A27 A29 AA14 AE29 AJ8 AP14 AP29 AT13 AU13 AW13 AY13 B2 B26 B27 B28 B29 B30 B33 B34 B36 B38 BH30 BJ28 BK28 BL31 BL34 BM19 BN22 BN23 BN25 BN27 BN28 BN33 BN35 BP1 BP19 BP20 BP22 BP23 BR2 BR19 BR22 BR23 BR31 BR35 BT19 BT22 BT23 C1 C26 C28 C30 C33 C34 C38 D1 D27 D29 D34 E1 E2 E26 E27 E28 E29 E30 E33 E36 E37 F26 F28 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; U4 2 28 29; U5 3 4; U7 A7 A9 A11 A13 A23 AB15 AB17 AB19 AB21 AB23 AC15 AC17 AC19 AC21 AC23 B7 B9 B11 B13 B23 D19 D20 E18 E19 E20 J1 J2 L1 L2 N1 N2 R1 R2 V18 W12 W16 W19 Y12 Y16 Y19; U8 9; U10 4 5 7 8; U11 9; U13 40 41 42 43 46 50 53; U14 A17 A22 A25 AA1 AA45 AC6 AC7 AC9 AC11 AC14 AC15 AE9 AE11 AE14 AE15 AG45 AH14 AH15 AH40 AH41 AH46 AH47 AJ47 AK47 AL35 AL47 AM43 AM45 AM47 AN4 AN37 AN40 AN46 AN47 AP2 AP3 AP21 AP48 AR13 AR42 AT10 AT49 AU24 AV13 AV16 AW3 AW13 AW15 AW24 B15 B17 B18 B19 B21 B23 B24 B25 B26 B27 B41 BC17 BC33 BD8 BD12 BD17 BD21 BE8 BE9 BE12 BE14 BE15 BE36 BF8 BF10 BF33 BF36 BG8 C15 C16 C17 C18 C19 C20 C21 C23 C24 C26 C27 C41 D20 D21 D29 E28 F14 F16 F20 F24 F26 G1 G2 G14 G17 G20 G24 G26 J13 J18 J21 J24 K13 K18 K21 K29 L24 L26 L41 L46 L47 L48 M26 M29 M40 M45 N2 N3 N18 N32 N47 N48 P9 P21 P24 P47 P48 R10 R13 R15 R18 R21 R24 R32 R46 R47 T1 T2 T46 U2 U3 U13 U35 U37 U47 U48 V47 V48 W6 W7 W46 W47 Y2 Y3 Y4 Y15 Y35 Y36 Y46 Y47 Y48; U17 4 5 6 8 16 17 32 33 34 35 36 37 50 51 54 55; U18 36 37 38 39 40 41 42 43 44 45 46 51 52 53 54 55 58 59 60 61 62 63; U21 5 27; U26 9; U28 4; U30 14 15 17 25; U34 2 4 9 10 12 25 26 37; U38 6; U39 4 5 7 8; U41 4 5 7 8; U44 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 30 31 32; UG1 AA44 AC9 AM1 AM2 AM3 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AT1 AT2 AT3 AT6 AT7 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 BB1 BB3 BD4 BD24 BE2 BE4 BK18 BK20 BK21 BK44 BL18 BL20 BL21 BM20 BM21 BM44 BM45 J14 J23 J35 J41 P9

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 7648 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 3469 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 1104 vias
v4: diameter 0.305, hole 0.152, TOP to BOTTOM, 6 vias
v5: diameter 0.457, hole 0.254, TOP to BOTTOM, 3 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_ANX: length 79
  TOP w0.203: v1(265.88,31.74) 265.88,31.87 265.4,32.35 265.04,32.35 264.82,32.57 U15.3 ; U24.22 263.94,23.34 263.76,23.52 v1(263.76,23.77) ; v1(265.99,33.07) 265.55,33.52 265.09,33.52 264.84,33.77 U15.6 ; U24.32 259.19,21.24 ; v1(260.46,30.03) 260.46,30.14 260.64,30.32 U15.33 ; U24.48 v1(261.54,14.32)
  TOP w0.381: R529.1 255.18,17.94 v1(254.92,17.94) ; v1(256,12.85) 255.9,12.95 255.9,13.05 255.49,13.46 R583.1 254.79,13.05 254.07,13.05 253.76,13.35 Q47.2 ; R601.1 267.1,13.13 267.2,13.04 267.96,13.04 C484.2 ; v1(248.23,27.07) 248.15,26.99 R394.2 ; Q47.5 253.76,15.23 253.94,15.06 v1(253.94,14.88)
  IN1 w0.381: v1(258.54,22.52) 258.54,22.65 258.16,23.03 255.99,23.03 254.73,24.29 v1(254.73,24.58)
  IN4 w0.381: v1(241.52,20.29) 241.52,18.46 240.05,16.98 238.43,16.98 237.41,15.96 237.41,15.05 v1(236.67,14.32) ; v1(279.42,40.05) 278.71,40.76 278.05,40.76 276.17,38.88 269.77,38.88 269.26,39.38 267.07,39.38 265.94,38.25 262.47,38.25 262.06,37.84 262.06,36.43 261,35.37 261,34.84 260.39,34.23 259.91,34.23 259.46,33.78 v1(257.65,33.78)
  BOTTOM w0.381: 249.35,26.15 249.35,24.32 R987.2 248.82,23.28 252,23.28 R984.2 252.68,23.35 252.88,23.56 R986.1 254.63,24.48 v1(254.73,24.58) ; 249.35,26.15 250.92,27.73 R937.1 ; 249.35,26.15 249.14,26.15 v1(248.23,27.07) ; R1005.1 257.49,21.86 v1(258.46,21.86) ; v1(254.92,17.94) 255.4,18.42 R1061.2 ; C926.2 261.66,14.44 v1(261.54,14.32) ; v1(256,12.85) 255.9,12.85 255.8,12.95 254.39,12.95 R1134.1 254.22,12.99 R1133.1 253.19,12.99 252,14.18 R1132.1
  vias: v1(232.94,10.71) v1(232.94,9.95) v1(233.7,10.71) v1(233.7,9.95) v1(249.29,16.15) v1(249.95,16.12) v1(260.78,38.14) v1(266.82,23.28) v1(267.18,24.15) v1(267.48,23.28) v1(267.43,14.42) v1(267.86,13.83)
1V8_AON_EN: length 254.3
  TOP w0.14: v1(7.23,90.07) 6.93,90.07 6.61,89.74 6.61,87.84 6.81,87.64 PR143.1
  IN1 w0.086: v1(8.45,135.7) 8.68,135.47 8.68,129.2 9.09,128.79 9.09,127.58 8.65,127.14 8.65,124.48 8.18,124 8.18,119.36 8.6,118.94 8.6,116.42 8.88,116.15 8.88,113.17 8.18,112.47 8.18,108.67 8.61,108.25 8.61,106.04 9.11,105.53 10.33,105.53 10.86,106.06 11.5,106.06 11.73,105.83 11.73,105.43 12.25,104.9 14.18,104.9 15.26,103.83 17.06,103.83 17.37,103.52 17.37,103.09 17.04,102.76 17.04,102 17.44,101.59 17.44,101.11 16.81,100.47 16.81,99.56 17.48,98.89 17.48,96.6 20.33,93.74 v1(22.11,93.74)
  IN2 w0.089: v1(7.23,90.07) 7.36,90.2 15.07,90.2 18.04,93.17 21.39,93.17 21.97,93.74 v1(22.11,93.74) 22.13,93.72 22.13,93.35 23.51,91.97 23.51,91.21 25.53,89.19 25.53,85.99 26.94,84.59 26.94,84.02 27.34,83.62 31.96,83.62 33.61,81.97 34.38,81.97 34.89,81.46 37.28,81.46 37.91,80.83 39.44,80.83 39.96,81.34 39.96,81.79 41.74,83.57 43.4,83.57 43.71,83.26 43.71,83 43.47,82.76 43.47,82.41 43.75,82.13 44.1,82.13 45.92,83.95 48.74,83.95 50.34,82.35 51.81,82.35 52.27,81.89 52.27,81.04 52.13,80.9 v1(52.06,80.9)
  IN3 w0.089: v1(104.03,159.47) 99.43,164.08 96.42,164.08 95.19,162.85 95.19,161.69 94.62,161.12 88.45,161.12 87.77,160.45 85.21,160.45 84.62,161.03 82.63,161.03 82.16,161.51 79.72,161.51 79.24,161.02 74.56,161.02 73.75,160.21 71.18,160.21 69.73,158.76 63.31,158.76 60.85,161.22 60.85,162.91 58.11,165.65 54.81,165.65 53.94,166.51 51.2,166.51 50.06,167.66 48.91,167.66 48.81,167.55 44.94,167.55 43.44,169.05 41.67,169.05 40.68,168.06 31.62,168.06 24.81,161.26 22.85,161.26 20.59,159 20.59,156.28 20.19,155.87 18.76,155.87 17.62,154.73 13.79,154.73 8.6,149.55 8.6,138.19 7.89,137.48 7.89,136.27 v1(8.45,135.7)
  BOTTOM w0.14: PR578.1 21.5,93.74 v1(22.11,93.74) ; Q80.2 103.2,157.42 R1169.1 104.19,159.31 v1(104.03,159.47) ; UG10.4 52.38,80.59 v1(52.06,80.9)
1V8_MAIN_EN: length 14.8
  BOTTOM w0.14: UG5.4 10.56,87.2 10.76,87 13.63,87 13.95,87.31 13.95,90.29 14.41,90.76 14.41,91.73 14.78,92.09 v1(14.78,92.34) 14.78,92.47 16.29,93.98 PQ45.2 17.06,94.32 17.73,94.32 17.9,94.49 PR478.1 18.75,94.49 PR477.2
1V8_MAIN_EN_U: length 49.1
  BOTTOM w0.14: UG5.2 8.55,86.55 8.72,86.72 13.75,86.72 14.47,87.44 15.15,87.44 15.51,87.8 15.51,88.23 v1(15.56,88.28) 15.64,88.36 17.66,88.36 18.06,88.76 21.82,88.76 22.31,88.27 22.31,87.38 21.71,86.78 21.71,86.39 22.01,86.1 23.09,86.1 24.19,87.19 24.98,87.19 25.84,88.04 27.37,88.04 27.97,88.64 34.39,88.64 35.07,89.32 39.46,89.32 39.83,88.95 39.83,88.14 37.47,85.78 36.52,85.78 36.19,85.45 36.19,84.78 DG5.1 37.45,83.52 RG180.1 38.19,83.52 RG179.2 39.41,84.32 39.78,83.95 UG6.4
1V8_MAIN_PG: length 4.7
  BOTTOM w0.14: UG8.1 34.7,81.81 RG183.2 35.61,82.72 v1(36.24,82.72) 36.24,83.2 35.58,83.86 DG5.2
1V8_MAIN_S:
  vias: v1(18.02,97.5)
3V3_SYS: length 61.8
  TOP w0.203: v1(263.77,29.91) 263.77,30.17 263.44,30.5 U15.40 ; U24.54 263.94,14.34 v1(263.92,14.32)
  TOP w0.508: R624.1 264.68,10.23 265.19,9.72 266.12,9.72 v1(266.34,9.94) ; R521.1 245.87,16.8 v1(245.31,17.35) ; R254.1 v1(278.4,40.17) ; R528.2 254.52,16.8 v1(254.87,17.15)
  IN1 w0.508: 243.33,12.69 243.33,13.78 245.36,15.82 245.36,17.31 v1(245.31,17.35)
  IN3 w0.508: v1(245.31,17.35) 245.79,17.35 248.13,19.69 248.13,25.19 248.76,25.82 v1(250.59,25.82)
  IN4 w0.508: 277.89,27.6 279.16,28.87 279.16,31.16 278.91,31.41 278.91,39.67 v1(278.4,40.17) ; v1(247.69,9.39) 247.69,9.95 248.25,10.51 250.31,10.51 251.66,11.85 251.66,14.77 252.23,15.35 253.24,15.35 254.55,16.65 254.55,16.83 v1(254.87,17.15)
  BOTTOM w0.508: v1(263.92,14.32) 263.8,14.44 C924.2 C923.2 264.89,15.1 R1115.1 ; R957.2 251.15,25.59 250.92,25.82 v1(250.59,25.82) ; 243.78,11.42 243.78,12.45 243.93,12.6 243.93,14.32 244.76,15.15 244.76,15.55 245.31,16.1 v1(245.31,17.35) ; R840.1 278.15,39.92 v1(278.4,40.17)
  vias: v1(226.97,10.61) v1(226.97,9.95) v1(227.73,10.61) v1(227.73,9.95) v1(247.01,9.39) v1(277.44,25.14) v1(278.28,25.11)
3V_LDO: length 313.5
  TOP w0.14: PR342.1 49.36,37.74 50.36,37.74 50.76,38.13 50.76,38.97 51.01,39.22 53.03,39.22 54.4,40.59 54.4,42.84 55.6,44.04 55.6,45.44 v1(55.52,45.52) ; v1(171.19,142.49) 173.5,144.8 PR116.1 ; PU28.3 120.41,25.75 121.1,26.43 PC247.1 PR381.1 120.49,26.51 v1(119.94,25.96) 119.94,27.23 120.03,27.32 120.03,28.67 118.79,29.91 115.78,29.91 113.71,31.98 v1(113.71,34.89) ; v1(113.48,26.1) 113.73,25.85 114.28,25.85 PR390.1
  IN3 w0.089: v1(171.19,142.49) 172.01,141.67 172.01,138.73 170.76,137.48 170.76,136.47 170.19,135.9 170.19,131.28 169.45,130.55 169.45,129.92 168.51,128.98 168.51,121.93 169.45,120.99 169.45,114.18 168.62,113.35 168.62,111.95 169.32,111.25 169.93,111.25 172.1,109.08 172.1,94.61 171.13,93.64 171.13,91.7 171.76,91.07 171.76,86.22 170.26,84.72 170.26,81.16 171.06,80.36 171.06,66.94 172.92,65.09 172.92,63.03 175.48,60.46 175.48,58.79 175.76,58.51 175.97,58.51 178.35,56.13 v1(178.35,55.76) ; v1(55.52,45.52) 55.94,45.52 57.79,43.67 57.79,41.18 59.17,39.8 68.41,39.8 68.9,40.29 73.5,40.29 73.63,40.43 81.01,40.43 81.52,40.94 86.62,40.94 87.6,39.96 88.89,39.96 89.16,40.23 89.44,40.23 89.47,40.2 91.48,40.2 91.69,40 91.99,40 92.25,39.74 94.77,39.74 95.18,40.15 96.11,40.15 96.77,40.81 v1(97.73,40.81)
  IN4 w0.086: v1(97.73,40.81) 98.19,40.81 98.93,41.55 98.93,43.59 99.78,44.44 99.78,49.46 101.65,51.34 101.65,63.39 103.45,65.19 110.85,65.19 111.08,65.42 115.38,65.42 117.75,67.79 162.23,67.79 171.84,58.17 173.06,58.17 175.46,55.76 v1(178.35,55.76)
  BOTTOM w0.14: v1(119.94,25.96) 118.61,27.3 116.4,27.3 114.96,25.85 113.73,25.85 v1(113.48,26.1) ; v1(97.73,40.81) 98.01,40.53 98.01,39.44 98.42,39.03 99.27,39.03 100.44,37.86 100.44,37.4 102.06,35.78 112.82,35.78 v1(113.71,34.89)
5V_VCONN:
  vias: v1(249.62,15.41) v1(249.62,14.75) v1(250.36,15.1)
51211V_DRVH: length 6.1
  TOP w0.635: v3(166.73,16.63) 165.95,16.63 165.84,16.74 PQ35.1
  IN2 w0.635: v3(166.73,16.63) 164.51,18.85 v3(164.51,20.22)
51211V_DRVL: length 10.8
  IN2 w0.635: v3(166.06,11.28) 161.97,15.37 161.97,20.05 v3(162.2,20.27)
51211V_EN: length 2.6
  TOP w0.14: PC449.1 163.33,25.96 162.86,26.43 PR385.2
  TOP w0.178: PC449.1 163.67,25.78 163.67,25.24 163.43,25 PU29.3
51211V_FB: length 6.4
  TOP w0.178: 162.53,25.34 162.6,25.34 162.93,25.02 PU29.4
  TOP w0.254: 162.53,25.34 162.17,25.7 162.17,26.57 162.48,26.88 v1(162.48,27.16) 162.39,27.25 162.03,27.25 PR382.1 161.58,26.86 161.12,26.4 161.12,25.04 PR399.1
51211V_SW: length 9.3
  TOP w0.254: v3(163.54,20.24) 163.54,19.48 PC278.2
  IN2 w0.635: v3(163.54,20.24) 163.54,16.13 v3(166.48,13.19)
  vias: v1(167.91,9.24)
51211V_TRIP: length 1.6
  TOP w0.178: PU29.2 163.93,25 164,25.07 164,25.78 PR384.2
51211V_TST: length 2.7
  TOP w0.178: PU29.5 162.43,24.47 161.66,23.7 161.66,23.46 v1(161.47,23.26) 160.9,22.7 PR408.2
51211V_VBST: length 2.7
  TOP w0.254: PR421.1 165.3,19.35 v1(165.3,20.37) 165.3,20.77 164.75,21.32 PU29.10
+1.2V: length 117.1
  IN3 w0.508: v1(142.21,168.88) 141.67,168.88 139.24,166.44 136.37,166.44 134.05,164.13 130.96,164.13 127.6,160.77 125.55,160.77 121.25,156.48 v1(119.04,156.48)
  IN4 w0.508: v1(142.21,168.88) 142.61,168.88 145.03,166.46 148.46,166.46 149.07,165.85 155.97,165.85 157.81,167.69 164.73,167.69 165.8,166.62 165.8,165.53 167.02,164.3 167.02,159.72 167.62,159.12 170.87,159.12 172.14,157.86 173.07,157.86 174.08,156.84 174.08,155.85 171.27,153.04 v1(171.27,151.5) ; v1(119.04,156.48) 118.54,156.98 111.99,156.98 106.18,162.79 100.64,162.79 v1(99.54,161.69)
  BOTTOM w0.178: U34.46 47.95,164.76 v1(47.9,164.71) ; U34.43 48.38,163.56 48.07,163.26 v1(48,163.26)
  BOTTOM w0.191: v1(52.47,159.45) 52.42,159.51 U34.30 ; v1(52.02,167.41) U34.6 ; U34.15 56.23,164.76 v1(56.28,164.71) ; v1(54.96,166.18) 54.96,166.69 54.65,167 54.21,167 54.02,166.81 U34.11 ; v1(56.51,163.41) 56.36,163.56 U34.18
  BOTTOM w0.508: PR469.1 177.82,149.9 177.31,149.39 174.76,149.39 173.88,150.27 172.49,150.27 v1(171.27,151.5)
  vias: v1(60.65,159.91) v1(61.26,159.68) v1(91.99,73.68) v1(91.99,72.91) v1(91.99,72.15) v1(96.44,162.35) v1(96.46,161.69) v1(97.12,161.76) v1(97.35,61.46) v1(97.55,63.29) v1(97.63,62.13)
+1.2V_U3: length 6.1
  TOP w0.178: v1(279.14,10.05) 279.83,10.05 C942.1 278.96,9.54 278.66,9.85 278.66,10.15 278.45,10.35 U30.19 ; U30.34 275.67,14.84 275.74,14.91 275.74,15.3 v1(275.69,15.35)
  TOP w0.191: v1(273.19,12.93) 273.37,12.75 U30.4
  vias: v1(273.25,9.3) v1(273.92,9.32) v1(277.82,13.63) v1(278.63,14.47) v1(278.99,10.79) v1(279.14,12.41) v1(279.14,11.75)
+1.2VSUS: length 522.3
  TOP w0.178: U3.AG9 v1(138.25,110.42)
  TOP w0.203: v1(156.32,21.19) 156.5,21.37 PU27.19 ; v1(138.18,107.82) 138.3,107.82 U3.AG5 ; v1(138.18,107.82) 137.87,108.14 U3.AF6 ; v1(138.18,107.82) 138.08,107.82 U3.AF5 ; U3.AJ12 v1(140.99,111.72) U3.AL11 ; U3.AW6 147.84,108.14 v1(148.25,107.82) 148.62,108.14 U3.AY6 ; JDIM1.112 145.32,49.02 145.93,48.42 145.93,47.94 145.6,47.62 145.46,47.62 v1(145.42,47.58) ; v1(132.75,111.75) U3.Y12
  TOP w0.254: JDIM2.129 141.07,44.42 141.29,44.2 141.29,43.43 v1(141.11,43.24) ; JDIM2.135 139.57,48.07 138.92,48.73 v1(138.05,48.73) ; U3.L6 125.69,107.81 v1(125.62,107.81) 125.51,107.81 125.19,108.14 U3.K6 U3.J6 124.25,108.14 v1(123.94,107.83) 124.28,107.49 U3.J5 ; v1(107.68,47.87) 110.11,47.87 111.07,46.91 JDIM2.241 ; v1(133.71,47.23) 134.1,47.23 134.57,46.76 JDIM2.147 ; 140.82,35.99 JDIM2.130 ; JDIM1.163 130.57,57.23 130.12,56.77 130.12,54.33 v1(130.37,54.07) ; v1(170.93,48.44) 170.55,48.82 170.55,48.97 170.32,49.19 JDIM1.12 ; v1(132.81,34.89) 132.81,35.06 132.82,35.08 JDIM2.154 v1(132.82,38.77) ; v1(126.82,34.89) JDIM2.178 126.82,39.52 126.01,40.34 126.01,40.34 126.01,40.35 v1(126,40.35) ; v1(166.31,42.29) 165.55,42.29 165.37,42.47 165.37,43.32 165.07,43.61 JDIM2.33 ; v1(141.85,48.81) 141.95,48.81 142.32,49.18 JDIM1.124 ; JDIM1.96 149.32,53.45 150.03,54.15 v1(150.07,54.15) ; v1(112.04,54.91) 112.02,54.94 111.97,54.94 111.56,55.36 111.56,56.98 111.2,57.35 111.07,57.47 JDIM1.241 ; v1(145.42,47.58) 145.06,47.58 143.82,48.81 JDIM1.118 ; JDIM1.220 116.32,49.06 v1(116.17,48.91) ; v1(137.51,56.49) 138.59,56.49 139.57,57.47 JDIM1.135 ; v1(135.09,48.9) 134.61,48.9 134.32,49.19 JDIM1.148 ; 142.32,35.82 JDIM2.124 ; v1(150.08,41.41) 150,41.41 149.32,40.74 JDIM2.96 149.32,35.81 ; v1(120.92,59.95) 121.43,59.95 121.57,59.8 JDIM1.199 ; U3.L12 125.7,112.25 125.27,112.25 U3.K12 124.92,111.9 124.79,111.9 v1(124.63,111.74) ; v1(131.26,38.79) 131.32,38.72 JDIM2.160 131.32,35.69 ; v1(129.43,54.27) 129.47,54.23 129.53,54.23 130.24,53.52 130.24,52.73 131.32,51.65 JDIM1.160 ; JDIM1.178 126.82,49.23 127.2,48.85 v1(127.53,48.85) ; v1(134.32,34.89) JDIM2.148 134.32,38.83 v1(134.43,38.94) ; v1(132.6,51.6) 132.82,51.38 JDIM1.154 ; U3.R6 U3.T6 130.3,108.14 v1(130.64,107.8) ; JDIM1.142 137.82,51.27 137.14,51.95 v1(136.29,51.95) ; v1(119.85,42.32) 119.85,42.42 121.57,44.15 JDIM2.199 ; JDIM2.142 137.82,35.54 ; JDIM1.33 165.07,57.15 164.84,56.92 164.84,56.06 165.08,55.82 165.08,55.04 v1(165.79,54.33) ; v1(131.57,60.11) JDIM1.159 ; 144.54,35.86 144.98,35.86 145.32,36.2 JDIM2.112 ; 170.32,35.89 JDIM2.12 170.32,38.8 v1(170.27,38.85) ; v1(140.73,53.9) 139.85,53.9 139.33,54.41 139.33,55.94 140.61,57.22 140.82,57.22 141.07,57.47 JDIM1.129 ; v1(135.87,60.06) 135.9,60.1 137.48,60.1 138.01,59.57 138.07,59.5 JDIM1.141 ; v1(141.85,48.15) 141.34,48.15 140.82,48.67 JDIM1.130 ; JDIM2.111 145.57,42.25 v1(146.78,41.05) ; JDIM2.153 133.07,44.32 132.65,43.9 v1(132.65,43.48) 132.27,43.48 131.57,44.18 JDIM2.159 ; 159.82,35.92 JDIM2.54 159.82,38.24 160.04,38.45 160.04,40.2 v1(160.54,40.71) ; JDIM1.153 133.07,57.28 132.92,57.12 v1(132.92,54.89) ; JDIM2.75 154.57,43.62 153.46,42.5 v1(153.46,40.36) ; U3.AP7 144.19,108.4 U3.AP6 U3.AR6 145.44,108.14 v1(145.71,107.87) ; v1(142.15,42.29) 142.27,42.41 142.27,43.77 142.57,44.08 JDIM2.123 ; v1(152.09,54.16) 152.84,54.16 154.04,55.35 154.04,56.68 154.57,57.21 JDIM1.75 ; JDIM1.123 142.57,57.13 142.14,56.7 v1(141.78,56.7) ; JDIM2.141 138.07,42.67 v1(137.49,42.09) ; v1(130.62,43.73) 130.57,43.78 JDIM2.163 ; U3.AE12 136.52,112.41 v1(136.42,112.41) ; v1(160.41,53.57) 160.23,53.57 159.82,53.17 JDIM1.54 ; v1(116.54,41.4) 116.7,41.23 116.7,39.6 116.32,39.23 JDIM2.220 116.32,35.11 116.28,35.06 v1(116.28,34.89) ; v1(144.17,43.42) 144.07,43.51 JDIM2.117 ; v1(142.87,39.09) 143.17,39.09 143.82,38.44 JDIM2.118 143.82,35.92 ; v1(139.49,51.81) 139.32,51.64 JDIM1.136 ; 139.32,35.78 JDIM2.136
  TOP w0.305: U3.W6 132.83,108.14 v1(133.16,107.81) 133.23,107.81 U3.AA6 ; U3.AR12 145.33,112.28 145.79,112.28 U3.AT12 146.02,112 146.24,111.78 v1(146.47,111.78)
  TOP w0.508: v1(108.38,90.28) 109.65,90.28 C99.1 114.23,91.11 114.83,91.71 114.83,93.8 112.37,96.27 112.37,97.62 111.37,98.62 ; v1(156.32,21.19) 155.51,20.38 PC269.1
  IN1 w0.508: v1(156.32,21.19) 156.32,21.72 154.53,23.51 150.89,23.51 150.26,22.88 147.57,22.88 v1(145.64,20.95)
  IN1 w1.016: 65.6,19.67 66.1,19.17 70.66,19.17 73.68,16.15 73.68,14.47 74.53,13.61 84.71,13.61 85.82,14.72 88.08,14.72 88.56,14.24 90.47,14.24 ; 95.32,17.14 99.32,17.14 99.84,16.62 101.27,16.62 102.2,17.55 102.2,21.54 104.96,24.3 118.76,24.3 119.43,24.97 120.33,24.97 123.13,27.76 129.51,27.76
  IN2 w1.016: 178.23,20.54 179.45,19.32 187.15,19.32 191.53,14.94 192.06,14.94 193.8,13.2 193.8,12.31 197.07,9.03 202.58,9.03 ; 251.96,8.96 269.69,8.96 ; 206.84,9.01 234.05,9.01 235.5,10.46 239.95,10.46 241.42,8.98 245.79,8.98
  BOTTOM w0.254: JDIM4.12 168.42,42.68 167.23,41.48 v1(167.23,41.29) ; v1(107.68,47.87) 109.17,49.37 JDIM3.241 ; v1(135.47,38.76) 135.7,38.76 136.17,38.28 JDIM4.141 v1(136.17,34.89) ; v1(137.51,56.49) 137.42,56.57 JDIM3.136 ; JDIM4.111 143.67,36 143.27,35.6 ; v1(138.05,48.73) 138.03,48.74 138.02,48.74 137.67,49.08 JDIM3.135 ; v1(130.37,54.07) 130.14,53.84 130.14,52.92 131.17,51.88 JDIM3.153 ; v1(129.43,54.27) 129.22,54.27 128.95,54.54 128.95,56.95 129.42,57.43 JDIM3.160 ; v1(129.31,39.48) 129.86,38.94 129.86,38.53 129.67,38.35 JDIM4.159 129.67,35.94 129.69,35.93 129.69,35.17 129.43,34.92 v1(129.43,34.89) ; JDIM4.112 143.42,44.16 v1(144.17,43.42) ; JDIM3.112 143.42,56.65 145.23,54.85 145.23,54.21 145,53.98 v1(144.75,53.98) ; JDIM3.220 114.42,55.44 113.92,54.94 v1(113.57,54.94) ; JDIM4.129 139.17,34.96 v1(139.27,34.86) ; v1(125.84,43.19) 124.92,44.1 JDIM4.178 ; v1(119.96,40.64) 119.89,40.58 119.89,38.57 119.67,38.36 JDIM4.199 119.67,35.1 119.64,35.06 v1(119.64,34.88) ; JDIM4.135 137.67,35.64 v1(138.45,34.86) ; JDIM4.220 114.42,43.39 114.21,43.17 114.21,40.95 v1(114.85,40.31) ; JDIM4.54 157.92,44.15 158.23,43.84 158.23,42.55 v1(157.24,41.56) ; v1(130.62,43.73) 130.64,43.74 130.92,44.03 JDIM4.154 ; JDIM4.118 141.92,44.32 142.16,44.09 142.16,42.3 v1(142.15,42.29) ; v1(137.49,42.09) 138.74,43.34 138.74,43.89 138.92,44.08 JDIM4.130 ; v1(167.78,54.87) 167.98,54.87 168.21,55.09 168.54,55.43 168.92,55.8 168.92,57.08 168.42,57.57 JDIM3.12 ; v1(141.78,56.7) 141.78,56.74 141.92,56.88 JDIM3.118 ; v1(132.81,34.89) 132.67,35.02 JDIM4.147 ; JDIM4.75 152.67,38.49 152.69,38.51 152.69,40.68 v1(152.1,41.28) ; JDIM3.33 163.17,51.78 163.27,51.88 163.27,53.04 162.58,53.74 v1(162.28,53.74) ; JDIM4.96 147.42,46.43 147.78,46.78 v1(147.91,46.78) ; JDIM3.54 157.92,57.28 158.38,56.82 158.38,54.87 v1(157.27,53.75) ; v1(162.58,40.82) 163.03,40.37 163.03,38.64 163.17,38.49 JDIM4.33 ; JDIM4.117 142.17,38.26 142.87,38.95 v1(142.87,39.09) ; JDIM3.75 152.67,53.71 152.23,54.16 v1(152.09,54.16) ; v1(127.96,34.89) 127.96,35.3 128.42,35.75 128.42,36.01 128.67,36.27 JDIM4.163 128.67,38.3 128.49,38.48 v1(128.49,40.34) ; JDIM4.142 135.92,44.56 135.91,44.54 v1(135.91,44.17) 137.18,44.17 137.42,44.41 JDIM4.136 ; JDIM4.123 140.67,35.03 v1(140.83,34.87) ; JDIM3.178 124.92,54.73 124.46,54.27 v1(124.19,54.27) ; v1(131.37,34.89) 131.37,35.92 131.17,36.12 JDIM4.153 131.17,38.71 v1(131.26,38.79) ; v1(119.22,54.16) 119.47,54.16 119.92,53.71 119.92,51.61 119.67,51.36 JDIM3.199 ; v1(135.87,60.06) 135.87,60.02 135.92,59.96 JDIM3.142 ; JDIM4.241 109.17,38.68 109.31,38.81 v1(109.31,39.86)
  BOTTOM w0.508: 177.47,48.05 177.54,48.05
  vias: v1(10.94,47.47) v1(11.47,47.09) v1(61.97,20.18) v1(62.45,19.75) v1(88.96,46.8) v1(89.37,47.4) v1(89.83,47.85) v1(106.47,90.37) v1(106.59,91.01) v1(107.12,91.51) v1(107.24,90.86) v1(112.59,64.3) v1(112.59,63.64) v1(112.59,62.98) v1(120.51,90.5) v1(120.92,62.91) v1(120.92,62.19) v1(120.92,60.6) v1(122.32,54.28) v1(127.01,46.78) v1(129.43,54.91) v1(129.41,52.33) v1(130.48,41.47) v1(130.44,40.82) v1(131.51,48.33) v1(133.08,63.16) v1(133.97,60.78) v1(140.29,60.92) v1(140.2,60.16) v1(141.85,61.26) v1(141.85,60.6) v1(141.85,59.94) v1(141.86,47.41) v1(142.34,34.88) v1(143.25,34.87) v1(144.39,61.76) v1(144.37,61.1) v1(144.39,60.44) v1(144.62,34.87) v1(146.96,62.02) v1(146.96,61.26) v1(146.93,60.5) v1(153.33,34.93) v1(154.76,34.93) v1(156.21,34.93) v1(157.74,34.92) v1(159.28,34.93) v1(160.77,34.93) v1(160.93,61.89) v1(160.93,61.23) v1(160.93,60.57) v1(163.7,34.93) v1(165.2,34.93) v1(174.26,43.48) v1(174.9,43.86) v1(174.92,43.15) v1(176.37,21.56) v1(176.35,20.9) v1(270.48,9.16) v1(271.14,9.16) v3(142.44,27.51) v3(142.43,26.7) v3(143.2,27.48) v3(143.2,26.72) v3(143.99,27.48) v3(143.99,26.72) v3(144.75,27.48) v3(144.75,26.72) v3(145.51,27.48) v3(145.51,26.72) v3(146.27,27.48) v3(146.27,26.72) v3(147.06,27.47) v3(147.06,26.71) v3(147.72,27.07)
+1.8V: length 322
  TOP w0.203: v1(43.12,80.84) 42.53,81.43 RG64.2 ; RG73.2 32.41,79.26 v1(32.14,79)
  TOP w0.508: PQ10.1 178.01,150.16 PR109.1 176.45,147.32 v1(176.99,146.78) ; v1(178.39,135.99) 178.05,135.64 R34.1
  IN1 w0.381: v1(43.12,80.84) 43.11,80.85 40.73,80.85 40.43,80.55 v1(36.9,80.55)
  IN1 w0.508: v1(32.14,79) 32.39,79.24 33.93,79.24 34.16,79.47 36.65,79.47 36.93,79.75 36.93,80.52 v1(36.9,80.55) ; v1(109.49,85.49) 107.23,85.49 v1(106.06,84.32) ; v1(178.39,135.99) 178.81,135.58 180.94,135.58 182.06,134.46 182.06,110.02 180.87,108.83 180.87,106.52 182.11,105.27 182.11,90.56 182.69,89.98 v1(183.86,89.98)
  IN2 w0.381: v1(51.35,79.92) 50.77,79.92 48.76,81.93 45.48,81.93 44.39,80.84 v1(43.12,80.84)
  IN2 w0.508: v1(8.13,84.71) 9.67,86.25 12.31,86.25 16.02,89.96 16.7,89.96 17.63,90.89 17.63,91.55 18.86,92.77 22.09,92.77 22.76,92.1 22.76,91.39 25.13,89.02 25.13,86.42 24.78,86.07 24.78,84.45 25.19,84.04 26.14,84.04 27.96,82.23 29.55,82.23 30.47,83.15 v1(31.39,83.15) ; v1(86.58,80.69) 84.98,80.69 83.9,79.61 55.58,79.61 54.73,80.46 52.69,80.46 52.15,79.92 v1(51.35,79.92) ; v1(178.39,135.99) 176.55,135.99 175.74,136.8 175.74,137.37 173.77,139.35 173.77,143.42 174.47,144.13 174.47,146.01 175.24,146.78 v1(176.99,146.78)
  IN3 w0.508: v1(106.06,84.32) 106.06,85.13 105,86.19 105,89.72 104.27,90.45 104.27,92.03 103.52,92.78 100.69,92.78 96.89,88.98 90.8,88.98 86.58,84.77 v1(86.58,80.69) ; v1(109.92,74.9) 109.92,76.14 108.45,77.61 108.45,84.45 v1(109.49,85.49)
  IN4 w0.508: v1(36.19,77.69) 35.19,77.69 33.88,79 v1(32.14,79) 32.14,79.87 32.07,79.94 32.07,80.38 31.72,80.74 31.21,80.74 30.57,81.37 30.57,82.34 v1(31.39,83.15)
  BOTTOM w0.203: v1(36.19,77.69) 36.03,77.53 RG193.2 ; RG186.2 36.72,80.75 36.9,80.57 v1(36.9,80.55)
  BOTTOM w0.254: v1(8.13,84.71) 8.78,85.37 8.78,86.07 9.06,86.35 RG176.2 ; RG191.2 46.86,77.89 47.24,77.51 49.62,77.51 50.12,78.01 51.12,78.01 51.9,78.79 UG10.5 52.38,79.18 52.04,79.52 51.76,79.52 v1(51.35,79.92)
  BOTTOM w0.508: v1(183.86,89.98) 183.86,89.59 173.7,79.42 166.52,79.42 162.58,75.49 110.5,75.49 v1(109.92,74.9)
+1.8V_AON: length 532.2
  TOP w0.2: v2(10.69,127.03) 10.69,126.99 10.88,126.79 VRAM5.V10
  TOP w0.203: PR144.1 7.36,89.36 7.61,89.11 7.61,88.45 7.46,88.31 v1(7.46,88.29) ; PR312.2 34.44,44.75 34.21,44.52 PR311.2 33.64,44.52 33.42,44.75 33.42,45.84 v1(33.65,46.06)
  TOP w0.25: v2(48.55,155.38) VRAM2.V5 ; v2(79.23,155.31) VRAM4.V5 ; v2(10.26,129.82) 10.56,130.11 10.67,130.11 VRAM5.V5 ; v2(99.17,104.33) VRAM8.V5
  TOP w0.254: PR6.1 12.16,173.22 11.96,173.42 v1(11.96,173.9) ; v1(90.04,91.43) 90.65,92.04 PR137.2
  TOP w0.3: v2(33.1,142.47) 33.11,142.46 33.4,142.46 33.7,142.16 VRAM1.V10 ; VRAM2.A10 45.26,142.16 v2(45.66,141.76) ; VRAM8.V10 98.97,107.48 v2(98.97,107.23) ; v2(10.28,114.83) 10.36,114.91 10.36,115.31 10.83,115.78 VRAM7.A10 ; v2(76.54,141.81) 76.23,141.81 VRAM4.A10 ; VRAM2.V10 45.46,155.11 v2(45.71,155.11) ; VRAM3.V10 64.32,142.16 64.02,142.46 v2(63.78,142.46) ; v2(86.32,120.53) 86.32,120.23 86.02,119.93 VRAM6.V10 ; v2(24.02,119.16) 24.02,119.09 24.7,118.41 24.7,118.36 24.75,118.31 24.75,116.9 23.63,115.79 VRAM7.V10 23.63,115.64 23.33,115.34 23.33,115.23 v2(23.31,115.21) ; VRAM6.V5 v2(85.64,123.31) ; v2(99.12,123.33) VRAM6.A5 ; v2(63.76,155.6) 63.76,155.47 64.32,154.91 VRAM3.A10 ; VRAM8.A10 v2(85.62,107.29) ; v2(24.03,126.97) 24.49,126.51 24.49,123.53 23.05,122.09 v2(21.2,122.09) ; v2(30.32,141.73) 30.32,141.79 VRAM1.V5 ; v2(76.74,155.17) 76.72,155.15 76.62,155.15 76.59,155.12 76.09,155.12 75.88,154.91 VRAM4.V10 ; VRAM6.A10 v2(99.2,120.36) ; v2(33.43,155.55) 33.43,155.25 33.7,154.98 VRAM1.A10 ; v2(60.95,141.78) 60.57,142.16 VRAM3.V5
  TOP w0.305: VRAM5.A10 v2(24.03,126.97) ; v2(10.4,112.42) 10.78,112.03 VRAM7.A5 ; VRAM7.V5 23.65,112.03 23.96,112.34 v2(23.96,112.44) ; VRAM5.A5 v2(24.01,130.7)
  TOP w0.381: v1(22.88,102.53) 22.38,103.03 QG3.2 ; RG59.1 27.72,82.35 27.6,82.46 QG14.2 26.66,82.46 v1(26.33,82.8) 26.08,82.8 25.75,82.46 QG14.5
  TOP w0.4: VRAM4.A5 79.63,142.16 v2(80,141.78) ; v2(49.39,141.78) 49.01,142.16 VRAM2.A5 ; v2(30.31,155.26) VRAM1.A5 ; v2(85.64,103.56) VRAM8.A5 ; VRAM3.A5 v2(60.92,155.26)
  TOP w0.508: RG24.1 31.89,97.97 v1(31.42,98.44) 31.91,98.92 RG21.1 ; 31.89,105.15 RG8.1 ; 31.89,105.15 31.89,105.3 32.22,105.63 RG7.1 ; 31.89,105.15 31.89,105 v1(32.28,104.61) 31.89,104.22 RG11.2 ; v1(18.94,103.22) 19.31,103.59 19.31,103.71 19.66,104.06 RG12.1 ; v1(31.21,100.91) 31.31,101.01 RG18.1 RG17.1 ; RG78.1 44.43,78.32 v1(44.67,78.55) 44.67,78.63 45.83,79.78 CG84.1 46.43,79.78 47.16,79.05 RG72.1 47.47,79.05 UG2.8 53.12,79.05 v1(53.82,78.35) 54.1,78.07 58.09,78.07 58.54,78.52 RG76.1 59.19,78.91 60.12,79.83 60.12,84.54 58.85,85.81 57.59,85.81 RG49.1 56.49,85.01 56.05,85.44 RG48.1 ; v1(23.2,97.33) 23.31,97.44 RG145.2 ; RG13.1 22.89,102.53 v1(22.88,102.53) ; v1(28.26,87.88) 27.63,87.88 27.63,87.88 RG39.1 ; v1(26.56,93.13) 26.81,93.38 RG29.1 26.81,94.16 26.69,94.28 RG28.1 ; RG40.1 v1(24.35,87.86) ; v1(29.19,99.64) 29.62,100.07 RG19.1 ; v1(27.88,97.96) 27.86,97.93 QG5.2 ; RG27.1 v1(31.41,96.41)
  IN1 w0.25: 62.41,154.25 62.41,148.96 v2(62.35,148.89) 62.18,148.72 62.18,146.88 63.21,145.84 63.21,142.9 63.65,142.46 v2(63.78,142.46) ; 62.41,154.25 v2(63.76,155.6) ; 62.41,154.25 61.41,155.26 v2(60.92,155.26) ; v2(13.13,120.51) 13.86,119.77 23.42,119.77 v2(24.02,119.16)
  IN1 w0.3: v2(31.84,149.53) 31.84,149.53 32.21,149.15 32.21,148.73 31.67,148.18 31.67,147.73 32.16,147.24 32.16,146.39 32.6,145.94 32.6,142.77 32.9,142.47 v2(33.1,142.47) ; v2(48.48,144.5) 48.13,144.5 47.83,144.2 47.83,143.61 48.51,142.92 48.51,142.66 v2(49.39,141.78)
  IN1 w0.305: v1(22.8,79.44) 21.79,79.44 20.24,77.89 15.51,77.89 v1(15,78.4) ; v1(12.42,91.47) 11.78,90.83 8.74,90.83 8.4,90.49 8.4,89.24 7.46,88.31 v1(7.46,88.29) 7.46,86.09 9.67,83.89 9.67,80 9.21,79.54 8.92,79.54 8.78,79.4 8.78,76.94 8.16,76.32 v1(8.07,76.32)
  IN1 w0.381: v1(15.23,136.03) 15.72,135.55 23.01,135.55 24.86,133.7 24.86,131.31 24.26,130.7 v2(24.01,130.7)
  IN1 w0.508: v2(80,141.78) 80,141.42 80.54,140.88 83.71,140.88 ; 77.49,154.73 77.49,150.74 v2(78.12,150.1) ; v1(24.35,87.86) 24.35,87.72 25.9,86.17 27.45,86.17 28.26,86.99 v1(28.26,87.88)
  IN2 w0.3: v2(76.54,141.81) 77.25,142.52 77.25,145.04 77.88,145.67 77.88,149.85 v2(78.12,150.1) ; v2(20.2,107.52) 20.82,108.14 23.4,108.14 23.92,108.66 23.92,109.21 24.53,109.82 24.53,111.89 24.1,112.32 24.08,112.32 23.99,112.41 23.99,112.41 v2(23.96,112.44) ; v2(48.55,155.38) 48.55,155.24 48.03,154.73 48.03,150.91 47.57,150.45 47.57,145.95 47.83,145.69 47.83,145.15 v2(48.48,144.5) 47.6,144.5 46.77,143.66 46.77,142.87 v2(45.66,141.76) ; v2(85.64,103.56) 86.3,104.22 86.69,104.22 87.83,105.36 95.01,105.36 v2(95.06,105.41)
  IN2 w0.305: v1(24.56,159.58) 24.56,159.79 20.31,164.04 20.31,171.34 17.34,174.31 12.26,174.31 11.96,174.01 v1(11.96,173.9) ; v2(60.92,155.26) 60.92,155.54 60.7,155.77 58.95,155.77 57.68,157.04 56.05,157.04 55.2,156.18 53.97,156.18 53.68,156.47 52.13,156.47 51.83,156.17 49.48,156.17 48.68,155.38 v2(48.55,155.38) ; v2(31.84,149.53) 31.44,149.93 31.44,153.98 32.58,155.12 33,155.12 v2(33.43,155.55) ; v2(33.43,155.55) 34.16,156.28 38.29,156.28 38.87,156.86 41.74,156.86 42.03,157.14 43.66,157.14 45.7,155.11 v2(45.71,155.11) ; v2(33.43,155.55) 32.04,155.55 31.54,155.05 30.52,155.05 v2(30.31,155.26) ; v2(79.23,155.31) 78.16,156.37 v2(77.64,156.37)
  IN2 w0.508: v1(24.05,84.85) 24.05,84.16 25.51,82.7 26.24,82.7 v1(26.33,82.8)
  IN3 w0.305: v1(15,78.4) 14.96,78.35 14.96,71.79 15.46,71.29 15.46,66.89 15.95,66.4 15.95,62.4 16.63,61.72 16.63,60.39 18.17,58.85 18.17,56.9 20.23,54.85 20.23,52.95 21.61,51.57 21.61,48.45 22.65,47.41 25.28,47.41 25.59,47.71 25.59,48.19 25.89,48.5 27.21,48.5 27.75,49.04 28.51,49.04 29.03,48.52 29.03,48.23 29.66,47.59 32.76,47.59 33.06,47.28 33.06,46.65 v1(33.65,46.06)
  IN3 w0.508: v1(90.04,91.43) 90.04,92.14 90.9,93 90.9,94.91 90.76,95.05 90.76,96.61 91.63,97.48 94,97.48 95.33,96.15 98.34,96.15 98.87,96.68 98.87,97.75 101.23,100.11 101.23,103.82 100.71,104.33 v2(99.17,104.33)
  IN4 w0.3: v2(31.84,149.53) 31.58,149.53 31.26,149.21 31.26,148.72 31.34,148.65 31.34,146.35 30.96,145.97 30.96,142.21 30.48,141.73 v2(30.32,141.73) ; v2(92.75,121.82) 92.61,121.96 91,121.96 90.24,122.73 86.23,122.73 v2(85.64,123.31) ; v2(20.2,107.52) 19.07,106.39 15.69,106.39 15.02,107.05 10.99,107.05 9.87,108.17 9.87,111.88 v2(10.4,112.42) v2(10.4,113.09) ; v2(60.95,141.78) 61.71,142.55 61.71,145.86 62.35,146.5 v2(62.35,148.89) ; v2(21.2,122.09) 20.61,121.5 18.46,121.5 18.04,121.08 13.7,121.08 v2(13.13,120.51)
  IN4 w0.381: v1(38.06,81.54) 38.58,82.05 39.18,82.05 40.97,80.26 v1(40.97,79.9)
  IN4 w0.508: v1(26.33,82.8) 27.8,81.33 27.8,80.64 29.29,79.15 29.29,77.77 30.28,76.78 32.89,76.78 v1(33.93,77.82)
  BOTTOM w0.203: CG340.1 25.37,126.07 24.87,126.58 CG336.1 24.43,126.58 v2(24.03,126.97) ; v1(38.06,81.54) 37.96,81.43 RG187.2 ; PC336.1 8.77,90.58 8.38,90.97 7.51,90.97 PR480.1 ; RG192.2 45.07,78.35 44.87,78.55 44.68,78.55 v1(44.67,78.55)
  BOTTOM w0.225: CG301.1 10.09,130.3 10.26,130.12 v2(10.26,129.82) ; CG273.1 64.01,142.24 v2(63.78,142.46) ; CG113.1 45.58,155.23 v2(45.71,155.11) ; v2(33.43,155.55) 33.43,155.61 CG98.1 ; v2(23.31,115.21) 23.48,115.38 CG521.1 ; CG109.1 48.87,155.6 48.64,155.38 v2(48.55,155.38) ; CG277.1 60.75,141.58 v2(60.95,141.78) ; CG584.1 24.18,112.21 v2(23.96,112.44)
  BOTTOM w0.254: CG458.1 24.1,119.08 v2(24.02,119.16) ; CG100.1 64.23,155.87 63.95,155.6 v2(63.76,155.6) ; v2(85.64,103.56) 85.61,103.59 CG753.2 ; v2(99.12,123.33) 99.48,123.68 CG348.1 ; CG111.1 76.75,155.18 v2(76.74,155.17) ; CG690.2 85.48,107.44 v2(85.62,107.29) ; v2(98.97,107.23) 99.05,107.31 CG691.1 ; v2(76.54,141.81) 76.23,141.5 CG279.1 ; QG20.5 QG20.2 9.95,84.46 10.2,84.71 13.7,84.71 13.71,84.73 v1(13.85,84.59) ; v2(79.23,155.31) 79.45,155.53 CG104.1 ; v1(15.28,74.29) 15.28,78.12 v1(15,78.4) 14.98,78.4 14.81,78.57 13.24,78.57 12.99,78.82 12.99,79.18 12.44,79.72 Q65.2 ; v2(49.39,141.78) 49.26,141.66 49.26,141.29 48.59,140.62 CG288.1 ; CG421.2 86.15,120.36 v2(86.32,120.53) ; CG353.1 85.48,123.47 v2(85.64,123.31) ; v2(99.17,104.33) 99.48,104.02 CG745.1 ; CG110.1 60.85,155.34 v2(60.92,155.26) ; CG415.1 99.25,120.42 v2(99.2,120.36) ; CG280.1 45.43,141.31 45.66,141.54 v2(45.66,141.76) ; CG275.1 33.42,142.14 33.1,142.46 v2(33.1,142.47) ; v2(30.31,155.26) 30.08,155.49 CG112.1 ; v1(8.07,76.32) 8.24,76.32 8.87,76.94 8.87,78.29 8.58,78.58 8.58,78.83 8.57,78.84 8.57,79.31 8.58,79.31 8.58,79.54 8.75,79.71 8.82,79.71 8.83,79.72 Q65.5 ; RG175.2 11.89,86.38 13.89,86.38 14.61,87.1 15.29,87.1 16.21,88.02 17.89,88.02 18.14,88.28 18.95,88.28 v1(19.25,87.98) ; v1(23.2,97.33) 23.2,97.4 RG162.2 ; CG282.1 30.19,141.44 30.32,141.57 v2(30.32,141.73)
  BOTTOM w0.305: v2(80,141.78) 79.66,141.78 78.9,141.01 CG286.1 ; v1(33.93,77.82) 34.23,77.53 RG194.2 ; v1(26.33,82.8) 25.22,82.8 23.08,80.66 23.08,79.72 v1(22.8,79.44)
  BOTTOM w0.381: v1(53.82,78.35) 53.74,78.43 53.74,80.05 51.73,82.06 51.73,82.83 RG181.2 ; CG727.1 85.6,107.27 v2(85.62,107.29) ; v1(28.73,104.33) 28.71,104.36 Q63.5 Q63.2
  BOTTOM w0.508: RG138.1 27.2,100.45 RG140.1 27.22,100.09 27.15,100.02 27.15,99.13 27.88,98.39 v1(27.88,97.96) ; v1(99.43,151.43) 100.76,151.43 101.37,152.04 R1167.1 ; v1(40.58,77.87) 40.63,77.92 RG190.2 ; RG171.2 18.26,91.04 RG173.2 17.98,89.95 20.72,89.95 ; v1(9.8,106.24) 9.8,106.06 10.81,105.05 RG128.1 10.81,104.64 11.73,103.72 RG130.1 11.96,103.69 RG133.2 11.96,101.86 RG135.1 12.08,101.17 12.45,101.17 14.35,99.27 RG143.2
  vias: v1(9.1,88.32) v1(9.44,87.75) v1(9.79,88.31) v1(10.16,87.77) v1(11.43,91.03) v1(12.93,91.91) v1(13.35,92.4) v1(13.58,91.78) v1(14,92.33) v1(19.76,87.57) v1(20.25,87.99) v1(20.5,87.38) v1(21.2,91.15) v1(21.93,96.49) v1(22.43,95.94) v1(22.94,95.52) v1(27.78,91.79) v2(10.39,127.65) v2(10.31,120.29) v2(10.86,120.29) v2(42.33,101.82) v2(42.85,101.8) v2(43.63,101.81) v2(43.71,100.72) v2(44.85,100.5) v2(45.48,100.52) v2(100.22,107.61) v2(100.22,106.98) v2(101.21,122.29) v2(101.21,121.73)
