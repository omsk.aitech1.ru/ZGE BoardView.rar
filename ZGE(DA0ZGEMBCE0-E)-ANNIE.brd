# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD27: length 25.5
  TOP w0.14: VRAM8.H10 91.27,107.17 91.53,106.91 91.83,106.91 91.95,107.03 92.11,107.03 92.23,106.91 93.38,106.91 93.62,107.15 93.62,107.58 VRAM8.L10
  TOP w0.165: 92.47,106.91 92.47,106.34 92.28,106.15 91.76,106.15 91.52,106.39 87.76,106.39 87.7,106.44 85.22,106.44 84.42,107.25 77.37,107.25 75.6,109.03 73.07,109.03 72.85,109.25 UG1.AJ52
FBA_CMD28: length 20.8
  TOP w0.11: 73.25,109.29 73.14,109.29 72.87,109.57 72.47,109.57 72.15,109.25 UG1.AJ51
  TOP w0.165: 73.25,109.29 75.71,109.29 77.2,107.8 84.45,107.8 85.38,106.87 89.53,106.87 90.14,107.48 90.14,108.06 VRAM8.G11
FBA_CMD29: length 26.7
  TOP w0.11: UG1.AJ50 71.44,109.25 71.79,109.6 72.16,109.6 72.34,109.78 72.95,109.78 73.16,109.58 73.3,109.58
  TOP w0.165: VRAM8.H12 91.27,109.18 v2(91.64,108.81) ; v2(90.02,112.1) 89.12,112.1 88.72,112.5 86.26,112.5 82.11,108.34 77.04,108.34 75.8,109.58 73.3,109.58
  IN2 w0.114: v2(90.02,112.1) 90.47,112.1 91.08,111.48 91.42,111.48 91.96,110.93 91.96,109.1 91.67,108.81 v2(91.64,108.81)
FBA_CMD30: length 26.9
  TOP w0.14: VRAM8.K12 92.63,109.32 92.16,109.32 VRAM8.J12
  TOP w0.165: UG1.AG50 71.59,110.31 72.08,110.31 72.36,110.02 73.2,110.02 73.35,109.87 75.89,109.87 76.87,108.89 81.88,108.89 85.91,112.92 88.95,112.92 89.36,112.51 90.33,112.51 90.76,112.08 90.76,111.64 91.11,111.29 91.25,111.29 91.63,110.92 91.63,109.74 91.81,109.56 92.22,109.56 92.39,109.4 92.39,109.32
FBA_CMD31: length 28.8
  TOP w0.14: VRAM8.J11 92.04,108.43 v2(92.41,108.06) 92.52,108.06 92.77,108.31 VRAM8.K11
  TOP w0.165: UG1.AG51 72.15,110.65 72.51,110.29 73.33,110.29 73.49,110.14 76,110.14 76.7,109.44 81.51,109.44 85.54,113.46 87.38,113.46 87.51,113.33 89.18,113.33 89.41,113.1 91.57,113.1 v2(92.86,111.82)
  IN2 w0.114: v2(92.86,111.82) 92.76,111.72 92.76,108.41 v2(92.41,108.06)
FBA_CMD32: length 31
  TOP w0.135: VRAM6.H12 93.52,118.47 v2(93.18,118.81)
  TOP w0.165: v2(94.38,115.03) 94.38,114.9 93.66,114.17 88.49,114.17 88.36,114.3 83.68,114.3 79.88,110.5 76.39,110.5 76.22,110.67 73.82,110.67 73.48,111.01 70.89,111.01 UG1.AF49
  IN2 w0.114: v2(93.18,118.81) 93.18,118.56 93.51,118.23 93.51,115.9 v2(94.38,115.03)
FBA_CMD33: length 27.9
  TOP w0.165: UG1.AG52 73.35,110.65 73.6,110.4 73.99,110.4 76.11,110.4 76.53,109.98 81.28,109.98 85.18,113.88 87.84,113.88 87.97,113.75 89.65,113.75 89.88,113.52 92.3,113.52 v2(93.91,111.92) ; VRAM8.L12 93.52,109.18 v2(93.14,108.81)
  IN2 w0.102: 93.77,111.78 v2(93.91,111.92)
  IN2 w0.114: 93.77,111.78 93.53,111.54 93.53,109.19 v2(93.14,108.81)
FBA_DBI0: length 39.7
  TOP w0.168: v2(69.53,117.33) 69.46,117.39 69.44,117.39 69.18,117.65 UG1.U47 ; VRAM6.D2 96.52,125.93 v2(96.89,125.56)
  IN2 w0.14: v2(69.53,117.33) 69.88,117.68 71.71,117.68 71.93,117.45 71.93,116.91 72.57,116.27 74.73,116.27 79.33,120.88 79.33,121.61 82.26,124.53 82.26,127.01 83.82,128.57 88.9,128.57 89.26,128.93 91.18,128.93 91.54,128.57 92.74,128.57 93.52,127.79 93.52,125.34 93.68,125.18 96.52,125.18 v2(96.89,125.56)
FBA_DBI1: length 34.2
  TOP w0.168: v2(69.51,115.96) 69.85,115.62 UG1.Y48 ; VRAM6.D13 v2(96.14,117.31)
  IN4 w0.102: v2(69.51,115.96) 69.73,115.73 70.35,115.73 70.88,115.2 71.84,115.2 72.31,114.74 75.56,114.74
  IN4 w0.127: v2(96.14,117.31) 95.77,117.69 95.21,117.69 95.02,117.88 95.02,119.33 94.37,119.98 94.04,119.98 93.17,120.85 91.32,120.85 90,122.17 85.18,122.17 77.75,114.74 75.56,114.74
FBA_DBI2: length 23.5
  TOP w0.168: v2(69.53,110.2) 69.15,110.59 UG1.AG47 ; v2(87.89,117.31) VRAM6.R13
  IN2 w0.14: v2(87.89,117.31) 87.52,116.93 85.1,116.93 77.77,109.61 71.94,109.61 71.8,109.47 71.19,109.47 70.52,110.14 70.52,110.36 70.29,110.59 69.92,110.59 v2(69.53,110.2)
FBA_DBI3: length 26.2
  TOP w0.135: v2(71.05,113.89) 70.93,113.77 70.4,113.77 70.08,113.45 UG1.AC48
  TOP w0.168: VRAM6.R2 88.27,125.93 v2(87.9,126.3)
  IN2 w0.14: v2(71.05,113.89) 72.82,113.89 72.98,113.73 76.13,113.73 85.27,122.87 85.75,122.87 86.02,123.14 86.02,124.27 86.18,124.43 88.09,124.43 88.27,124.62 88.27,125.93 v2(87.9,126.3)
FBA_DBI4: length 19.9
  TOP w0.102: UG1.BB51 72.35,99.6 72.68,99.27 73.15,99.04 v2(74.45,99.04)
  TOP w0.216: v2(88.64,101.31) VRAM8.D2
  IN2 w0.14: v2(74.45,99.04) 74.88,99.47 76.76,99.47 77.53,100.24 82.94,100.24 85.13,102.43 88.04,102.43 88.27,102.2 88.27,101.68 v2(88.64,101.31)
FBA_DBI5: length 22
  TOP w0.102: v2(71.62,103.3) 71.61,103.28 71.58,103.28 UG1.AV50
  TOP w0.216: VRAM8.D13 88.63,110.29 v2(88.63,110.33)
  IN2 w0.14: v2(71.62,103.3) 71.62,103.32 71.95,103.64 72.73,103.64 73.01,103.36 74.64,103.36 74.65,103.35 80.19,103.35 85.13,108.29 85.13,108.97 85.34,109.18 88.13,109.18 88.27,109.32 88.27,109.97 v2(88.63,110.33)
FBA_DBI6: length 34.6
  TOP w0.168: v2(96.89,109.56) VRAM8.R13 ; v2(69.51,107.57) 69.84,107.15 UG1.AM48
  IN2 w0.14: v2(96.89,109.56) 96.52,109.93 96.52,112.55 95.52,113.55 94.17,113.55 93.92,113.8 84.42,113.8 78.44,107.82 72.38,107.82 71.81,107.25 71.14,107.25 70.8,107.58 69.55,107.58 69.53,107.57 v2(69.51,107.57)
FBA_DBI7: length 31.1
  TOP w0.102: v2(74.93,104.19) 74.43,104.7 70.9,104.7 UG1.AR49
  TOP w0.168: VRAM8.R2 v2(96.14,101.31)
  IN4 w0.102: v2(74.93,104.19) 75.21,103.92 75.56,103.92
  IN4 w0.127: 75.56,103.92 82.8,103.92 84.08,105.19 88.89,105.19 89.19,104.89 89.38,104.71 89.65,104.71 89.78,104.59 89.78,104.04 89.77,104.04 89.77,101.15 89.99,100.93 95.77,100.93 v2(96.14,101.31)
FBA_DEBUG0: length 6.6
  TOP w0.102: v2(74.22,117.95) 74.22,117.16 73.18,116.12 72.31,116.12 ; 71.62,115.69 71.81,115.87 71.82,115.87
  TOP w0.109: 71.62,115.69 71.49,115.55 UG1.Y50 ; 72.31,116.12 72.1,115.92 71.86,115.92 71.82,115.87
  BOTTOM w0.165: TPG52.1 73.69,116.47 74.22,117 v2(74.22,117.95)
FBA_DEBUG1: length 9.9
  TOP w0.102: UG1.AR50 71.45,105.05 71.77,105.37 72.06,105.37 72.32,105.63 74.42,105.63 74.9,105.15 74.9,104.92 75.2,104.61
  TOP w0.165: 75.2,104.61 75.45,104.37 75.45,102.82 v2(75.22,102.59)
  BOTTOM w0.165: v2(75.22,102.59) 75.13,102.51 72.94,102.51 TPG66.1
FBA_EDC0: length 38.9
  TOP w0.168: v2(70.18,119.37) 70.17,119.3 UG1.R48 ; VRAM6.C2 97.27,125.93 v2(97.64,126.31)
  IN2 w0.14: v2(97.64,126.31) 97.29,126.67 97.29,127.33 96.57,128.05 96.57,128.87 94.03,131.41 82.93,131.41 79.39,127.86 79.39,124.75 76.92,122.28 76.92,121.55 75.06,119.7 74.53,119.7 74.28,119.95 73.52,119.95 73.32,119.76 70.57,119.76 v2(70.18,119.37)
FBA_EDC1: length 35.5
  TOP w0.168: v2(69.97,116.25) 69.99,116.42 69.99,116.47 70.02,116.66 69.84,116.88 UG1.V48 ; VRAM6.C13 v2(96.89,118.06)
  IN4 w0.102: 75.56,115.34 72.66,115.34 72.19,115.81 70.78,115.81
  IN4 w0.127: 70.78,115.81 70.34,116.25 v2(69.97,116.25) ; v2(96.89,118.06) 96.51,118.44 95.99,118.44 95.77,118.66 95.77,120.54 93.91,122.4 91.24,122.4 89.95,123.69 85.42,123.69 77.07,115.34 75.56,115.34
FBA_EDC2: length 25.3
  TOP w0.168: v2(87.14,118.06) VRAM6.T13 ; UG1.AF44 67.05,111.35 v2(66.71,111.69)
  IN2 w0.14: v2(66.71,111.69) 66.71,111.68 67.06,111.44 67.2,111.36 67.7,111.36 68.12,111.25 68.5,111.25 68.66,111.41 70.51,111.41 70.96,110.96 71.27,110.96 71.97,110.26 77.52,110.26 84.94,117.68 86.77,117.68 v2(87.14,118.06)
FBA_EDC3: length 23.7
  TOP w0.168: VRAM6.T2 87.52,125.93 v2(87.14,125.56) ; v2(70.24,115.21) 70.21,115.21 UG1.AA48
  IN2 w0.14: v2(70.24,115.21) 70.6,114.85 71.42,114.85 71.81,114.46 72.98,114.46 73.17,114.27 75.72,114.27 85.26,123.81 85.26,125.01 85.43,125.18 86.77,125.18 v2(87.14,125.56)
FBA_EDC4: length 17.9
  TOP w0.168: UG1.BB52 72.65,99.97 v2(72.93,99.68)
  TOP w0.216: v2(87.89,102.06) VRAM8.C2
  IN2 w0.14: v2(87.89,102.06) 87.52,101.69 85.3,101.69 83.3,99.69 77.75,99.69 76.73,98.67 74.21,98.67 73.43,99.44 73.17,99.44 v2(72.93,99.68)
FBA_EDC5: length 20.6
  TOP w0.102: v2(73.66,104.02) 73.51,103.88 72.52,103.88 72.42,103.97 71.89,103.97 71.52,104.35 UG1.AT50
  TOP w0.216: VRAM8.C13 v2(87.89,109.56)
  IN2 w0.14: v2(87.89,109.56) 87.51,109.94 85.24,109.94 84.58,109.28 84.58,108.72 79.78,103.92 75.27,103.92 75.12,103.77 73.93,103.77 73.67,104.02 v2(73.66,104.02)
FBA_EDC6: length 35.2
  TOP w0.168: v2(97.64,110.31) VRAM8.T13 ; UG1.AK48 69.54,108.86 69.51,108.86 v2(69.47,108.9)
  IN2 w0.14: v2(69.47,108.9) 69.51,108.86 69.54,108.86 69.85,108.55 70.5,108.55 70.63,108.67 71.06,108.67 71.37,108.36 78.22,108.36 84.2,114.34 96.1,114.34 97.3,113.14 97.3,110.65 v2(97.64,110.31)
FBA_EDC7: length 29.6
  TOP w0.102: UG1.AR51 72.22,105.05 72.6,105.43 73.46,105.43 v2(73.77,105.12)
  TOP w0.168: VRAM8.T2 v2(96.89,102.06)
  IN4 w0.102: v2(73.77,105.12) 74.2,104.69 75.56,104.69
  IN4 w0.127: v2(96.89,102.06) 96.89,102.03 96.55,101.68 95.99,101.68 95.99,101.68 90.74,101.68 90.53,101.9 90.53,104.56 90.14,104.94 88.65,105.72 83.74,105.72 82.7,104.69 75.56,104.69
FBA_PLL_AVDD: length 5.9
  TOP w0.2: UG1.L17 v2(48.12,121.36)
  TOP w0.25: UG1.L29 v2(56.97,121.43) ; UG1.V11 43.95,116.95 44.25,116.65 v2(44.33,116.65)
  TOP w0.3: UG1.AF42 65.65,111.48 v2(65.38,111.76) ; v2(65.25,106.2) 65.29,106.19 UG1.AN42 ; UG1.L38 62.63,121.63 v2(62.63,121.4)
  BOTTOM w0.305: CG407.1 62.39,121.16 v2(62.63,121.4) ; CG724.1 65.04,105.98 v2(65.25,106.2) ; CG410.1 48.12,120.96 v2(48.12,121.36) ; CG581.1 65.33,111.8 v2(65.38,111.76) ; v2(44.33,116.65) 44.42,116.56 CG504.1
  vias: v1(27.12,106.29) v1(27.28,106.95) v1(27.93,106.98)
FBA_VREFC: length 65.7
  TOP w0.3: VRAM6.K1 92.02,126.76 v2(92.35,127.09) ; VRAM8.K1 92.56,100.73 v2(92.56,100.39)
  TOP w0.508: v1(90.44,134.03) 90.12,133.7 RG2.2 90.12,132.37 RG5.2 91.03,132.37 RG3.2
  IN2 w0.508: v1(90.44,134.03) 91.47,133 97.06,133 101.14,128.92 101.14,125.92 102.21,124.85 102.21,102.31 98.28,98.38 93.07,98.38 92.56,98.89 v2(92.56,100.39)
  IN4 w0.381: v2(92.35,127.09) 92.27,127.17 92.27,127.27
  IN4 w0.508: 92.27,127.27 92.27,128.21 92.7,128.64 92.7,129.81 90.44,132.07 v1(90.44,134.03)
  BOTTOM w0.508: CG835.1 92.29,100.11 v2(92.56,100.39)
FBA_ZQ_1_A: length 5.9
  TOP w0.102: VRAM6.J14 93.18,116.52 93.18,115.8 93.38,115.6 94.35,115.6 94.83,115.13 v2(94.83,113.94)
  BOTTOM w0.14: v2(94.83,113.94) 94.83,113.94 RG115.1
FBA_ZQ_1_B: length 1.2
  TOP w0.102: v2(92.39,116.56) VRAM6.K14
  BOTTOM w0.14: RG113.1 92.37,116.54 v2(92.39,116.56)
FBA_ZQ_2_A: length 2
  TOP w0.3: VRAM8.J14 92.02,110.8 v2(92.34,111.13)
  BOTTOM w0.3: RG117.1 92.34,112.5 v2(92.34,111.13)
FBA_ZQ_2_B: length 2.1
  TOP w0.3: v2(93.14,111.06) VRAM8.K14
  BOTTOM w0.3: v2(93.14,111.06) 93.36,111.27 93.36,112.08 93.44,112.17 RG116.1
FBB_CMD0: length 32.3
  TOP w0.135: v2(59.44,149.28) 59.44,149.29 VRAM3.H3
  TOP w0.165: v2(56.07,150.54) 55.82,150.54 54.85,149.57 54.85,147.14 55,147 55,141.52 55.07,141.45 55.07,140.49 55.07,140.32 56.7,138.69 56.7,133.21 58.55,131.36 59.25,131.36 60.41,130.21 60.41,128.7 60.6,128.51 60.75,128.36 60.75,128.15 UG1.B35
  IN1 w0.102: v2(59.44,149.28) 59.44,149.49 59.81,149.86 59.81,150.98 59.65,151.14 56.67,151.14 v2(56.07,150.54)
FBB_CMD1: length 28.2
  TOP w0.14: VRAM3.K3 v2(58.7,148.53) VRAM3.J3
  TOP w0.165: v2(56.46,149.01) 56.46,149.35 56.18,149.63 55.6,149.63 55.23,149.26 55.23,147.35 55.4,147.18 55.4,141.67 55.62,141.45 55.62,140.54 57.25,138.92 57.25,133.4 59.02,131.63 59.36,131.63 60.75,130.25 60.75,128.85 UG1.A35
  IN2 w0.089: v2(56.46,149.01) 56.56,149.01 56.67,148.9 58.33,148.9 v2(58.7,148.53)
FBB_CMD2: length 26.7
  TOP w0.135: VRAM3.J1 56.99,148.91 56.47,148.39 v2(56.47,147.76)
  TOP w0.165: v2(56.47,147.76) 55.8,147.08 55.8,141.8 56.16,141.43 56.16,140.77 57.79,139.14 57.79,133.23 59.13,131.9 59.48,131.9 61.1,130.27 61.1,127.1 UG1.D35
  BOTTOM w0.165: RG97.1 56.03,147.31 v2(56.47,147.76)
FBB_CMD3: length 26.2
  TOP w0.14: VRAM3.K4 v2(60.2,148.53) VRAM3.J4
  TOP w0.165: v2(56.29,146.83) 56.22,146.76 56.22,141.85 56.71,141.36 56.71,140.99 58.34,139.37 58.34,133.41 61.45,130.3 UG1.A36
  IN2 w0.089: v2(56.29,146.83) 56.68,147.22 58.84,147.22 59.08,147.46 59.08,148.01 59.22,148.15 59.81,148.15 v2(60.2,148.53)
FBB_CMD4: length 23.4
  TOP w0.11: UG1.B36 61.45,128.15 61.45,128.36 61.76,128.67 61.76,129.05 61.72,129.09 61.72,129.25
  TOP w0.165: VRAM3.L3 58.69,147.03 57.05,147.03 56.7,146.68 56.7,141.76 56.97,141.49 56.98,141.49 58.88,139.59 58.88,133.41 61.72,130.57 61.72,129.25
FBB_CMD5: length 22.5
  TOP w0.11: 61.98,129.29 61.97,129.28 61.97,128.52 61.8,128.35 61.8,128.02 61.45,127.67 UG1.C36
  TOP w0.165: 61.98,129.29 61.98,130.72 59.43,133.27 59.43,139.7 61.41,141.68 61.41,145.96 61.08,146.28 60.2,146.28 VRAM3.M4
FBB_CMD6: length 24.4
  TOP w0.14: VRAM3.J5 60.57,148.85 60.94,148.48 60.62,148.16 VRAM3.K5
  TOP w0.165: UG1.C38 62.85,127.66 62.51,128.01 62.51,128.29 62.24,128.56 62.24,129.09 62.31,129.15 62.31,130.84 59.98,133.17 59.98,139.06 61.51,140.6 61.51,141.17 61.68,141.33 61.68,146.97 61.49,147.16 61.49,147.62 61.06,148.05 61.06,148.36 60.94,148.48
FBB_CMD7: length 26.5
  TOP w0.14: VRAM3.L5 61.03,147.41 v2(61.1,147.34) ; v2(61.49,148.47) 61.68,148.66 61.68,149.21 61.51,149.38 60.76,149.38 60.57,149.57 VRAM3.H5
  TOP w0.165: UG1.B38 62.85,128.33 62.51,128.67 62.51,128.98 62.57,129.04 62.57,131.03 60.52,133.09 60.52,138.84 62.06,140.38 62.06,141.39 61.95,141.51 61.95,147.08 61.76,147.27 61.76,147.83 61.42,148.17 61.42,148.4 v2(61.49,148.47)
  IN2 w0.114: v2(61.49,148.47) 61.49,147.4 61.34,147.26 61.18,147.26 v2(61.1,147.34)
FBB_CMD8: length 25.3
  TOP w0.165: UG1.A38 62.84,128.86 62.84,131.24 61.07,133.01 61.07,138.61 62.61,140.15 62.61,141.35 62.21,141.75 62.21,147.19 62.02,147.38 62.02,148.53 61.93,148.63 61.93,149.91 61.06,150.78 60.39,150.78 60.01,150.41 VRAM3.G4
FBB_CMD9: length 27.9
  TOP w0.165: UG1.D38 63.2,127.1 63.2,131.37 61.61,132.95 61.61,138.38 63.15,139.92 63.15,141.18 62.48,141.86 62.48,147.38 62.29,147.57 62.29,148.28 62.88,148.87 62.88,149.46 63.37,149.95 63.37,150.35 63.79,150.77 64.71,150.77 VRAM3.G11
FBB_CMD10: length 28.8
  TOP w0.14: VRAM3.M10 63.91,146.66 v2(63.58,146.33) ; v2(63.85,150.28) 63.85,150.22 64,150.06 64.21,150.06 64.32,150.17 VRAM3.G10
  TOP w0.165: UG1.A39 63.55,131.48 62.16,132.87 62.16,138.16 63.7,139.7 63.7,141.14 62.75,142.09 62.75,148 v2(62.85,148.1)
  IN2 w0.089: v2(63.58,146.33) 63.38,146.33 62.5,147.2 62.5,147.94 62.67,148.1 v2(62.85,148.1) 62.88,148.1 63.44,148.66 63.44,149.87 v2(63.85,150.28)
  BOTTOM w0.165: RG95.2 63.02,147.94 v2(62.85,148.1)
FBB_CMD11: length 26.5
  TOP w0.14: VRAM3.L10 63.72,147.41 63.54,147.59 63.54,148.44 63.38,148.61 63.54,148.77 63.54,149.56 63.74,149.76 64.21,149.76 VRAM3.H10
  TOP w0.165: 63.38,148.61 63.26,148.5 63.26,147.67 63.01,147.42 63.01,142.2 63.43,141.79 63.8,141.79 64.24,141.34 64.24,139.47 62.71,137.93 62.71,132.85 63.87,131.69 63.87,130.49 63.87,130.49 63.87,129.35 63.9,129.32 63.9,128.7 63.55,128.34 UG1.B39
FBB_CMD12: length 22.5
  TOP w0.102: UG1.C39 63.55,127.66 63.9,128.01 63.9,128.32 64.14,128.55 64.14,129.56
  TOP w0.165: 64.14,129.56 64.14,131.88 63.25,132.76 63.25,137.71 64.79,139.24 64.79,141.18 63.91,142.05 63.54,142.05 63.28,142.31 63.28,145.59 63.6,145.92 63.8,145.92 64.17,146.28 64.7,146.28 VRAM3.M11
FBB_CMD13: length 25.9
  TOP w0.102: UG1.C41 64.95,127.46 64.59,127.82 64.59,128.34 64.36,128.57 64.36,129.5 64.4,129.54
  TOP w0.135: v2(65.45,147.76) 65.8,147.41 VRAM3.L12
  TOP w0.165: v2(67.73,147.75) 68.15,147.33 68.15,141.6 63.8,137.25 63.8,132.63 64.4,132.02 64.4,129.54
  IN2 w0.114: v2(67.73,147.75) 67.4,147.41 65.79,147.41 v2(65.45,147.76)
FBB_CMD14: length 27.3
  TOP w0.14: VRAM3.K11 64.74,148.49 v2(64.74,148.54) 64.74,148.67 64.97,148.91 VRAM3.J11
  TOP w0.165: v2(68.98,147.42) 68.69,147.13 68.69,141.31 67.82,140.44 64.34,136.96 64.34,132.59 64.67,132.26 64.67,129.35 64.6,129.27 64.6,128.71 64.95,128.36 UG1.B41
  IN4 w0.102: v2(68.98,147.42) 68.23,148.17 65.11,148.17 v2(64.74,148.54)
FBB_CMD15: length 26
  TOP w0.14: VRAM3.K12 v2(66.19,148.53) 65.82,148.9 VRAM3.J12
  TOP w0.165: v2(68.99,148.75) 69.38,148.37 69.38,147.05 69.24,146.92 69.24,141.09 64.89,136.74 64.89,132.62 64.95,132.56 UG1.A41
  IN4 w0.102: v2(66.19,148.53) 66.58,148.91 68.83,148.91 v2(68.99,148.75)
FBB_CMD16: length 35.3
  TOP w0.135: VRAM4.L3 81.13,149.66 v2(80.75,149.28)
  TOP w0.165: v2(83.27,149.44) 84.71,149.44 85.1,149.05 85.1,140.47 76.6,131.97 75.73,131.97 74.06,130.31 71.78,130.31 71.46,130.63 70.83,130.63 70.21,130 70.21,128.49 UG1.B49
  IN2 w0.114: v2(83.27,149.44) 83.17,149.44 82.95,149.65 81.38,149.65 81.01,149.28 v2(80.75,149.28)
FBB_CMD17: length 37.1
  TOP w0.14: VRAM4.J3 81.13,148.16 81.49,148.52 v2(81.5,148.52) 81.49,148.53 81.49,148.54 81.13,148.91 VRAM4.K3
  TOP w0.165: UG1.A49 70.48,128.92 70.48,129.87 70.86,130.25 71.38,130.25 71.62,130.01 74.71,130.01 75.92,131.23 77.01,131.23 85.64,139.87 85.64,149.36 84.52,150.49 v2(84.04,150.49)
  IN2 w0.089: v2(84.04,150.49) 84.13,150.39 84.13,149.78 83.44,149.08 82.91,149.08 82.72,148.89 82.07,148.89 81.7,148.52 v2(81.5,148.52)
FBB_CMD18: length 30.3
  TOP w0.135: 84.46,147.37 83.56,148.28 82.75,148.28 VRAM4.J1
  TOP w0.165: 84.46,147.37 84.46,147.05 v1(84.45,147.03) 84.55,146.93 84.55,140.76 76.45,132.66 75.6,132.66 73.55,130.61 71.95,130.61 71.64,130.93 70.75,130.93 69.85,130.02 UG1.A48
  BOTTOM w0.165: RG91.1 84.53,147.03 v1(84.45,147.03)
FBB_CMD19: length 31.2
  TOP w0.14: VRAM4.K4 v2(80,148.53) VRAM4.J4
  TOP w0.165: UG1.D47 68.81,127.09 68.81,128.29 68.6,128.5 68.6,130.55 70.34,132.29 71.19,132.29 74.48,135.58 75.19,135.58 79.46,139.85 79.46,141.4 78.93,141.93 78.93,143.05 78.31,143.67 78.31,144.94 78.59,145.22 78.59,145.86 78.98,146.25 78.98,147.26 v2(79.06,147.34)
  IN2 w0.089: v2(79.06,147.34) 78.61,147.8 78.61,148.59 78.92,148.91 79.37,148.91 79.75,148.53 v2(80,148.53)
FBB_CMD20: length 29.1
  TOP w0.135: v2(80.75,147.78) 81.13,147.41 VRAM4.H3
  TOP w0.165: UG1.A47 69.23,128.93 69.23,130.3 70.48,131.54 72.7,131.54 75.17,134.02 75.93,134.02 83.46,141.55 83.46,146.58 v2(83,147.03)
  IN2 w0.114: v2(80.75,147.78) 81.14,147.39 82.64,147.39 v2(83,147.03)
FBB_CMD21: length 26.7
  TOP w0.11: 68.97,129.13 68.84,129.01 68.84,128.67 69.15,128.36 UG1.B47
  TOP w0.165: VRAM4.G4 80.01,147.03 79.49,147.03 79.25,146.79 79.25,146.14 78.85,145.75 78.85,145.11 78.58,144.83 78.58,143.78 79.2,143.16 79.2,142.04 80.01,141.24 80.01,139.63 72.19,131.81 70.33,131.81 68.97,130.45 68.97,129.13
FBB_CMD22: length 35.1
  TOP w0.14: VRAM4.K5 79.47,148.91 v2(79.08,148.52) 79.43,148.16 VRAM4.J5
  TOP w0.165: UG1.C47 69.15,127.63 69.5,127.98 69.5,130.12 70.62,131.24 71.82,131.24 72.06,131 73.16,131 75.45,133.29 76.14,133.29 84.01,141.15 84.01,146.59 83.53,147.06 v2(83.53,147.64)
  IN2 w0.089: v2(83.53,147.64) 83.53,147.85 83.23,148.15 79.44,148.15 v2(79.08,148.52)
FBB_CMD23: length 30
  TOP w0.14: VRAM4.H5 79.61,147.41 78.91,148.11 78.63,148.38 78.63,148.6 79.63,149.6 VRAM4.L5
  TOP w0.165: 78.63,148.38 78.5,148.25 78.5,146.14 78.32,145.97 78.32,145.33 78.04,145.05 78.04,143.56 78.66,142.94 78.66,141.82 78.91,141.57 78.91,140.08 74.96,136.13 74.25,136.13 70.88,132.76 70.27,132.76 68.31,130.8 68.31,128.56 68.1,128.35 68.1,128.01 67.75,127.66 67.75,127.45 UG1.C45
FBB_CMD24: length 29.6
  TOP w0.11: 68,129.12 68,129.05 68.06,128.99 68.06,128.66 67.75,128.35 UG1.B45
  TOP w0.165: 68,129.12 68,130.94 70.5,133.44 70.5,134.62 73.58,137.7 75.76,137.7 78.37,140.31 78.37,142.85 77.78,143.45 77.78,145.17 78.05,145.44 78.05,146.08 78.23,146.25 78.23,148.56 79.16,149.49 79.16,149.75 79.45,150.03 80,150.03 VRAM4.M4
FBB_CMD25: length 30.4
  TOP w0.165: VRAM4.M11 75.13,150.41 75.52,150.8 76.07,150.8 76.21,150.94 76.58,150.94 77.96,149.55 77.96,146.36 77.79,146.19 77.79,145.55 77.51,145.28 77.51,143.34 78.05,142.79 78.05,141.16 77.82,140.93 77.82,140.53 75.54,138.25 73.35,138.25 69.96,134.85 69.96,133.34 67.65,131.03 67.65,128.95 UG1.A45
FBB_CMD26: length 35.5
  TOP w0.14: VRAM4.M10 75.88,150.28 76.05,150.12 76.35,150.12 76.48,150.25 76.48,150.42 v2(76.37,150.53) ; VRAM4.G10 v2(76.86,147.3)
  TOP w0.165: UG1.D44 67.05,126.75 67.39,127.09 67.39,131.21 69.41,133.24 69.41,135.08 73.13,138.79 75.31,138.79 77.27,140.76 77.27,140.91 77.74,141.37 77.74,142.73 77.24,143.23 77.24,145.39 77.52,145.66 77.52,146.3 77.7,146.47 77.7,147.9 77.7,148.85 77.46,149.08 v2(77.07,149.08)
  IN2 w0.089: v2(76.86,147.3) v2(77.07,149.08) 77.07,149.94 76.48,150.53 v2(76.37,150.53)
  BOTTOM w0.165: v2(76.37,150.53) 76.5,150.41 RG82.2
FBB_CMD27: length 30
  TOP w0.14: VRAM4.L10 76,149.66 76.1,149.76 76.36,149.76 76.65,149.48 76.65,147.69 76.37,147.41 VRAM4.H10
  TOP w0.165: UG1.A44 67.05,131.55 68.86,133.37 68.86,135.3 72.9,139.34 75.08,139.34 77.38,141.63 77.38,142.71 76.97,143.12 76.97,145.5 77.25,145.77 77.25,146.41 77.42,146.58 77.42,148.45 77.23,148.64 76.65,148.64
FBB_CMD28: length 25.6
  TOP w0.11: 66.73,129.67 66.74,129.66 66.74,128.66 66.93,128.47 66.93,128.27 UG1.B44
  TOP w0.165: 66.73,129.67 66.73,131.91 68.32,133.5 68.32,135.53 72.67,139.88 74.86,139.88 76.14,141.17 76.53,141.17 77.05,141.68 77.05,142.67 76.71,143.01 76.71,145.8 76.22,146.28 75.5,146.28 75.13,146.66 VRAM4.G11
FBB_CMD29: length 26.2
  TOP w0.11: UG1.C44 67.05,127.64 66.7,127.99 66.7,128.29 66.53,128.46 66.53,129.51 66.49,129.55
  TOP w0.135: v2(74.75,147.78) VRAM4.H12
  TOP w0.165: v2(71.55,146.73) 71.91,146.37 71.91,142.09 72.01,141.99 72.01,139.99 67.77,135.76 67.77,133.6 66.46,132.29 66.46,129.58 66.49,129.55
  IN2 w0.114: v2(74.75,147.78) 73.65,147.78 73.32,147.45 72.55,147.45 71.83,146.73 v2(71.55,146.73)
FBB_CMD30: length 27.1
  TOP w0.14: VRAM4.J12 v2(74,148.53) VRAM4.K12
  TOP w0.165: v2(71.63,147.83) 71.04,147.24 71.04,146.57 71.46,146.14 71.46,140.22 67.23,135.98 67.23,133.88 66.09,132.74 66.09,129.58 66.29,129.38 66.29,128.58 66,128.29 66,128 65.65,127.65 UG1.C42
  IN2 w0.089: v2(71.63,147.83) 71.89,148.09 73.56,148.09 v2(74,148.53)
FBB_CMD31: length 28.6
  TOP w0.14: VRAM4.J11 75.2,148.16 75.45,148.4 75.45,148.54 v2(75.46,148.55) 75.46,148.58 VRAM4.K11
  TOP w0.165: UG1.B42 65.65,128.35 66.02,128.73 66.02,129.27 65.82,129.47 65.82,133.02 66.6,133.8 66.6,136.13 70.92,140.44 70.92,146.26 70.56,146.62 70.56,147.59 v2(71.83,148.86)
  IN2 w0.089: v2(71.83,148.86) 71.91,148.86 71.97,148.91 75,148.91 75.37,148.55 v2(75.46,148.55)
FBB_CMD32: length 30.8
  TOP w0.135: VRAM3.H12 65.49,149.32 v2(65.49,149.28)
  TOP w0.165: v2(68.97,150.13) 69.44,150.13 70.3,149.27 70.3,148.39 69.78,147.87 69.78,146.25 69.79,146.25 69.79,140.86 65.44,136.51 65.44,133.74 65.29,133.59 65.29,127.09 UG1.D41
  IN4 w0.102: v2(65.49,149.28) 65.71,149.28 66.08,149.65 66.36,149.65 66.41,149.7 68.54,149.7 v2(68.97,150.13)
FBB_CMD33: length 28.6
  TOP w0.135: v2(74.75,149.28) VRAM4.L12
  TOP w0.165: v2(71.67,150.48) 70.77,149.58 70.77,148.31 70.18,147.71 70.18,146.45 70.37,146.26 70.37,140.67 66.05,136.35 66.05,133.74 65.55,133.24 65.55,128.95 UG1.A42
  IN2 w0.114: v2(74.75,149.28) 74.38,149.66 72.23,149.66 72.1,149.79 72.1,150.06 v2(71.67,150.48)
FBB_DBI0: length 32.3
  TOP w0.168: v2(59.05,127.8) 59.04,127.8 58.69,127.45 UG1.C32 ; VRAM3.D2 v2(58.7,153.03)
  IN1 w0.127: v2(59.05,127.8) 59.05,127.82 59.29,128.06 59.29,128.86 59.57,129.13 59.57,130.22 59.84,130.49 59.84,135.25 54.74,140.36 54.74,148.47 54.95,148.68 54.95,149.86 54.73,150.08 54.73,150.91 55.18,151.35 55.18,151.86 56.73,153.41 58.09,153.41 58.47,153.03 v2(58.7,153.03)
FBB_DBI1: length 40.4
  TOP w0.168: v2(59.04,126.39) 59.06,126.39 59.07,126.38 59.07,126.38 UG1.E33 ; VRAM3.D13 v2(66.95,152.28)
  IN4 w0.102: 60.06,131.84 60.06,128.31 59.45,127.7 59.45,126.71 59.17,126.43 59.1,126.43 59.07,126.4 59.05,126.4 v2(59.04,126.39)
  IN4 w0.127: 60.06,131.84 60.06,136.59 57.55,139.1 57.55,146.77 58.32,147.54 58.32,153.3 58.43,153.41 61.93,153.41 62.9,154.38 64.2,154.38 64.42,154.16 66.36,154.16 66.56,153.96 66.56,152.69 66.95,152.31 v2(66.95,152.28)
FBB_DBI2: length 21.5
  TOP w0.168: UG1.E44 67.05,126.01 v2(66.71,125.66) ; v2(66.95,144.03) VRAM3.R13
  IN4 w0.102: 67.69,131.84 67.69,131.34 66.79,130.44 66.79,127.19 66.54,126.93
  IN4 w0.127: v2(66.95,144.03) 66.57,143.66 66.04,143.66 65.82,143.44 65.82,143.13 65.82,143.13 65.82,141.44 67.69,139.58 67.69,131.84 ; v2(66.71,125.66) 66.64,125.73 66.64,125.75 66.54,125.85 66.54,126.93
FBB_DBI3: length 25.3
  TOP w0.168: v2(57.95,144.04) 57.95,144.04 VRAM3.R2 ; UG1.G39 63.83,124.37 63.86,124.37 v2(63.9,124.33)
  IN2 w0.14: v2(63.9,124.33) 63.86,124.37 63.77,124.37 63.63,124.51 63.63,125.3 63.55,125.39 63.55,126.58 63.5,126.63 63.5,127.66 64.5,128.66 64.5,135.63 59.82,140.31 59.82,143.46 59.81,143.46 59.62,143.65 59.23,143.65 59.07,143.81 59.07,144.21 58.89,144.39 58.3,144.39 57.95,144.04 v2(57.95,144.04)
FBB_DBI4: length 33.1
  TOP w0.168: v2(82.25,144.78) 81.88,144.41 VRAM4.D2 ; UG1.P49 70.92,120.12 70.92,120.18 v2(70.94,120.2)
  IN2 w0.14: v2(70.94,120.2) 71.09,120.2 71.29,120 73.22,120 73.55,120.32 74.77,120.32 76.27,121.82 76.27,122.55 78.74,125.02 78.74,128.13 80.46,129.85 80.46,137.91 82.63,140.08 82.63,144.41 v2(82.25,144.78)
FBB_DBI5: length 26.9
  TOP w0.168: v2(69.53,121.52) 69.53,121.53 UG1.L48 ; VRAM4.D13 73.26,144.78 v2(73.22,144.78)
  IN2 w0.14: v2(73.22,144.78) 72.83,144.39 72.83,142.16 72.81,142.14 72.81,126.27 71.86,125.31 70.7,125.31 70.54,125.15 70.54,124.2 70.37,124.03 69.96,124.03 69.68,123.75 69.68,123.39 69.87,123.2 69.87,122.7 69.55,122.38 69.55,121.53 v2(69.53,121.52)
FBB_DBI6: length 31.9
  TOP w0.168: v2(70.93,127.1) 70.93,127.07 UG1.D50 ; v2(74,153.03) VRAM4.R13
  IN2 w0.14: v2(74,153.03) 73.63,153.41 73.63,153.96 73.44,154.15 72.92,154.15 72.86,154.21 72.27,154.21 71.95,153.88 71.95,153.24 71.12,152.41 71.12,151.09 70.92,150.89 70.92,148.32 70.56,147.96 70.56,145.32 70.98,144.9 70.98,140.68 71.44,140.22 71.44,128.4 71.3,128.25 70.93,127.1 v2(70.93,127.1)
FBB_DBI7: length 39.5
  TOP w0.168: UG1.H50 v2(71.58,123.62) ; VRAM4.R2 81.88,152.66 v2(82.25,152.28)
  IN4 w0.102: 71.61,124.37 72.69,125.45 72.69,125.71 73.26,126.29 73.44,126.29 73.81,126.66 73.81,127.41 73.82,127.41 74.25,127.84 74.25,129.56 74.26,129.56
  IN4 w0.127: v2(71.58,123.62) 71.61,123.65 71.61,124.37 ; 74.26,129.56 74.38,129.68 74.38,144.2 74.59,144.41 76.48,144.41 76.69,144.62 76.69,145 78.14,146.44 78.14,149.6 78.57,150.02 78.57,150.2 78.43,150.34 78.43,150.84 78.68,151.09 78.68,151.83 79.51,152.66 80.91,152.66 81.13,152.88 81.13,153.24 81.31,153.41 81.35,153.41 81.35,153.41 81.66,153.41 81.66,153.41 82.09,153.41 82.1,153.41 82.41,153.41 82.42,153.41 82.47,153.41 82.63,153.26 82.63,152.66 v2(82.25,152.28)
FBB_DEBUG0: length 10.5
  TOP w0.136: UG1.C35 60.42,127.78 60.42,128.33 60.02,128.73 60.02,130.24 59.15,131.11 58.25,131.11 v2(57.18,132.18)
  BOTTOM w0.165: v2(57.18,132.18) 57.93,132.18 58.4,131.72 TPG36.1
FBB_DEBUG1: length 6.9
  TOP w0.109: UG1.B50 71.6,128.5 71.6,129.44 71.88,129.71 73.6,129.71 73.81,129.51
  TOP w0.165: 73.81,129.51 75.96,129.51 76.32,129.86 TPG42.1
FBB_EDC0: length 32.9
  TOP w0.168: VRAM3.C2 v2(57.95,153.78) ; v2(59.71,128.51) 59.35,128.15 UG1.B33
  IN2 w0.14: v2(57.95,153.78) 58.32,153.41 58.91,153.41 59.07,153.25 59.07,150.57 58.91,150.4 56.96,150.4 56.7,150.14 55.89,150.14 55.28,149.54 55.28,139.37 60.64,134.01 60.64,129.73 59.71,128.81 v2(59.71,128.51)
FBB_EDC1: length 34
  TOP w0.168: VRAM3.C13 v2(66.2,153.03)
  TOP w0.254: v2(60.44,126.41) 60.75,126.1 UG1.E35
  IN4 w0.102: 60.99,126.89 60.99,127.91 61.13,128.04 61.13,131.84
  IN4 w0.127: v2(60.44,126.41) 60.45,126.42 60.52,126.42 60.99,126.89 ; 61.13,131.84 61.13,137.66 59.07,139.72 59.07,146.73 59.81,147.47 59.81,150.37 60.53,151.08 61.46,151.08 63.04,152.67 65.62,152.67 66,153.05 66.18,153.05 v2(66.2,153.03)
FBB_EDC2: length 22.6
  TOP w0.168: v2(66.82,124.1) UG1.G44 ; v2(66.2,143.28) VRAM3.T13
  IN4 w0.102: v2(66.82,124.1) 66.82,124.39 67.04,124.6 67.67,124.6 67.85,124.78 67.85,125.25 67.75,125.36 67.75,126.63 67.44,126.94 67.44,129.96 68.46,130.99 68.46,131.84
  IN4 w0.127: 68.46,131.84 68.46,139.66 66.57,141.55 66.57,142.91 v2(66.2,143.28)
FBB_EDC3: length 22.9
  TOP w0.168: VRAM3.T2 v2(58.7,143.28) ; UG1.H38 v2(62.5,124.3)
  IN2 w0.14: v2(58.7,143.28) 59.07,142.91 59.07,140.28 63.95,135.4 63.95,128.88 62.8,127.73 62.8,126.74 62.68,126.62 62.68,126.2 62.81,126.06 62.81,125.78 62.76,125.73 62.76,124.55 v2(62.5,124.3)
FBB_EDC4: length 30.6
  TOP w0.135: UG1.P50 71.59,120.09 72.74,120.09 v2(73.05,120.4)
  TOP w0.168: v2(81.5,144.03) 81.88,143.66 VRAM4.C2
  IN2 w0.14: v2(73.05,120.4) 73.26,120.62 74.29,120.62 75.72,122.05 75.72,122.78 78.2,125.25 78.2,128.47 79.75,130.03 79.75,138.25 81.88,140.37 81.88,143.66 v2(81.5,144.03)
FBB_EDC5: length 26.3
  TOP w0.168: UG1.J48 v2(70.2,123.6) ; VRAM4.C13 v2(74,144.03)
  IN2 w0.14: v2(70.2,123.6) 70.2,123.48 70.46,123.22 71.84,123.22 71.96,123.34 71.96,124.2 72.15,124.39 72.28,124.39 72.64,124.75 73.22,124.75 73.62,125.16 73.62,125.41 74.59,126.38 74.59,130 75.52,130.93 75.52,139.64 74.38,140.77 74.38,143.66 v2(74,144.03)
FBB_EDC6: length 29.7
  TOP w0.168: v2(72.3,127.15) 72.3,127.11 72.29,127.1 72.29,127.09 UG1.D51 ; v2(73.25,153.78) VRAM4.T13
  IN2 w0.14: v2(73.25,153.78) 72.88,153.41 72.88,152.84 72.69,152.66 72.18,152.66 71.6,152.07 71.6,150.97 71.28,150.65 71.28,148.2 71.05,147.97 71.05,146.05 71.76,145.34 71.76,140.88 71.99,140.65 71.99,129.78 71.68,129.48 71.68,128.37 71.96,128.09 71.96,127.47 72.28,127.15 v2(72.3,127.15)
FBB_EDC7: length 35.2
  TOP w0.128: 72.29,125.69 73.09,125.69 v2(73.14,125.63)
  TOP w0.168: v2(81.5,153.03) 81.88,153.41 VRAM4.T2 ; 72.29,125.69 UG1.F51
  IN4 w0.102: v2(73.14,125.63) 73.15,125.63 74.61,127.09 74.61,127.44 75.13,127.96 75.13,128.69
  IN4 w0.127: v2(81.5,153.03) 81.88,152.66 81.88,152.11 81.67,151.91 79.76,151.91 79.52,151.67 79.52,150.48 79.26,150.21 79.26,149.24 78.69,148.67 78.69,146.53 77.12,144.97 77.12,143.22 76.7,142.8 76.28,142.8 76.17,142.91 75.3,142.91 75.14,142.75 75.14,128.7 75.13,128.69
FBB_FB_TCK0: length 1.6
  TOP w0.102: VRAM3.N5 60.61,145.91 v2(60.99,145.53)
  BOTTOM w0.14: v2(60.99,145.53) 61.67,144.85 TPG33.1
FBB_FB_TDI0: length 3.4
  TOP w0.102: v2(62.84,149.99) 62.84,150.35 63.57,151.07 64.23,151.07 VRAM3.F10
  BOTTOM w0.14: TPG21.1 62.84,149.27 v2(62.84,149.99)
FBB_FB_TDO0: length 1.5
  TOP w0.102: VRAM3.N10 63.91,145.5 63.76,145.5 v2(63.76,145.5)
  BOTTOM w0.14: TPG31.1 63.79,145.57 63.79,145.53 v2(63.76,145.5)
FBB_FB_TMS0: length 1.8
  TOP w0.102: v2(61.33,151.59) 60.9,151.16 VRAM3.F5
  BOTTOM w0.14: TPG11.1 61.33,152.07 v2(61.33,151.59)
FBB_VREFC: length 74.2
  TOP w0.3: VRAM4.K1 83.12,148.91 v2(83.32,148.7)
  TOP w0.305: VRAM3.K1 57.46,148.16 v2(57.13,148.48)
  TOP w0.381: RG4.2 85.56,132.28 RG6.2 86.63,132.35 RG1.2 85.69,133.34 v1(85.44,133.09)
  IN2 w0.381: v1(85.44,133.09) 85.16,133.37 84.6,133.37 83.15,134.81 83.15,137.28 85.06,139.19 85.06,147.43 84.45,148.05 83.98,148.05 v2(83.32,148.7) 83.61,148.7 84.52,149.62 84.52,155.01 83.75,155.78 80.64,155.78 79.24,157.18 77.3,157.18 76.59,157.89 70.65,157.89 68.94,156.19 64.32,156.19 64.23,156.09 62.71,156.09 62.47,155.86 61.24,155.86 60.8,156.3 60.32,156.3 59.84,156.78 58.56,156.78 57.85,157.5 55.69,157.5 v1(54.99,156.8)
  IN4 w0.381: v1(54.99,156.8) 55.65,156.14 55.65,151.04 55.19,150.58 55.19,148.95 55.66,148.48 v2(57.13,148.48)
  BOTTOM w0.381: v2(57.13,148.48) 57.02,148.37 CG192.1
FBB_ZQ_1_A: length 1.2
  TOP w0.2: VRAM3.J14 67.36,148.91 v2(67.77,149.32)
  BOTTOM w0.254: v2(67.77,149.32) 67.79,149.33 RG84.1
FBB_ZQ_1_B: length 1.2
  TOP w0.2: v2(67.7,148.53) VRAM3.K14
  BOTTOM w0.254: RG90.1 67.84,148.39 v2(67.7,148.53)
FBB_ZQ_2_A: length 2.1
  TOP w0.3: VRAM4.J14 72.76,148.16 v2(72.44,148.48)
  BOTTOM w0.254: v2(72.44,148.48) 72.28,148.33 71.2,148.33 RG92.1
FBB_ZQ_2_B: length 2.1
  TOP w0.3: v2(72.5,149.28) 72.88,148.91 VRAM4.K14
  BOTTOM w0.254: RG81.1 71.28,149.34 72.45,149.34 v2(72.5,149.28)
FBC_CMD0: length 40.8
  TOP w0.102: 43.29,128.82 43.35,128.76 43.35,128.48 43.55,128.28 43.55,127.85 43.95,127.45 UG1.C11
  TOP w0.135: VRAM1.H3 28.45,149.65 v2(28.83,149.28)
  TOP w0.165: v2(25.55,150.49) 25.55,150.22 24.19,148.85 24.19,142.92 24,142.74 24,141.44 35.12,130.32 42.33,130.32 43.29,129.36 43.29,128.82
  IN1 w0.102: v2(25.55,150.49) 26.12,150.49 26.18,150.43 28.27,150.43 28.45,150.24 28.45,149.87 28.83,149.5 v2(28.83,149.28)
FBC_CMD1: length 37.4
  TOP w0.14: VRAM1.J3 v2(28.08,148.53) VRAM1.K3
  TOP w0.165: UG1.B11 43.95,128.37 43.59,128.73 43.59,129.46 42.47,130.59 35.63,130.59 24.5,141.71 24.5,148.45 25.04,148.99 25.74,148.99 v2(25.77,149.01)
  IN1 w0.102: v2(25.77,149.01) 25.86,148.91 27.7,148.91 v2(28.08,148.53)
FBC_CMD2: length 34.8
  TOP w0.135: 43.95,128.85 UG1.A11
  TOP w0.14: VRAM1.J1 26.58,149.28 v2(26.57,149.28)
  TOP w0.165: v2(26.57,149.28) 26.28,149 26.28,148.86 26.03,148.6 25.21,148.6 24.77,148.16 24.77,145.2 25.1,144.88 25.1,141.89 36.13,130.85 42.58,130.85 43.95,129.48 43.95,128.85
  BOTTOM w0.165: RG83.1 26.02,149.83 v2(26.57,149.28)
FBC_CMD3: length 37.9
  TOP w0.14: VRAM1.K4 v2(29.58,148.53) VRAM1.J4
  TOP w0.165: v2(25.53,146.96) 25.04,146.47 25.04,145.31 25.64,144.71 25.64,142.12 36.64,131.12 42.69,131.12 44.3,129.51 44.3,127.1 UG1.D11
  IN1 w0.102: v2(29.58,148.53) 29.36,148.32 28.97,148.17 27.34,148.17 26.88,148.07 26.28,148.07 26.22,148.01 v2(25.53,146.96)
FBC_CMD4: length 34.4
  TOP w0.135: VRAM1.L3 v2(28.83,147.78)
  TOP w0.165: UG1.A12 44.65,129.53 42.8,131.39 37.14,131.39 26.19,142.34 26.19,145.44 v2(25.43,146.19)
  IN2 w0.114: v2(28.83,147.78) 28.47,148.15 26.99,148.15 26.93,148.08 26.31,148.08 25.55,147.32 25.38,147.32 25.13,147.07 25.13,146.5 v2(25.43,146.19)
FBC_CMD5: length 28.9
  TOP w0.135: UG1.B12 44.65,128.15 44.65,128.36 44.97,128.69 44.97,129.3 44.96,129.32 44.96,129.61
  TOP w0.165: 44.96,129.61 42.91,131.65 38.21,131.65 30.22,139.64 30.22,140.89 30.78,141.45 30.78,145.87 30.38,146.27 29.59,146.27 VRAM1.M4
FBC_CMD6: length 31.2
  TOP w0.135: UG1.C12 44.65,127.45 44.65,127.66 45,128.01 45,128.35 45.21,128.56 45.21,129.73
  TOP w0.14: VRAM1.J5 30.27,148.6 30.27,148.47 VRAM1.K5
  TOP w0.165: 45.21,129.73 43.02,131.92 38.71,131.92 30.77,139.86 30.77,141.06 31.05,141.34 31.05,147.69 30.27,148.47
FBC_CMD7: length 34
  TOP w0.14: v2(30.59,149.92) 30.22,149.92 VRAM1.H5 ; v2(30.48,147.29) 30.07,147.29 VRAM1.L5
  TOP w0.165: v2(30.87,148.47) 30.87,148.25 31.31,147.8 31.31,140.09 39.22,132.19 43.16,132.19 45.47,129.87 45.47,129.13 45.48,129.13 45.48,128.52 45.69,128.31 45.69,128 45.92,127.77 45.92,127.58 UG1.C14
  IN2 w0.089: v2(30.59,149.92) 30.87,149.64 v2(30.87,148.47) 30.87,147.42 30.69,147.24 30.53,147.24 v2(30.48,147.29)
FBC_CMD8: length 32.6
  TOP w0.135: 43.19,132.47 43.23,132.47 45.73,129.97 45.73,128.71 46.05,128.39 46.05,128.15 UG1.B14
  TOP w0.165: 43.19,132.47 39.71,132.47 31.91,140.26 31.91,140.35 31.58,140.69 31.58,147.91 31.29,148.2 31.29,150.09 30.61,150.78 29.57,150.78 VRAM1.G4
FBC_CMD9: length 32
  TOP w0.165: UG1.A14 46.05,130.01 43.33,132.72 43.31,132.72 43.3,132.74 40.21,132.74 32.46,140.49 32.46,140.7 31.85,141.32 31.85,148.46 32.24,148.85 32.24,150.49 32.53,150.78 34.08,150.78 VRAM1.G11
FBC_CMD10: length 35.8
  TOP w0.135: 46.05,126.75 UG1.D14
  TOP w0.14: v2(32.97,146.31) 33.32,146.66 VRAM1.M10 ; VRAM1.G10 33.36,150.41 v2(33.23,150.28)
  TOP w0.165: v2(32.23,148.08) 32.23,147.38 32.11,147.26 32.11,141.61 32.87,140.85 40.72,133 43.41,133 43.42,132.99 43.44,132.99 46.4,130.03 46.4,127.1 46.05,126.75
  IN2 w0.089: v2(33.23,150.28) 32.33,148.12 v2(32.23,148.08) 32.35,148.03 v2(32.97,146.31)
  BOTTOM w0.165: RG86.2 32.55,148.33 32.3,148.08 v2(32.23,148.08)
FBC_CMD11: length 31
  TOP w0.14: VRAM1.L10 33.17,147.41 32.95,147.63 32.95,148.42 32.76,148.61 32.94,148.79 32.94,149.43 33.27,149.76 33.6,149.76 VRAM1.H10
  TOP w0.165: 32.76,148.61 32.63,148.48 32.63,147.08 32.38,146.83 32.38,142.11 41.22,133.27 43.52,133.27 43.53,133.25 43.56,133.25 46.67,130.14 46.67,128.93 UG1.A15
FBC_CMD12: length 27.2
  TOP w0.135: UG1.B15 46.75,128.34 47.07,128.67 47.07,129.13 46.99,129.21 ; VRAM1.M11 34.08,146.28 33.51,146.28 33.11,145.88 32.91,145.88 32.71,145.68 32.71,142.25 33.56,141.4
  TOP w0.165: 46.99,129.21 46.99,130.41 43.96,133.43 43.81,133.43 43.7,133.54 41.76,133.54 33.9,141.4 33.56,141.4
FBC_CMD13: length 28
  TOP w0.135: VRAM1.L12 35.18,147.41 v2(34.83,147.75) ; UG1.C15 46.75,127.64 47.1,127.99 47.1,128.35 47.31,128.56 47.31,129.33 47.36,129.37 47.36,129.52
  TOP w0.165: v2(37.11,147.75) 37.52,147.35 37.52,140.1 43.82,133.8 44.04,133.8 47.36,130.48 47.36,129.52
  IN2 w0.114: v2(34.83,147.75) 35.16,147.43 35.72,147.43 35.73,147.42 36.79,147.42 v2(37.11,147.75)
FBC_CMD14: length 32.5
  TOP w0.135: UG1.C17 48.15,127.64 47.79,127.99 47.79,128.26 47.54,128.51 47.54,129.16 47.64,129.25 47.64,129.36
  TOP w0.14: VRAM1.J11 34.33,148.91 34.12,148.7 v2(34.12,148.51) 34.12,148.32 34.28,148.16 VRAM1.K11
  TOP w0.165: v2(38.55,149.02) 38.02,149.02 37.71,148.71 37.71,147.53 38.06,147.18 38.06,140.32 47.64,130.75 47.64,129.36
  IN2 w0.114: v2(34.12,148.51) 34.54,148.93 38.46,148.93 v2(38.55,149.02)
FBC_CMD15: length 28.3
  TOP w0.14: VRAM1.J12 35.58,148.54 v2(35.58,148.53) 35.57,148.53 VRAM1.K12
  TOP w0.165: UG1.B17 48.15,128.37 47.81,128.71 47.81,128.99 47.97,129.14 47.97,131.19 38.61,140.55 38.61,147.42 38.58,147.44 v2(38.58,148.15)
  IN2 w0.114: v2(35.58,148.53) 35.95,148.15 v2(38.58,148.15)
FBC_CMD16: length 30
  TOP w0.11: UG1.B24 53.05,128.37 53.38,128.69 53.38,129.32
  TOP w0.135: v2(50.14,149.28) 50.51,149.66 VRAM2.L3
  TOP w0.165: 53.38,129.32 53.38,131.02 56.15,133.8 56.15,138.46 54.53,140.09 54.53,141.14 54.59,141.2 54.59,149.84 53.86,150.57 53.3,150.57 v2(53.04,150.83)
  IN1 w0.102: v2(50.14,149.28) 50.52,149.67 50.52,150.19 50.75,150.42 52.63,150.42 v2(53.04,150.83)
FBC_CMD17: length 27.8
  TOP w0.14: VRAM2.K3 50.51,148.91 50.88,148.54 50.88,148.53 v2(50.89,148.52) 50.88,148.52 50.51,148.16 VRAM2.J3
  TOP w0.165: v2(52.48,149.44) 53.12,149.44 53.64,149.97 53.96,149.97 54.26,149.67 54.26,147.61 54.2,147.55 54.2,141.36 53.98,141.14 53.98,139.86 55.61,138.24 55.61,133.75 53.05,131.19 UG1.A24
  IN1 w0.102: v2(52.48,149.44) 51.95,148.91 51.27,148.91 v2(50.89,148.52)
FBC_CMD18: length 26
  TOP w0.14: VRAM2.J1 v2(52.85,148.16)
  TOP w0.165: v2(52.85,148.16) 53.72,148.16 53.87,148.01 53.87,147.64 53.75,147.52 53.75,141.45 53.43,141.14 53.43,139.64 55.06,138.01 55.06,133.63 52.7,131.26 52.7,126.92 52.53,126.75 UG1.D23
  BOTTOM w0.165: v2(52.85,148.16) 53.27,147.74 RG93.1
FBC_CMD19: length 25.5
  TOP w0.14: VRAM2.J4 v2(49.39,148.53) VRAM2.K4
  TOP w0.165: UG1.A23 52.43,128.93 52.43,131.43 54.51,133.51 54.51,137.78 52.85,139.44 52.85,141.1 53.33,141.58 53.33,146.85 v2(52.4,147.78)
  IN1 w0.102: v2(52.4,147.78) 52.03,148.15 49.77,148.15 v2(49.39,148.53)
FBC_CMD20: length 24.3
  TOP w0.11: 52.17,129.49 52.17,129.1 52.04,128.98 52.04,128.67 52.35,128.36 52.35,128.15 UG1.B23
  TOP w0.135: v2(50.14,147.79) 50.14,147.78 VRAM2.H3
  TOP w0.165: v2(52.4,147.03) 52.61,147.03 52.93,146.71 52.93,141.56 52.71,141.34 52.5,141.34 52.31,141.15 52.31,139.22 53.97,137.56 53.97,133.42 52.17,131.62 52.17,129.49
  IN1 w0.102: v2(52.4,147.03) 52.39,147.03 51.99,147.43 50.49,147.43 50.14,147.78 v2(50.14,147.79)
FBC_CMD21: length 24.2
  TOP w0.11: 51.83,129.4 51.83,128.59 52.01,128.41 52.01,127.79 UG1.C23
  TOP w0.165: 51.83,129.4 51.83,131.68 53.42,133.28 53.42,137.33 49.37,141.38 49.24,141.38 48.63,141.99 48.63,143.14 48,143.76 48,144.73 48.26,144.98 48.26,146.51 48.77,147.02 49.4,147.02 VRAM2.G4
FBC_CMD22: length 25.7
  TOP w0.14: VRAM2.K5 48.86,148.91 v2(48.48,148.52) 48.84,148.16 VRAM2.J5
  TOP w0.165: UG1.C21 50.95,127.66 51.3,128.01 51.3,128.34 51.59,128.63 51.59,129.25 51.55,129.29 51.55,131.87 52.88,133.19 52.88,137 49.07,140.8 49.07,141.18 48.36,141.88 48.36,143.03 47.73,143.65 47.73,144.84 47.99,145.09 47.99,146.62 48.3,146.93 48.43,147.06 v2(48.43,147.42)
  IN2 w0.089: v2(48.43,147.42) 48.48,147.47 v2(48.48,148.52)
FBC_CMD23: length 26.3
  TOP w0.14: VRAM2.H5 48.13,148.29 48.06,148.51 48.04,148.62 48.14,148.79 VRAM2.L5
  TOP w0.165: UG1.B21 50.95,128.37 51.32,128.74 51.32,129.15 51.27,129.2 51.27,129.73 51.27,129.73 51.27,131.98 52.33,133.04 52.33,136.77 48.38,140.72 48.38,141.49 48.09,141.77 48.09,142.92 47.47,143.54 47.47,144.95 47.72,145.2 47.72,146.73 47.97,146.98 47.97,148.43 48.06,148.51
FBC_CMD24: length 25.6
  TOP w0.165: UG1.A21 50.95,132.2 51.78,133.03 51.78,136.54 47.83,140.5 47.83,142.81 47.2,143.43 47.2,145.06 47.46,145.31 47.46,146.84 47.68,147.07 47.68,148.18 47.67,148.2 47.67,149.51 47.92,149.77 48.53,149.77 48.8,150.03 49.39,150.03 VRAM2.M4
FBC_CMD25: length 29.9
  TOP w0.165: UG1.D20 50.61,127.11 50.61,132.32 51.24,132.94 51.24,136.32 47.28,140.27 47.28,142.97 46.93,143.32 46.93,145.17 47.19,145.42 47.19,146.95 47.42,147.18 47.42,148.07 47.4,148.09 47.4,150.76 46.85,151.3 46.39,151.3 46.05,150.97 45.62,150.97 45.43,150.78 44.89,150.78 VRAM2.M11
FBC_CMD26: length 36.3
  TOP w0.14: v2(45.75,150.53) 45.75,150.26 45.67,150.18 45.62,150.12 45.47,150.12 45.26,150.33 VRAM2.M10 ; v2(46.22,147.07) 46.22,146.65 46.11,146.54 45.38,146.54 VRAM2.G10
  TOP w0.165: UG1.A20 50.25,132.34 50.69,132.79 50.69,136.09 46.74,140.05 46.74,141.14 46.89,141.3 46.89,142.99 46.67,143.21 46.67,145.28 46.92,145.53 46.92,147.06 47.15,147.29 47.15,147.96 47.13,147.98 47.13,150.65 46.81,150.96 46.43,150.96 46.14,150.68 46.14,149.79 46.46,149.47 46.46,149.06 v2(46.43,149.03)
  IN2 w0.089: v2(45.75,150.53) 45.75,150.73 45.94,150.92 46.44,150.92 46.66,150.69 46.66,149.29 46.61,149.24 46.43,149.06 v2(46.43,149.03) 46.43,149 46.08,148.65 46.08,148.37 46,148.29 46,148.09 46.29,147.79 46.61,147.79 46.72,147.69 46.72,147.24 46.55,147.07 v2(46.22,147.07)
  BOTTOM w0.165: v2(46.43,149.03) 46.45,149.02 RG88.2
FBC_CMD27: length 27.1
  TOP w0.14: VRAM2.H10 45.8,147.41 46.03,147.65 46.03,148.83 46.03,148.83 46.03,149.52 45.79,149.76 45.37,149.76 VRAM2.L10
  TOP w0.165: 46.03,148.64 46.64,148.64 46.84,148.44 46.84,147.89 46.66,147.71 46.66,145.99 46.4,145.73 46.4,143.1 46.51,142.99 46.51,141.46 46.19,141.14 46.19,139.82 50.15,135.86 50.15,133.01 49.93,132.79 49.93,129.06 49.91,129.05 49.91,128.71 50.25,128.37 UG1.B20
FBC_CMD28: length 22.5
  TOP w0.102: UG1.C20 49.85,127.85 49.85,128.32 49.63,128.55 49.63,129.17 49.6,129.19 49.6,129.25
  TOP w0.165: 49.6,129.25 49.6,135.64 45.51,139.73 45.51,141 46.24,141.74 46.24,142.88 46.12,143 46.12,145.57 45.42,146.28 44.89,146.28 VRAM2.G11
FBC_CMD29: length 27.9
  TOP w0.135: v2(44.15,147.75) 44.09,147.7 44.09,147.7 43.81,147.41 VRAM2.H12 ; 49.05,133.8 49.35,133.5 49.35,129.15 49.41,129.09 49.41,128.49 49.2,128.29 49.2,128 48.85,127.65 UG1.C18
  TOP w0.165: 49.05,133.8 48.47,134.39 48.47,134.56 41.34,141.68 41.34,145.28 v2(40.66,145.95)
  IN1 w0.102: v2(44.15,147.75) 44.05,147.75 43.65,148.15 42,148.15 41.47,147.62 41.47,147.12 40.66,146.31 40.66,145.95 v2(40.66,145.95)
FBC_CMD30: length 28.9
  TOP w0.135: UG1.B18 48.85,128.39 49.17,128.72 49.17,128.99 49.05,129.11 49.05,132.88 48.13,133.8
  TOP w0.14: VRAM2.K12 43.57,148.72 v2(43.39,148.53) VRAM2.J12
  TOP w0.165: 48.13,133.8 47.92,134.01 47.92,134.33 40.79,141.46 40.79,144.42 40.21,145.01 40.21,146.3 40.48,146.58 41.16,146.58 41.58,147 41.58,147.45 41.23,147.8 v2(41.16,147.8)
  IN1 w0.102: v2(41.16,147.8) 41.27,147.9 41.27,148.5 41.66,148.89 43.03,148.89 v2(43.39,148.53)
FBC_CMD31: length 29.9
  TOP w0.14: VRAM2.J11 44.85,148.5 v2(44.85,148.53) 44.85,148.57 VRAM2.K11
  TOP w0.165: UG1.A18 48.8,128.9 48.8,132.35 47.23,133.92 47.23,134.25 40.25,141.23 40.25,144.13 39.79,144.58 39.79,147.29 41.13,148.62 v2(41.13,149)
  IN2 w0.102: v2(44.85,148.53) 44.63,148.53 44.26,148.16 42.47,148.16 42.22,148.42 42.22,148.75 42.05,148.92 41.21,148.92 v2(41.13,149)
FBC_CMD32: length 31.4
  TOP w0.135: v2(34.83,149.32) 35.17,149.66 VRAM1.H12 ; UG1.A17 48.22,128.92 48.22,131.71
  TOP w0.165: v2(38.51,150.42) 38.9,150.42 39.83,149.49 39.83,148.81 39.15,148.14 39.15,140.78 48.22,131.71
  IN2 w0.114: v2(38.51,150.42) 35.38,150.42 35.2,150.24 35.2,149.69 v2(34.83,149.32)
FBC_CMD33: length 32.4
  TOP w0.135: v2(44.14,149.28) VRAM2.L12
  TOP w0.165: v2(41.3,150.07) 41.01,150.07 40.44,149.5 40.44,148.58 39.47,147.62 39.47,144.05 39.7,143.82 39.7,141 46.68,134.02 46.68,133.81 48.49,132 48.49,127.09 UG1.D17
  IN2 w0.114: v2(44.14,149.28) 43.75,149.67 43.75,150.25 43.58,150.42 41.69,150.42 41.35,150.07 v2(41.3,150.07)
FBC_DBI0: length 41.5
  TOP w0.168: VRAM1.D2 v2(28.08,153.03) ; UG1.A5 v2(39.41,129.3)
  IN2 w0.14: v2(28.08,153.03) 27.7,153.41 25.33,153.41 23.14,151.22 23.14,149.41 22.31,148.58 22.31,144.57 23.17,143.7 23.17,137.42 31.07,129.52 35.66,129.52 35.94,129.24 37.1,129.24 37.24,129.09 37.75,129.09 37.92,128.92 38.75,128.92 39.13,129.3 v2(39.41,129.3)
FBC_DBI1: length 43
  TOP w0.168: UG1.C8 42.22,127.82 v2(42.23,127.82) ; v2(36.33,152.28) VRAM1.D13
  IN1 w0.127: v2(36.33,152.28) 35.95,151.91 34.64,151.91 34.47,151.73 34.47,151.17 34.07,150.78 32.42,150.78 31.33,149.69 31.33,146.7 31,146.36 29.99,146.36 29.49,146.86 28.37,146.86 28.26,146.76 27.29,146.76 26.95,146.42 26.95,142.18 26.76,141.99 26.76,141.35 27.77,140.34 28.43,140.34 36.88,131.89 39.56,131.89 41.89,129.56 42.37,129.56 42.53,129.4 42.53,128.92 42.62,128.84 42.62,128.22 42.23,127.83 v2(42.23,127.82)
FBC_DBI2: length 29.4
  TOP w0.168: v2(36.33,143.97) 35.95,144.35 VRAM1.R13 ; UG1.J18 48.54,122.94 v2(48.5,122.94)
  IN2 w0.14: v2(48.5,122.94) 48.49,122.94 48.12,123.31 48.12,123.93 48.01,124.04 48.01,124.57 48.12,124.68 48.12,125.93 48.03,126.03 48.03,126.62 48.38,126.97 48.38,130.09 40.89,137.58 37.76,137.58 36.7,138.63 36.7,143.6 v2(36.33,143.97)
FBC_DBI3: length 31.5
  TOP w0.168: UG1.F12 44.65,125.35 44.96,125.04 44.96,125.01 v2(44.96,125) ; v2(27.33,144.04) VRAM1.R2
  IN2 w0.14: v2(27.33,144.04) 27.33,143.88 27.7,143.51 27.7,142.27 27.82,142.16 30.48,142.16 31.02,141.62 31.02,138.27 35.04,134.26 39.51,134.26 44.22,129.54 44.22,126.86 44.51,126.57 44.51,126.11 44.74,125.88 44.96,125.01 v2(44.96,125)
FBC_DBI4: length 23.3
  TOP w0.168: v2(56.07,127.71) 56.07,127.49 56.42,126.88 UG1.D29 ; VRAM2.D2 51.46,144.61 v2(51.64,144.78)
  IN2 w0.14: v2(56.07,127.71) 56.6,128.24 56.6,128.94 56.1,129.44 56.1,132.48 49.76,138.82 49.76,144.26 49.92,144.41 51.26,144.41 51.35,144.5 51.46,144.61 v2(51.64,144.78)
FBC_DBI5: length 26.4
  TOP w0.168: VRAM2.D13 42.64,144.78 v2(42.6,144.78) ; v2(55.5,125.7) UG1.E27
  IN2 w0.14: v2(42.6,144.78) 42.97,144.42 42.97,143.88 43.16,143.68 43.96,143.68 43.98,143.66 44.32,143.66 44.51,143.48 44.51,141.59 54.12,131.97 54.12,130.63 54.6,130.14 54.6,128.76 55.25,128.11 55.25,127.45 54.95,127.15 54.95,126.89 55.18,126.66 55.18,126.02 v2(55.5,125.7)
FBC_DBI6: length 40.8
  TOP w0.168: v2(50.6,124.96) 50.57,124.96 UG1.F20 ; VRAM2.R13 v2(43.39,153.03)
  IN2 w0.14: v2(50.6,124.96) 50.57,124.96 50.25,125.29 50.25,130.68 41.61,139.32 39.85,139.32 38.69,140.48 38.69,144.72 38.4,145.01 38.4,147.07 38.96,147.63 38.96,149.29 39.2,149.54 39.2,150.88 40.51,152.19 40.51,153.78 40.95,154.22 42.36,154.22 42.41,154.17 42.89,154.17 43.01,154.04 43.01,153.41 v2(43.39,153.03)
FBC_DBI7: length 33.3
  TOP w0.168: v2(54.74,126.4) 54.74,126.34 UG1.E26 ; VRAM2.R2 v2(51.64,152.28)
  IN4 w0.102: v2(54.74,126.4) 54.74,126.42 54.4,126.76 54.4,128.01 54,128.42 53.61,128.42 52.24,129.79 52.24,131.84
  IN4 w0.127: v2(51.64,152.28) 51.26,151.91 51.26,151.33 51.09,151.16 49.98,151.16 49.76,150.94 49.76,147.33 49.5,147.07 49.38,146.99 49.12,146.73 48.3,146.73 47.86,146.29 47.86,145.73 47.14,145.01 47.14,140.48 52.24,135.39 52.24,131.84
FBC_DEBUG0: length 1.2
  TOP w0.109: v2(42.9,129.2) 42.9,129.2 UG1.A9
  BOTTOM w0.165: v2(42.9,129.2) 43.56,129.2 TPG37.1
FBC_DEBUG1: length 11.5
  TOP w0.109: 53.68,130.94 53.68,129.13 53.59,129.04 53.59,128.52 53.4,128.34 53.4,128.02 53.26,127.87 53.05,127.67 53.05,127.45 UG1.C24
  TOP w0.136: v2(57.17,131.63) 56.63,132.18 54.92,132.18 53.68,130.94
  BOTTOM w0.165: v2(57.17,131.63) 56.7,131.63 56.51,131.45 56.51,130.39 57.2,129.71 TPG39.1
FBC_EDC0: length 44.1
  TOP w0.168: v2(39.44,126.41) 39.75,126.72 UG1.D5 ; VRAM1.C2 v2(27.33,153.78)
  IN2 w0.14: v2(39.44,126.41) 39.07,126.78 39.07,127.96 38.89,128.14 38.28,128.14 38.17,128.24 37.56,128.24 37.38,128.06 36.69,128.06 36.47,128.28 36.23,128.28 35.67,128.84 30.96,128.84 22.63,137.17 22.63,143.48 21.76,144.34 21.76,148.81 22.6,149.64 22.6,151.47 25.29,154.16 26.95,154.16 v2(27.33,153.78)
FBC_EDC1: length 48.3
  TOP w0.168: UG1.D8 41.67,126.75 41.26,127.15 v2(41.26,127.36)
  TOP w0.216: v2(35.58,153.03) VRAM1.C13
  IN1 w0.127: v2(35.58,153.03) 35.2,153.41 35.2,154.71 34.97,154.94 33.82,154.94 33.65,155.1 32.9,155.1 30.45,152.66 26.38,152.66 24.91,151.18 24.91,145.32 25.28,144.95 25.28,140.28 31.45,134.11 32.45,134.11 35.98,130.59 38.84,130.59 40.13,129.3 40.13,129.09 41.26,127.95 v2(41.26,127.36)
FBC_EDC2: length 24.8
  TOP w0.122: UG1.E17 48.15,126.29 47.81,126.64 v2(47.81,127.09)
  TOP w0.168: v2(35.58,143.28) VRAM1.T13
  IN2 w0.14: v2(35.58,143.28) 35.95,142.91 35.95,138.62 37.53,137.03 40.66,137.03 47.8,129.9 47.8,127.09 v2(47.81,127.09)
FBC_EDC3: length 28.4
  TOP w0.168: v2(44.97,126.4) 44.96,126.39 44.96,126.36 44.65,126.05 UG1.E12 ; VRAM1.T2 v2(28.08,143.28)
  IN2 w0.14: v2(44.97,126.4) 44.97,126.6 44.64,126.92 44.64,129.89 39.73,134.8 35.83,134.8 31.57,139.07 31.57,141.84 30.51,142.91 28.45,142.91 v2(28.08,143.28)
FBC_EDC4: length 21.9
  TOP w0.168: VRAM2.C2 51.25,143.66 50.89,144.02 v2(50.89,144.03) ; UG1.E30 57.25,126.08 57.52,126.35 57.52,126.36 57.55,126.39 v2(57.55,126.4)
  IN2 w0.14: v2(50.89,144.03) 50.89,144.02 50.51,143.64 50.51,141.43 50.31,141.22 50.31,139.04 56.65,132.7 56.65,131.31 56.6,131.26 56.6,129.44 57.07,128.96 57.07,126.87 57.55,126.4 v2(57.55,126.4)
FBC_EDC5: length 24.1
  TOP w0.102: v2(54.62,131.32) 55.64,131.15 56.04,130.75 56.88,128.98 56.88,128.75 UG1.B29
  TOP w0.168: VRAM2.C13 43.38,144.03 v2(43.38,144.06)
  IN2 w0.14: v2(54.62,131.32) 54.85,131.55 54.85,132.04 45.28,141.61 45.28,144.22 45.07,144.44 43.76,144.44 v2(43.38,144.06)
FBC_EDC6: length 38.7
  TOP w0.168: UG1.G21 51.05,124.53 51.17,124.38 v2(51.37,124.34) ; v2(42.64,153.78) VRAM2.T13
  IN2 w0.14: v2(51.37,124.34) 51.19,124.34 51,124.53 51,125.89 50.87,126.35 50.87,130.83 41.84,139.86 40.87,139.86 39.23,141.5 39.23,144.95 38.95,145.24 38.95,147.06 39.36,147.48 39.36,148.31 39.82,148.77 39.82,149.94 39.75,150.02 39.75,150.58 39.96,150.79 40.61,150.79 41.24,151.42 41.24,153.09 41.58,153.43 42.28,153.43 42.35,153.5 42.46,153.61 v2(42.64,153.78)
FBC_EDC7: length 34
  TOP w0.168: UG1.E24 53.35,126.34 53.38,126.34 v2(53.41,126.37) ; VRAM2.T2 v2(50.89,153.03)
  IN4 w0.102: v2(53.41,126.37) 52.63,127.16 52.63,127.98 51.15,129.47 51.15,131.84
  IN4 w0.127: v2(50.89,153.03) 50.51,152.66 48.87,152.66 48.76,152.55 48.45,152.55 48.2,152.3 47.9,151.33 47.9,150.35 47.99,150.17 48.44,149.72 48.44,149.03 47.58,148.18 47.03,146.05 46.33,145.34 46.33,144.17 46.13,143.97 46.13,139.86 51.15,134.84 51.15,131.84
