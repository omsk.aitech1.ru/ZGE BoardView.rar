# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ12: length 76.9
  TOP w0.089: U3.BJ11 v1(155.62,111.07)
  TOP w0.102: v1(162.28,52.43) 162.39,52.43 162.95,51.88 162.95,51.44 162.82,51.31 JDIM1.42
  IN1 w0.079: 158.12,105.03 158.12,104.15 158.72,103.55 158.72,102.75 160.37,101.1 160.37,100.1 ; v1(155.62,111.07) 156.03,110.66 156.03,110.32 156.37,109.99 156.37,109.07 158.12,107.32 158.12,106.79
  IN1 w0.114: 158.12,105.03 158.12,106.79 ; v1(162.28,52.43) 162.37,52.43 163.4,53.46 163.4,55.8 163.65,56.05 163.65,64.8 163.43,65.02 163.43,82.45 163.31,82.57 162.76,82.57 162.65,82.68 162.65,82.91 162.76,83.03 163.31,83.03 163.43,83.14 163.43,83.37 163.31,83.48 162.76,83.48 162.65,83.6 162.65,83.83 162.76,83.94 163.31,83.94 163.43,84.05 163.43,84.28 163.31,84.4 162.76,84.4 162.65,84.51 162.65,84.74 162.76,84.86 163.31,84.86 163.43,84.97 163.43,85.2 163.31,85.31 162.76,85.31 162.65,85.43 162.65,85.66 162.76,85.77 163.31,85.77 163.43,85.88 163.43,86.11 163.31,86.23 162.76,86.23 162.65,86.34 162.65,86.57 162.76,86.68 163.31,86.68 163.43,86.8 163.43,87.03 163.31,87.14 162.76,87.14 162.65,87.26 162.65,87.48 162.76,87.6 163.23,87.6 163.35,87.71 163.35,87.93 163.22,88.06 162.76,88.06 162.65,88.17 162.65,88.51 162.76,88.63 163.07,88.63 163.18,88.74 163.18,88.97 163.07,89.08 162.76,89.08 162.65,89.2 162.65,89.62 161.84,90.44 161.84,95.74 160.37,97.21 160.37,100.1
  BOTTOM w0.102: v1(162.28,52.43) 162.22,52.43 161.93,52.15 161.93,51.53 162.17,51.29 JDIM3.37
M_B_DQ13: length 77.7
  TOP w0.089: v1(155.62,110.42) U3.BJ10
  TOP w0.102: v1(162.32,53.09) 162.41,53.09 163.82,51.68 JDIM1.38
  IN1 w0.079: 160.03,100.1 160.03,101.14 158.42,102.74 158.42,103.42 157.03,104.81 157.03,107.48 156.2,108.3 156.2,109.91 155.69,110.42 v1(155.62,110.42)
  IN1 w0.114: v1(162.32,53.09) 163.05,53.83 163.05,55.94 163.3,56.19 163.3,64.67 163.09,64.88 163.09,75.55 162.97,75.66 162.42,75.66 162.31,75.78 162.31,76.01 162.42,76.12 162.97,76.12 163.09,76.23 163.09,76.46 162.97,76.58 162.42,76.58 162.31,76.69 162.31,76.92 162.42,77.03 162.97,77.03 163.09,77.15 163.09,77.38 162.97,77.49 162.42,77.49 162.31,77.61 162.31,77.83 162.42,77.95 162.97,77.95 163.09,78.06 163.09,78.29 162.97,78.41 162.42,78.41 162.31,78.52 162.31,78.75 162.42,78.86 162.97,78.86 163.09,78.98 163.09,79.21 162.97,79.32 162.42,79.32 162.31,79.44 162.31,79.66 162.42,79.78 162.97,79.78 163.09,79.89 163.09,80.12 162.97,80.24 162.42,80.24 162.31,80.35 162.31,80.58 162.42,80.69 162.97,80.69 163.09,80.81 163.09,81.04 162.97,81.15 162.42,81.15 162.31,81.26 162.31,81.49 162.42,81.61 162.97,81.61 163.09,81.72 163.09,81.95 162.97,82.06 162.42,82.06 162.31,82.18 162.31,89.48 161.49,90.29 161.49,95.6 160.03,97.07 160.03,100.1
  BOTTOM w0.102: JDIM3.41 161.17,51.95 v1(162.32,53.09)
M_B_DQ14: length 73.9
  TOP w0.089: U3.BL7 v1(157.25,109.34)
  TOP w0.102: JDIM1.29 166.07,57.12 166.19,57 166.19,56.79 v1(165.84,56.44)
  IN1 w0.079: v1(157.25,109.34) 158.71,109.34 159.38,108.67 159.38,106.8
  IN1 w0.114: 159.38,106.8 159.38,105.49 161.96,102.91 166.78,102.91 168.87,100.82 168.87,97.28 164.52,92.93 164.52,65.61 164.74,65.39 164.74,59.61 164.85,59.5 165.53,59.5 165.66,59.37 165.66,59.16 165.54,59.04 164.85,59.04 164.74,58.93 164.74,58.7 164.85,58.58 165.53,58.58 165.66,58.46 165.66,58.24 165.54,58.13 164.85,58.13 164.74,58.01 164.74,57.78 164.85,57.67 165.53,57.67 165.66,57.55 165.66,57.33 165.54,57.21 164.85,57.21 164.74,57.1 164.74,56.65 164.96,56.44 v1(165.84,56.44)
  BOTTOM w0.102: JDIM3.24 165.42,56.86 v1(165.84,56.44)
M_B_DQ15: length 74.6
  TOP w0.089: U3.BJ7 v1(155.62,109.12)
  TOP w0.102: JDIM1.41 163.07,56.99 162.6,56.51 v1(162.33,56.51)
  IN1 w0.079: v1(155.62,109.12) 155.23,108.73 155.23,105.03 159.29,100.97 159.29,100.1
  IN1 w0.114: 159.29,100.1 159.29,96.83 160.81,95.31 160.81,89.51 161,89.32 161.5,89.32 161.62,89.2 161.62,88.9 161.51,88.78 160.92,88.78 160.81,88.67 160.81,88.44 160.92,88.33 161.51,88.33 161.62,88.21 161.62,87.87 161.51,87.75 160.92,87.75 160.81,87.64 160.81,87.41 160.92,87.3 161.51,87.3 161.62,87.18 161.62,86.95 161.51,86.84 160.92,86.84 160.81,86.73 160.81,86.5 160.92,86.38 161.51,86.38 161.62,86.27 161.62,86.04 161.51,85.93 160.92,85.93 160.81,85.81 160.81,85.58 160.92,85.47 161.51,85.47 161.62,85.35 161.62,85.01 161.5,84.89 160.92,84.89 160.81,84.77 160.81,84.54 160.92,84.43 161.51,84.43 161.62,84.32 161.62,84.1 161.5,83.97 160.92,83.97 160.81,83.86 160.81,83.63 160.92,83.52 161.51,83.52 161.62,83.4 161.62,83.18 161.5,83.06 160.92,83.06 160.81,82.94 160.81,82.72 160.92,82.6 161.51,82.6 161.62,82.49 161.62,82.27 161.5,82.14 160.92,82.14 160.81,82.03 160.81,81.8 160.92,81.69 161.51,81.69 161.62,81.57 161.62,81.35 161.5,81.23 160.92,81.23 160.81,81.12 160.81,80.89 160.92,80.77 161.51,80.77 161.62,80.66 161.62,80.44 161.5,80.32 160.92,80.32 160.81,80.2 160.81,79.98 160.92,79.87 161.51,79.87 161.62,79.75 161.62,66.44 162.4,65.66 162.4,56.58 v1(162.33,56.51)
  BOTTOM w0.102: JDIM3.38 161.92,56.92 v1(162.33,56.51)
M_B_DQ16: length 69.2
  TOP w0.089: v1(154.7,111.72) 154.57,111.72 U3.BG11
  TOP w0.102: v1(160.32,52.26) 160.49,52.26 160.82,51.93 JDIM1.50
  IN1 w0.079: 158.84,100.1 158.84,101.09 154.98,104.94 154.98,109.35 155.17,109.54 155.17,111.25 v1(154.7,111.72)
  IN1 w0.114: v1(160.32,52.26) 160.87,52.26 161.87,53.26 161.87,57.89 161.49,58.27 161.49,58.68 161.98,59.17 161.98,65.49 161.2,66.27 161.2,78.8 160.72,79.28 160.39,79.61 160.39,95.14 158.84,96.69 158.84,100.1
  BOTTOM w0.102: JDIM3.45 160.17,51.15 159.91,51.41 159.91,51.89 160.28,52.26 v1(160.32,52.26)
M_B_DQ17: length 70.8
  TOP w0.089: v1(153.79,111.07) 154.21,110.77 U3.BG10
  TOP w0.102: v1(160.37,52.93) 161.52,52.93 161.82,52.62 JDIM1.46
  IN1 w0.079: 157.09,99.78 157.09,101.51 154.72,103.88 154.72,107.86 154.47,108.11 154.47,109.42 154.27,109.62 154.27,110.59 v1(153.79,111.07)
  IN1 w0.114: v1(160.37,52.93) 161.34,53.9 161.34,57.56 160.94,57.96 160.94,59.59 161.64,60.29 161.64,65.35 160.86,66.13 160.86,78.66 160.05,79.47 160.05,95 157.09,97.95 157.09,99.78
  BOTTOM w0.102: JDIM3.49 159.17,51.41 158.84,51.74 158.84,52.35 159.15,52.67 159.4,52.67 159.66,52.93 v1(160.37,52.93)
M_B_DQ18: length 69.6
  TOP w0.089: v1(153.84,109.77) 153.93,109.77 U3.BG8
  TOP w0.102: JDIM1.45 162.07,57.38 161.49,56.8 161.49,55.29 161.21,55.01 160.68,55.01 v1(160.58,55.11)
  IN1 w0.079: v1(153.84,109.77) 153.84,109.72 154.22,109.34 154.22,107.87 154.42,107.67 154.42,103.94 156.75,101.61 156.75,99.44
  IN1 w0.114: v1(160.58,55.11) 160.99,55.53 160.99,57.04 160.52,57.52 160.52,76.78 160.4,76.89 159.82,76.89 159.71,77.01 159.71,77.23 159.83,77.36 160.3,77.36 160.41,77.47 160.41,77.7 160.3,77.82 159.82,77.82 159.71,77.93 159.71,78.15 159.83,78.27 160.3,78.27 160.41,78.39 160.41,78.62 160.3,78.73 159.82,78.73 159.7,78.84 159.7,94.86 156.75,97.81 156.75,99.44
  BOTTOM w0.102: JDIM3.50 158.92,57.41 159.33,57 159.33,56.04 160.26,55.11 v1(160.58,55.11)
M_B_DQ19: length 69.6
  TOP w0.089: U3.BF8 153.34,109.52 v1(152.91,109.82)
  TOP w0.102: v1(157.27,52.81) 157.42,52.81 158.82,51.4 JDIM1.58
  IN1 w0.079: 154.68,99.18 154.68,99.31 154.18,99.81 154.18,101.23 152.33,103.07 152.33,107.15 152.85,107.66 152.85,108.61 152.5,108.96 152.5,109.28 152.91,109.69 v1(152.91,109.82)
  IN1 w0.114: v1(157.27,52.81) 157.27,53.09 157.74,53.57 157.74,54.85 158,55.11 158,55.11 158.11,55.23 158.11,56.96 157.93,57.14 157.93,60.92 158.05,61.04 158.5,61.04 158.64,61.17 158.64,61.38 158.52,61.49 158.05,61.49 157.93,61.61 157.93,61.84 158.05,61.95 158.62,61.95 158.74,62.07 158.74,70.48 157.93,71.29 157.93,93.97 154.68,97.21 154.68,99.18
  BOTTOM w0.102: v1(157.27,52.81) 157.19,52.81 155.67,51.29 JDIM3.63
M_B_DQ20: length 69.8
  TOP w0.089: v1(153.81,111.74) 153.68,111.74 U3.BF11
  TOP w0.102: JDIM1.63 157.57,56.83 157.28,56.53 v1(157.24,56.53)
  IN1 w0.079: v1(153.81,111.74) 153.37,112.17 152.76,112.17 152.49,111.9 152.49,111.01 152.36,110.88 152.36,109.61 152.06,109.31 152.06,108.52 151.78,108.24 151.78,102.16 152.85,101.09 152.85,100.33
  IN1 w0.114: v1(157.24,56.53) 157.24,56.54 157.24,66.14 157.35,66.25 157.91,66.25 158.02,66.37 158.02,66.59 157.91,66.71 157.35,66.71 157.24,66.82 157.24,67.05 157.35,67.17 157.85,67.17 157.96,67.28 157.96,67.51 157.85,67.62 157.35,67.62 157.24,67.74 157.24,67.97 157.35,68.08 157.76,68.08 157.88,68.19 157.88,68.42 157.76,68.54 157.35,68.54 157.24,68.65 157.24,68.88 157.35,69 157.76,69 157.88,69.11 157.88,69.34 157.76,69.45 157.35,69.45 157.24,69.57 157.24,69.91 157.35,70.02 157.76,70.02 157.88,70.14 157.88,70.37 157.76,70.48 157.35,70.48 157.24,70.6 157.24,93.68 154,96.93 154,99.18 152.85,100.33
  BOTTOM w0.102: v1(157.24,56.53) 156.92,56.85 JDIM3.58
M_B_DQ21: length 71.3
  TOP w0.089: v1(152.87,111.15) 153.34,110.82 U3.BF10
  TOP w0.102: JDIM1.59 158.57,56.6 v1(157.24,55.27)
  IN1 w0.079: 153.12,100.4 153.12,101.1 151.95,102.27 151.95,108.03 152.29,108.37 152.29,109.3 152.53,109.54 152.53,110.81 v1(152.87,111.15)
  IN1 w0.114: v1(157.24,55.27) 157.77,55.8 157.77,56.82 157.59,57 157.59,62.29 157.7,62.41 158.19,62.41 158.3,62.52 158.3,62.74 158.18,62.87 157.7,62.87 157.59,62.98 157.59,63.21 157.7,63.32 158.19,63.32 158.3,63.44 158.3,63.66 158.18,63.78 157.7,63.78 157.59,63.89 157.59,64.12 157.7,64.24 158.19,64.24 158.3,64.35 158.3,64.57 158.18,64.69 157.7,64.69 157.59,64.81 157.59,65.11 157.72,65.24 158.12,65.24 158.39,65.52 158.39,70.33 157.58,71.15 157.58,93.83 154.34,97.07 154.34,99.18 153.12,100.4
  BOTTOM w0.102: v1(157.24,55.27) 156.15,56.37 156.15,57.28 155.92,57.5 JDIM3.62
M_B_DQ22: length 67.1
  TOP w0.089: U3.BG7 153.93,109.12 v1(153.84,109.12)
  TOP w0.102: v1(160.58,56.47) 160.58,56.76 161.07,57.25 JDIM1.49
  IN1 w0.079: v1(153.84,109.12) 153.84,107.86 154.17,107.53 154.17,103.87 156.41,101.64 156.41,99.18
  IN1 w0.114: v1(160.58,56.47) 160.58,56.74 160.17,57.15 160.17,71.69 160.07,71.79 159.45,71.79 159.36,71.88 159.36,72.21 159.48,72.32 160.06,72.32 160.17,72.43 160.17,72.66 160.06,72.78 159.5,72.78 159.36,72.91 159.36,73.12 159.48,73.23 160.06,73.23 160.17,73.35 160.17,73.58 160.06,73.69 159.5,73.69 159.36,73.83 159.36,74.03 159.48,74.15 160,74.15 160.11,74.26 160.11,74.49 160,74.61 159.5,74.61 159.36,74.74 159.36,74.95 159.48,75.06 160,75.06 160.11,75.18 160.11,75.41 160,75.52 159.5,75.52 159.36,75.65 159.36,75.86 159.48,75.98 160,75.98 160.11,76.09 160.11,76.32 160,76.43 159.5,76.43 159.36,76.57 159.36,94.71 156.41,97.67 156.41,99.18
  BOTTOM w0.102: v1(160.58,56.47) 159.92,57.12 JDIM3.46
M_B_DQ23: length 67.8
  TOP w0.089: U3.BF7 v1(152.88,109.12)
  TOP w0.102: v1(157.27,52.17) 157.35,52.17 157.82,51.69 JDIM1.62
  IN1 w0.079: v1(152.88,109.12) 152.88,108.94 153.07,108.75 153.07,107.59 152.71,107.22 152.71,103.12 154.38,101.45 154.38,100.03 155.02,99.38 155.02,99.18
  IN1 w0.114: v1(157.27,52.17) 158.46,53.36 158.46,57.1 158.28,57.29 158.28,58.32 158.39,58.43 158.8,58.43 158.91,58.55 158.91,58.77 158.79,58.89 158.39,58.89 158.28,59 158.28,59.35 158.39,59.46 158.73,59.46 158.86,59.59 158.86,59.8 158.71,59.94 158.41,59.94 158.28,60.08 158.28,60.29 158.39,60.4 158.97,60.4 159.08,60.51 159.08,70.62 158.27,71.43 158.27,94.11 155.02,97.36 155.02,99.18
  BOTTOM w0.102: v1(157.27,52.17) 156.67,51.58 JDIM3.59
M_B_DQ24: length 70
  TOP w0.089: U3.BB11 v1(150.14,111.72)
  TOP w0.102: v1(152.02,56.58) 152.57,57.14 JDIM1.83
  IN1 w0.114: v1(150.14,111.72) 148.84,110.42 148.84,108.92 148.48,108.56 147.9,108.56 147.32,107.98 147.32,98.57 150.4,95.49 150.4,95.2 153.67,91.93 153.67,79.03 152.46,77.82 152.46,64.5 150.4,62.44 150.4,62.1 150.51,61.98 150.89,61.98 151,61.87 151,61.64 150.89,61.53 150.51,61.53 150.4,61.41 150.4,61.18 150.51,61.07 150.87,61.07 150.98,60.95 150.98,60.73 150.87,60.61 150.51,60.61 150.4,60.5 150.4,60.27 150.51,60.15 150.87,60.15 150.98,60.04 150.98,59.81 150.87,59.7 150.51,59.7 150.4,59.58 150.4,59.35 150.51,59.24 150.87,59.24 150.98,59.12 150.98,58.9 150.87,58.78 150.51,58.78 150.4,58.67 150.4,57.7 151.51,56.58 v1(152.02,56.58)
  BOTTOM w0.102: JDIM3.80 151.42,57.18 v1(152.02,56.58)
M_B_DQ25: length 69.9
  TOP w0.089: v1(151.99,111.1) 151.69,111.4 U3.BC11
  TOP w0.102: JDIM1.70 155.82,51.76 v1(155.25,52.34)
  IN1 w0.079: 152.52,101.08 151.61,101.99 151.61,108.42 151.79,108.61 151.79,109.4 151.58,109.61 151.58,110.69 v1(151.99,111.1)
  IN1 w0.114: 152.52,101.08 152.52,100.2 153.58,99.15 153.58,96.75 156.82,93.51 156.82,66.37 156.71,66.26 156.34,66.26 156.23,66.14 156.23,65.91 156.34,65.8 156.71,65.8 156.82,65.68 156.82,65.46 156.71,65.34 156.34,65.34 156.23,65.23 156.23,65 156.34,64.88 156.71,64.88 156.82,64.77 156.82,64.54 156.71,64.43 156.34,64.43 156.23,64.31 156.23,64.08 156.34,63.97 156.71,63.97 156.82,63.86 156.82,55.24 155.89,54.31 155.89,52.97 v1(155.25,52.34)
  BOTTOM w0.102: v1(155.25,52.34) 154.97,52.05 154.97,51.7 154.67,51.4 JDIM3.67
M_B_DQ26: length 70.3
  TOP w0.089: v1(150.09,109.77) 150.54,109.45 U3.BB8
  TOP w0.102: JDIM1.80 153.32,52.28 v1(152.09,53.52)
  IN1 w0.114: v1(150.09,109.77) 149.48,109.17 149.48,108.66 148.82,108 148.82,98.19 151.3,95.71 151.3,95.27 154.36,92.22 154.36,77.97 153.14,76.76 153.14,63.55 153.03,63.44 152.77,63.44 152.65,63.32 152.65,63.11 152.78,62.98 153.03,62.98 153.14,62.87 153.14,62.64 153.03,62.52 152.77,62.52 152.65,62.41 152.65,62.19 152.78,62.07 153.03,62.07 153.14,61.95 153.14,61.72 153.03,61.61 152.77,61.61 152.65,61.5 152.65,61.28 152.78,61.15 153.03,61.15 153.14,61.04 153.14,55.74 152.5,55.09 152.5,53.93 v1(152.09,53.52)
  BOTTOM w0.102: JDIM3.83 150.67,51.67 151.25,52.54 151.62,53.05 v1(152.09,53.52)
M_B_DQ27: length 69.7
  TOP w0.089: U3.BC8 151.47,109.45 v1(151.02,109.77)
  TOP w0.102: v1(155.24,55.26) 156.12,56.15 156.37,56.46 156.45,56.72 156.45,57.16 156.57,57.28 JDIM1.67
  IN1 w0.079: v1(151.02,109.77) 151.02,109.69 151.45,109.26 151.45,108.82 151.21,108.57 151.21,101.51 151.99,100.73
  IN1 w0.114: 151.99,100.73 151.99,99.79 152.89,98.89 152.89,96.47 156.14,93.23 156.14,72.09 156.02,71.97 155.65,71.97 155.53,71.86 155.53,71.63 155.65,71.51 156.02,71.51 156.14,71.4 156.14,71.17 156.02,71.06 155.65,71.06 155.53,70.94 155.53,70.6 155.65,70.49 155.95,70.49 156.07,70.36 156.07,70.14 155.96,70.03 155.65,70.03 155.53,69.91 155.53,69.69 155.65,69.57 155.96,69.57 156.07,69.46 156.07,69.23 155.96,69.11 155.65,69.11 155.53,69 155.53,68.66 155.65,68.54 155.98,68.54 156.09,68.43 156.09,68.2 155.98,68.09 155.65,68.09 155.53,67.97 155.53,62.95 156.14,62.35 156.14,59.72 155.27,58.86 155.27,57.58 155.71,57.15 155.71,55.73 v1(155.24,55.26)
  BOTTOM w0.102: v1(155.24,55.26) 154.96,55.43 154.86,55.53 154.62,55.85 154.35,56.17 153.92,56.6 JDIM3.70
M_B_DQ28: length 70.8
  TOP w0.089: v1(151.05,111.11) 151.15,111.11 U3.BC10
  TOP w0.102: JDIM1.66 156.82,51.26 156.4,51.68 156.4,52.35 155.77,52.99 v1(155.29,52.99)
  IN1 w0.079: 152.22,100.93 151.41,101.74 151.41,108.53 151.62,108.73 151.62,109.33 151.41,109.54 151.41,110.75 v1(151.05,111.11)
  IN1 w0.114: 152.22,100.93 152.22,100.04 153.23,99.03 153.23,96.61 156.48,93.37 156.48,67.74 156.36,67.63 155.99,67.63 155.87,67.51 155.87,67.29 155.99,67.17 156.36,67.17 156.48,67.06 156.48,66.83 156.36,66.71 155.99,66.71 155.87,66.6 155.87,63.09 156.03,62.94 156.36,62.94 156.48,62.82 156.48,55.82 155.29,54.63 v1(155.29,52.99)
  BOTTOM w0.102: JDIM3.71 153.67,51.73 154.93,52.99 v1(155.29,52.99)
M_B_DQ29: length 72
  TOP w0.089: U3.BB10 150.62,110.77 150.62,111 150.5,111.12 150.18,111.12 v1(150.14,111.07)
  TOP w0.102: JDIM1.79 153.57,57.44 153.4,57.27 153.4,56.39 152.35,55.34 v1(151.92,55.34)
  IN1 w0.114: v1(150.14,111.07) 149.22,110.16 149.22,108.91 148.57,108.27 148.05,108.27 147.64,107.85 147.64,98.77 150.96,95.45 150.96,95.13 154.01,92.07 154.01,78.53 152.8,77.31 152.8,64.36 151.61,63.17 151.61,58.6 151.73,58.48 152.41,58.48 152.53,58.37 152.53,58.16 152.4,58.04 151.74,58.04 151.61,57.91 151.61,57.51 152.05,57.07 152.6,57.07 152.8,56.87 152.8,56.22 v1(151.92,55.34)
  BOTTOM w0.102: v1(151.92,55.34) 150.59,56.67 150.59,57.35 150.42,57.51 JDIM3.84
M_B_DQ30: length 66.4
  TOP w0.089: U3.BC7 151.47,108.8 v1(151.05,109.1)
  TOP w0.102: v1(155.17,56.49) 155.36,56.49 155.57,56.71 JDIM1.71
  IN1 w0.079: 151.18,99.91 150.15,100.94 150.15,107.78 151.05,108.69 v1(151.05,109.1)
  IN1 w0.114: v1(155.17,56.49) 154.74,56.92 154.74,59.85 154.85,59.96 155.63,59.96 155.74,60.07 155.74,60.3 155.63,60.42 154.78,60.42 154.66,60.54 154.66,60.76 154.78,60.87 155.63,60.87 155.74,60.99 155.74,61.22 155.63,61.33 154.78,61.33 154.66,61.45 154.66,61.67 154.78,61.79 155.63,61.79 155.74,61.9 155.74,62.13 155.63,62.25 154.89,62.25 154.78,62.36 154.78,62.59 155.19,63 155.19,72.32 155.79,72.92 155.79,92.89 152.55,96.14 152.55,98.75 151.39,99.91 151.18,99.91
  BOTTOM w0.102: JDIM3.66 154.92,56.73 v1(155.17,56.49)
M_B_DQ31: length 67.9
  TOP w0.089: U3.BB7 150.27,109.12 v1(150.08,109.12)
  TOP w0.102: JDIM1.84 152.32,51.97 v1(152.09,52.2)
  IN1 w0.114: v1(152.09,52.2) 152.98,53.1 152.98,55.09 153.49,55.6 153.49,67.84 153.6,67.95 153.75,67.95 153.86,68.07 153.86,68.29 153.75,68.41 153.6,68.41 153.49,68.52 153.49,68.75 153.6,68.87 153.75,68.87 153.86,68.98 153.86,69.21 153.75,69.32 153.6,69.32 153.49,69.44 153.49,69.67 153.6,69.78 153.75,69.78 153.86,69.89 153.86,70.12 153.75,70.24 153.6,70.24 153.49,70.35 153.49,70.58 153.6,70.69 153.75,70.69 153.86,70.81 153.86,71.04 153.75,71.15 153.6,71.15 153.49,71.27 153.49,71.49 153.6,71.61 153.75,71.61 153.86,71.72 153.86,71.95 153.75,72.07 153.6,72.07 153.49,72.18 153.49,76.34 154.7,77.56 154.7,92.36 151.64,95.41 151.64,95.83 149.16,98.31 149.16,107.84 149.89,108.57 149.89,108.92 v1(150.08,109.12)
  BOTTOM w0.102: JDIM3.79 151.67,51.79 v1(152.09,52.2)
M_B_DQ32: length 74.2
  TOP w0.089: U3.AA11 v1(133.68,111.72)
  TOP w0.102: v1(124.16,52.25) 124.59,51.83 124.59,51.68 124.82,51.44 JDIM1.186
  IN1 w0.079: v1(133.68,111.72) 133.17,111.22 133.17,110.07 133.26,109.98 133.26,109.64 132.84,109.22 132.84,108.85 132.27,108.28 132.27,103.11 129.21,100.04 129.21,97.51
  IN1 w0.114: v1(124.16,52.25) 123.68,51.76 123.24,51.76 122.77,52.23 122.77,57.2 120.97,59 120.97,59.36 121.33,59.73 121.33,61.12 121.22,61.23 120.98,61.23 120.87,61.34 120.87,61.57 120.98,61.69 121.22,61.69 121.33,61.8 121.33,66.86 121.22,66.97 120.98,66.97 120.87,67.09 120.87,67.32 120.98,67.43 121.22,67.43 121.33,67.55 121.33,68.51 120.96,68.88 120.96,73.15 121.99,74.18 121.99,87.64 126.13,91.78 126.13,94.44 129.21,97.51
  BOTTOM w0.102: v1(124.16,52.25) 123.87,52.25 123.67,52.06 JDIM3.183
M_B_DQ33: length 76
  TOP w0.089: U3.AA10 133.86,111.02 v1(133.72,111.02)
  TOP w0.102: JDIM1.183 125.57,55.79 124.69,54.91 v1(124.2,54.91)
  IN1 w0.079: 129.4,97.34 129.4,99.98 132.44,103.03 132.44,108.21 133.01,108.78 133.01,109.15 133.43,109.57 133.43,110.05 133.34,110.14 133.34,110.64 v1(133.72,111.02)
  IN1 w0.114: v1(124.2,54.91) 123.91,54.62 123.31,54.62 123.12,54.81 123.12,57.44 121.68,58.88 121.68,68.79 121.56,68.91 121.42,68.91 121.3,69.02 121.3,69.25 121.42,69.36 121.56,69.36 121.68,69.48 121.68,69.71 121.56,69.82 121.42,69.82 121.3,69.93 121.3,70.16 121.42,70.28 121.56,70.28 121.68,70.39 121.68,70.62 121.56,70.73 121.42,70.73 121.3,70.85 121.3,71.08 121.42,71.19 121.82,71.19 121.98,71.34 121.98,71.53 121.86,71.65 121.42,71.65 121.3,71.76 121.3,71.99 121.42,72.11 121.89,72.11 122.02,72.24 122.02,72.43 121.89,72.56 121.42,72.56 121.3,72.68 121.3,72.91 121.42,73.02 121.56,73.02 121.68,73.13 121.68,73.38 122.33,74.04 122.33,87.5 126.48,91.64 126.48,94.42 129.4,97.34
  BOTTOM w0.102: JDIM3.186 122.92,55.82 123.83,54.91 v1(124.2,54.91)
M_B_DQ34: length 74.7
  TOP w0.089: v1(135.5,111.71) 135.19,111.4 U3.AC11
  TOP w0.102: JDIM1.170 128.82,53.32 128.37,53.78 127.75,53.78 v1(127.54,53.57)
  IN1 w0.079: v1(135.5,111.71) 135.83,111.38 135.83,110.85 135.43,110.45 135.43,108.35 134.48,107.41 134.48,102.11 131.65,99.28 131.65,99.01
  IN1 w0.114: 131.65,99.01 131.65,96.52 129.3,94.17 129.3,90.49 125.95,87.15 125.95,83.15 125.59,82.78 125.59,70.45 124.62,69.49 124.62,60.62 125.26,59.97 125.26,59.75 126.58,58.44 126.8,58.44 127.96,57.27 127.96,53.72 127.81,53.57 v1(127.54,53.57)
  BOTTOM w0.102: JDIM3.173 126.17,52.33 126.49,52.65 126.49,53.55 126.82,53.88 127.24,53.88 v1(127.54,53.57)
M_B_DQ35: length 73.9
  TOP w0.089: v1(134.6,111.06) 134.6,111.06 134.91,110.75 U3.AC10
  TOP w0.102: v1(127.52,55.01) 128.13,55.01 128.6,55.49 128.6,56.86 129.07,57.33 JDIM1.169
  IN1 w0.079: 131.07,98.79 131.07,99.21 134.15,102.29 134.15,107.62 134.98,108.44 134.98,110.68 134.6,111.06 v1(134.6,111.06)
  IN1 w0.114: 131.07,98.79 131.07,96.7 128.61,94.24 128.61,90.78 124.9,87.06 124.9,76.1 124.79,75.98 124.57,75.98 124.45,75.87 124.45,75.65 124.58,75.53 124.79,75.53 124.9,75.41 124.9,75.18 124.79,75.07 124.57,75.07 124.45,74.95 124.45,74.73 124.57,74.61 124.79,74.61 124.9,74.5 124.9,74.27 124.79,74.15 124.57,74.15 124.45,74.04 124.45,73.81 124.57,73.7 124.79,73.7 124.9,73.58 124.9,70.74 123.94,69.77 123.94,59.89 126.45,57.37 126.45,55.75 126.9,55.3 126.9,55.02 127.02,54.91 127.42,54.91 v1(127.52,55.01)
  BOTTOM w0.102: v1(127.52,55.01) 127.12,55.01 125.92,56.21 JDIM3.174
M_B_DQ36: length 73.1
  TOP w0.089: U3.AA7 134.13,108.85 133.75,109.13 v1(133.76,109.12)
  TOP w0.102: v1(124.16,53.52) 125.31,52.37 125.31,51.81 125.82,51.3 125.82,51.3 JDIM1.182
  IN1 w0.079: v1(133.76,109.12) 133.76,108.97 132.78,107.98 132.78,102.86 129.8,99.88 129.8,97.02
  IN1 w0.114: v1(124.16,53.52) 124.72,54.07 124.72,56.99 122.5,59.21 122.5,70.36 123.02,70.88 123.02,76.71 123.13,76.82 123.35,76.82 123.47,76.93 123.47,77.16 123.35,77.28 123.13,77.28 123.02,77.39 123.02,77.62 123.13,77.73 123.35,77.73 123.47,77.85 123.47,78.08 123.35,78.19 123.13,78.19 123.02,78.31 123.02,78.53 123.13,78.65 123.35,78.65 123.47,78.76 123.47,78.99 123.35,79.11 123.13,79.11 123.02,79.22 123.02,79.45 123.13,79.56 123.35,79.56 123.47,79.68 123.47,79.91 123.35,80.02 123.13,80.02 123.02,80.13 123.02,80.36 123.13,80.48 123.35,80.48 123.47,80.59 123.47,80.82 123.35,80.94 123.13,80.94 123.02,81.05 123.02,81.39 123.47,81.84 123.47,87.66 127.16,91.36 127.16,94.39 129.8,97.02
  BOTTOM w0.102: JDIM3.187 122.67,51.38 122.9,51.6 122.9,52.53 123.88,53.52 v1(124.16,53.52)
M_B_DQ37: length 72.1
  TOP w0.089: v1(133.72,110.38) 133.66,110.31 133.66,109.92 U3.AA8
  TOP w0.102: JDIM1.187 124.57,57.43 124.75,57.25 124.75,56.6 124.36,56.21 v1(124.21,56.21)
  IN1 w0.079: v1(133.72,110.38) 133.72,109.63 133.26,109.16 133.26,108.74 132.61,108.08 132.61,102.95 129.62,99.96 129.62,97.21
  IN1 w0.114: v1(124.21,56.21) 123.95,55.95 123.73,55.95 123.46,56.22 123.46,57.6 122.02,59.04 122.02,70.37 122.68,71.03 122.68,71.87 122.56,71.98 122.48,71.98 122.37,72.1 122.37,72.33 122.48,72.44 122.56,72.44 122.68,72.56 122.68,72.78 122.56,72.9 122.13,72.9 122.02,73.01 122.02,73.24 122.13,73.36 122.56,73.36 122.68,73.47 122.68,81.71 122.83,81.87 123.01,81.87 123.12,81.98 123.12,82.21 123.01,82.32 122.79,82.32 122.68,82.44 122.68,82.67 122.79,82.78 123.01,82.78 123.12,82.9 123.12,83.12 123.01,83.24 122.79,83.24 122.68,83.35 122.68,83.58 122.79,83.7 123.01,83.7 123.12,83.81 123.12,84.04 123.01,84.15 122.79,84.15 122.68,84.27 122.68,84.5 122.79,84.61 123.01,84.61 123.12,84.72 123.12,84.95 123.01,85.07 122.79,85.07 122.68,85.18 122.68,85.41 122.79,85.52 123.01,85.52 123.12,85.64 123.12,85.87 123.01,85.98 122.79,85.98 122.68,86.1 122.68,86.32 122.79,86.44 123.01,86.44 123.12,86.55 123.12,86.78 123.01,86.9 122.79,86.9 122.68,87.01 122.68,87.31 122.83,87.46 122.97,87.46 123.12,87.61 123.12,87.8 123.37,88.05 126.82,91.5 126.82,94.41 129.62,97.21
  BOTTOM w0.102: v1(124.21,56.21) 124.16,56.21 123.77,56.6 123.77,57.38 123.92,57.53 JDIM3.182
M_B_DQ38: length 70.4
  TOP w0.089: U3.AC8 135.11,109.45 135.44,109.78 135.44,111.04 v1(135.45,111.05)
  TOP w0.102: JDIM1.173 128.07,57.36 128.04,57.33 128.04,56.47 127.88,56.31 v1(127.52,56.31)
  IN1 w0.079: v1(135.45,111.05) 135.45,111.22 135.28,111.39 135.1,111.39 135.02,111.31 135.02,110.95 135.21,110.76 135.21,108.4 134.32,107.51 134.32,102.21 131.38,99.27 131.38,98.86
  IN1 w0.114: 131.38,98.86 131.38,96.63 128.96,94.21 128.96,90.64 125.24,86.92 125.24,86.58 125.36,86.46 125.5,86.46 125.61,86.35 125.61,86.12 125.5,86.01 125.36,86.01 125.24,85.89 125.24,85.66 125.36,85.55 125.5,85.55 125.61,85.44 125.61,85.21 125.5,85.09 125.36,85.09 125.24,84.98 125.24,84.75 125.36,84.64 125.5,84.64 125.61,84.52 125.61,84.29 125.5,84.18 125.36,84.18 125.24,84.06 125.24,83.83 125.36,83.72 125.5,83.72 125.61,83.61 125.61,83.38 125.5,83.26 125.36,83.26 125.24,83.15 125.24,70.59 124.28,69.63 124.28,60.11 127.11,57.28 127.11,56.72 v1(127.52,56.31)
  BOTTOM w0.102: v1(127.52,56.31) 127.39,56.31 126.92,56.78 JDIM3.170
M_B_DQ39: length 69.9
  TOP w0.089: U3.AC7 134.79,108.8 v1(134.59,108.6)
  TOP w0.102: v1(127.54,52.33) 127.79,52.33 127.98,52.14 127.98,51.26 127.82,51.1 JDIM1.174
  IN1 w0.079: 130.78,98.72 130.78,99.17 133.98,102.37 133.98,107.99 v1(134.59,108.6)
  IN1 w0.114: v1(127.54,52.33) 126.56,53.31 126.56,55.16 125.89,55.83 125.89,57.37 123.59,59.66 123.59,69.91 124.11,70.43 124.11,70.88 124.23,70.99 124.44,70.99 124.56,71.11 124.56,71.33 124.44,71.45 124.23,71.45 124.11,71.56 124.11,71.79 124.23,71.91 124.44,71.91 124.56,72.02 124.56,72.25 124.44,72.36 124.23,72.36 124.11,72.48 124.11,72.71 124.23,72.82 124.44,72.82 124.56,72.94 124.56,73.16 124.44,73.28 124.23,73.28 124.11,73.39 124.11,76.03 124.56,76.48 124.56,87.21 128.27,90.92 128.27,94.25 130.78,96.76 130.78,98.72
  BOTTOM w0.102: JDIM3.169 127.17,51.29 126.97,51.5 126.97,52.07 127.23,52.33 v1(127.54,52.33)
M_B_DQ40: length 76
  TOP w0.089: v1(131.86,109.77) 131.98,109.77 U3.W8
  TOP w0.102: v1(122.24,53.52) 122.62,53.9 123.54,53.9 123.69,53.75 123.69,53.54 123.59,53.44 123.2,53.44 123.1,53.34 123.1,53.15 123.21,53.04 123.59,53.04 123.69,52.93 123.69,51.47 123.82,51.33 JDIM1.190
  IN1 w0.079: 128.32,97.66 128.32,100 131.75,103.43 131.75,108.47 132.26,108.98 132.26,109.25 131.86,109.65 v1(131.86,109.77)
  IN1 w0.114: 128.32,97.66 125.03,94.37 125.03,92.24 120.88,88.1 120.88,78.19 119.86,77.16 119.86,70.74 119.76,70.64 119.76,58.56 120.74,57.58 120.74,56.84 121.28,56.29 121.28,53.81 121.57,53.52 v1(122.24,53.52)
  BOTTOM w0.102: JDIM3.195 120.67,52.55 120.78,52.65 121.43,52.65 121.54,52.76 121.54,52.96 121.43,53.06 120.78,53.06 120.67,53.16 120.67,53.36 120.83,53.52 v1(122.24,53.52)
M_B_DQ41: length 71.4
  TOP w0.089: v1(131.85,109.12) U3.W7
  TOP w0.102: JDIM1.194 122.82,51.23 122.91,51.32 122.91,51.84 122.52,52.23 v1(122.29,52.23)
  IN1 w0.079: 128.09,99.24 128.09,100.03 131.58,103.51 131.58,108.62 131.85,108.89 v1(131.85,109.12)
  IN1 w0.114: v1(122.29,52.23) 121.36,51.3 120.62,51.3 120.22,51.7 120.22,52.72 120.94,53.44 120.94,56.15 120.39,56.69 120.39,57.44 119.42,58.41 119.42,70.79 119.51,70.88 119.51,77.3 120.54,78.33 120.54,88.24 124.69,92.38 124.69,94.32 128.09,97.73 128.09,99.24
  BOTTOM w0.102: JDIM3.191 121.67,51.73 122.17,52.23 v1(122.29,52.23)
M_B_DQ42: length 74.7
  TOP w0.089: v1(130.93,111.07) U3.V10
  TOP w0.102: v1(119.22,53.55) 119.44,53.55 120.32,52.66 JDIM1.204
  IN1 w0.079: v1(130.93,111.07) 130.59,110.73 130.59,110.04 130.53,109.99 130.53,109.51 130.35,109.32 130.35,108.31 129.97,107.93 129.97,104.75 129.63,104.4 129.63,103.7 125.62,99.7 125.62,99.53
  IN1 w0.114: v1(119.22,53.55) 118.81,53.55 118.63,53.37 118.63,52.95 118.41,52.73 118.09,52.73 117.89,52.93 117.89,57.41 117.64,57.66 117.64,62.53 117,63.17 117,70.88 117.73,71.62 117.73,81.23 118.76,82.26 118.76,88.98 122.89,93.1 122.89,94.51 125.62,97.25 125.62,99.53
  BOTTOM w0.102: v1(119.22,53.55) 117.67,52 JDIM3.207
M_B_DQ43: length 74.2
  TOP w0.089: U3.V11 v1(130.93,111.72)
  TOP w0.102: v1(119.24,52.27) 119.61,52.27 119.77,52.11 119.77,51.55 119.32,51.11 JDIM1.208
  IN1 w0.079: v1(130.93,111.72) 130.52,111.31 130.52,110.98 130.42,110.88 130.42,110.11 130.37,110.06 130.37,109.58 130.18,109.39 130.18,108.38 129.76,107.96 129.76,104.89 129.4,104.53 129.4,103.69 125.33,99.62 125.33,99.33
  IN1 w0.114: v1(119.24,52.27) 118.43,51.46 117.9,51.46 117.55,51.81 117.55,57.27 117.3,57.52 117.3,62.39 116.65,63.03 116.65,71.02 117.39,71.76 117.39,81.38 118.42,82.4 118.42,89.12 122.55,93.24 122.55,94.51 125.33,97.3 125.33,99.33
  BOTTOM w0.102: JDIM3.203 118.67,51.26 118.45,51.48 118.45,51.83 118.92,52.3 119.21,52.3 v1(119.24,52.27)
M_B_DQ44: length 74.3
  TOP w0.089: v1(131.85,111.72) U3.W11
  TOP w0.102: JDIM1.195 122.57,57.34 122.8,57.12 122.8,56.38 122.64,56.22 122.34,56.22 v1(122.29,56.27)
  IN1 w0.079: v1(131.85,111.72) 131.5,111.72 131.27,111.96 131.27,112.19 131.38,112.3 132.18,112.3 132.33,112.15 132.33,111.01 132.41,110.93 132.41,110.3 132.44,110.27 132.44,109.59 132.61,109.42 132.61,108.85 132.08,108.33 132.08,103.16 129.01,100.09 129.01,97.66
  IN1 w0.114: 129.01,97.66 125.72,94.36 125.72,91.96 121.57,87.81 121.57,77.47 121.46,77.36 121.02,77.36 120.85,77.19 120.85,77.02 120.97,76.9 121.46,76.9 121.57,76.79 121.57,76.56 121.46,76.44 120.68,76.44 120.55,76.32 120.55,76.1 120.67,75.99 121.46,75.99 121.57,75.87 121.57,74.36 121.03,73.82 120.68,73.82 120.54,73.68 120.54,70.46 120.45,70.36 120.45,69.96 120.54,69.87 120.54,69.43 120.45,69.33 120.45,68.38 120.56,68.26 120.79,68.26 120.9,68.15 120.9,67.92 120.79,67.81 120.56,67.81 120.45,67.69 120.45,64.62 120.56,64.5 120.8,64.5 120.91,64.39 120.91,64.16 120.8,64.04 120.56,64.04 120.45,63.93 120.45,63.7 120.45,58.91 121.55,57.81 121.55,56.99 122.27,56.27 v1(122.29,56.27)
  BOTTOM w0.102: JDIM3.190 121.92,57.42 121.8,57.29 121.8,56.52 122.04,56.27 v1(122.29,56.27)
M_B_DQ45: length 76.6
  TOP w0.089: v1(131.85,111.07) U3.W10
  TOP w0.102: JDIM1.191 123.57,54.69 123.33,54.44 122.77,54.44 v1(122.29,54.93)
  IN1 w0.079: v1(131.85,111.07) 132.03,111.07 132.23,110.86 132.23,110.25 132.28,110.21 132.28,109.47 132.42,109.32 132.42,108.91 131.91,108.4 131.91,103.31 128.77,100.17 128.77,97.76
  IN1 w0.114: 128.77,97.76 125.37,94.36 125.37,92.1 121.23,87.95 121.23,78.05 120.21,77.03 120.21,75.66 120.32,75.55 121.11,75.55 121.23,75.43 121.23,75.2 121.11,75.09 120.32,75.09 120.21,74.97 120.21,74.75 120.32,74.63 120.74,74.63 120.88,74.49 120.88,74.28 120.78,74.17 120.32,74.17 120.2,74.05 120.2,70.6 120.1,70.5 120.1,58.77 121.21,57.67 121.21,56.85 121.62,56.44 121.62,55.39 122.08,54.93 v1(122.29,54.93)
  BOTTOM w0.102: JDIM3.194 120.92,54.78 121.11,54.6 121.96,54.6 v1(122.29,54.93)
M_B_DQ46: length 70.9
  TOP w0.089: v1(130.91,109.11) 131.36,108.8 U3.V7
  TOP w0.102: v1(119.22,56.39) 119.34,56.39 119.8,56.85 119.8,57.22 119.57,57.44 JDIM1.207
  IN1 w0.079: 126.87,97.8 126.87,99.53 130.26,102.92 130.26,103.09 130.08,103.27 130.08,103.8 130.32,104.04 130.9,104.04 131.06,104.21 131.06,108.04 130.91,108.19 v1(130.91,109.11)
  IN1 w0.114: 126.87,97.8 123.57,94.51 123.57,92.82 119.45,88.69 119.45,81.98 118.42,80.95 118.42,80.61 118.53,80.49 119.34,80.49 119.45,80.38 119.45,80.18 119.3,80.03 118.53,80.03 118.42,79.92 118.42,79.69 118.53,79.58 119.34,79.58 119.45,79.46 119.45,79.23 119.34,79.12 118.53,79.12 118.42,79.01 118.42,78.78 118.53,78.66 118.88,78.66 119,78.55 119,78.33 118.87,78.21 118.53,78.21 118.42,78.09 118.42,71.33 118.33,71.24 118.33,64.83 118.21,64.71 117.8,64.71 117.68,64.6 117.68,64.37 117.8,64.26 118.21,64.26 118.33,64.14 118.33,63.91 118.21,63.8 117.8,63.8 117.68,63.69 117.68,63.46 117.8,63.34 118.21,63.34 118.33,63.23 118.33,57.94 118.8,57.46 118.8,56.64 119.06,56.39 v1(119.22,56.39)
  BOTTOM w0.102: v1(119.22,56.39) 118.42,57.18 JDIM3.204
M_B_DQ47: length 73.7
  TOP w0.089: U3.V8 131.07,109.77 v1(130.92,109.77)
  TOP w0.102: v1(119.2,55.76) 119.6,55.76 120.57,56.73 JDIM1.203
  IN1 w0.079: 126.05,99.64 126.05,99.89 129.86,103.7 129.86,104.25 130.21,104.61 130.21,107.93 130.52,108.24 130.52,109.25 130.92,109.65 v1(130.92,109.77)
  IN1 w0.114: v1(119.2,55.76) 119.05,55.61 118.58,55.61 118.23,55.95 118.23,57.55 117.98,57.8 117.98,62.67 117.34,63.31 117.34,66.97 117.45,67.08 117.87,67.08 117.98,67.19 117.98,67.42 117.87,67.54 117.45,67.54 117.34,67.65 117.34,67.88 117.45,67.99 117.87,67.99 117.98,68.11 117.98,68.34 117.87,68.45 117.45,68.45 117.34,68.57 117.34,68.79 117.45,68.91 117.87,68.91 117.98,69.02 117.98,69.25 117.87,69.37 117.45,69.37 117.34,69.48 117.34,69.71 117.45,69.82 117.87,69.82 117.98,69.94 117.98,70.17 117.87,70.28 117.45,70.28 117.34,70.39 117.34,70.74 117.49,70.89 117.84,70.89 117.98,71.04 117.98,71.38 118.08,71.48 118.08,81.09 119.11,82.12 119.11,88.83 123.23,92.96 123.23,94.53 125.89,97.18 125.89,98.43 126,98.55 126.35,98.55 126.46,98.66 126.46,98.89 126.35,99 126,99 125.89,99.12 125.89,99.48 126.05,99.64
  BOTTOM w0.102: JDIM3.208 117.42,57.54 v1(119.2,55.76)
M_B_DQ48: length 76.8
  TOP w0.089: v1(129.1,111.8) 129.15,111.8 U3.R11
  TOP w0.102: JDIM1.215 117.57,56.64 117.16,56.22 v1(116.91,56.22)
  IN1 w0.079: v1(129.1,111.8) 129.26,111.97 129.69,111.97 129.89,111.77 129.89,111.62 129.63,111.36 129.63,110.27 130.01,109.89 130.01,108.45 129.56,108 129.56,105.06 129.17,104.67 129.17,103.69 124.95,99.47 124.95,99.23
  IN1 w0.114: v1(116.91,56.22) 116.42,56.22 116.23,56.41 116.23,57.69 116.35,57.8 116.76,57.8 116.88,57.92 116.88,58.14 116.76,58.26 116.35,58.26 116.23,58.37 116.23,58.6 116.35,58.72 116.76,58.72 116.88,58.83 116.88,59.06 116.76,59.17 116.35,59.17 116.23,59.29 116.23,59.52 116.35,59.63 116.76,59.63 116.88,59.75 116.88,59.97 116.76,60.09 116.35,60.09 116.23,60.2 116.23,60.43 116.35,60.55 116.76,60.55 116.88,60.66 116.88,60.89 116.76,61 116.35,61 116.23,61.12 116.23,61.35 116.35,61.46 116.76,61.46 116.88,61.57 116.88,61.8 116.76,61.92 116.35,61.92 116.23,62.03 116.23,71.2 116.97,71.93 116.97,74.81 116.83,74.95 116.49,74.95 116.37,75.07 116.37,75.29 116.48,75.41 116.86,75.41 116.97,75.52 116.97,75.72 116.86,75.84 116.38,75.84 116.27,75.95 116.27,76.17 116.39,76.29 116.86,76.29 116.97,76.41 116.97,76.64 116.86,76.75 116.56,76.75 116.44,76.87 116.44,77.09 116.56,77.21 116.86,77.21 116.97,77.32 116.97,81.55 118,82.58 118,89.29 122.13,93.42 122.13,94.5 124.95,97.33 124.95,99.23
  BOTTOM w0.102: JDIM3.212 116.42,56.47 116.68,56.22 v1(116.91,56.22)
M_B_DQ49: length 76.9
  TOP w0.089: U3.P11 v1(128.19,111.72)
  TOP w0.102: v1(113.64,53.04) 115.32,51.36 JDIM1.224
  IN1 w0.079: 119.59,95.37 120.01,95.37 122.36,97.72 122.36,101.14 123.19,101.96 123.85,101.96 125.73,103.84 125.91,103.84 126.47,104.39 126.47,107.9 127.39,108.82 127.39,109.91 127.65,110.17 127.65,111.19 127.71,111.25 127.71,112.02 127.79,112.09 127.9,112.09 128.19,111.8 v1(128.19,111.72)
  IN1 w0.114: v1(113.64,53.04) 113.64,53.76 113.46,53.95 112.67,53.95 112.48,54.14 112.48,54.36 112.89,54.77 112.89,54.99 112.46,55.41 112.46,57.58 112.3,57.74 111.98,57.74 111.87,57.86 111.87,58.2 112.02,58.36 112.27,58.36 112.38,58.47 112.38,60.8 111.8,61.38 111.8,72.89 112.38,73.47 112.38,81.41 114.75,83.78 114.75,90.53 119.59,95.37
  BOTTOM w0.102: v1(113.64,53.04) 113.5,53.04 112.64,52.18 112.64,51.67 112.17,51.2 JDIM3.229
M_B_DQ50: length 72.4
  TOP w0.089: v1(128.17,109.12) 128.63,108.8 U3.P7
  TOP w0.102: v1(113.61,52.41) 113.99,52.41 114.32,52.07 JDIM1.228
  IN1 w0.079: 119.94,94.4 123.12,97.58 123.12,99.02 127.23,103.13 127.23,107.95 127.96,108.67 127.96,108.92 v1(128.17,109.12)
  IN1 w0.114: v1(113.61,52.41) 114.06,52.85 114.06,57.3 113.53,57.83 113.53,68.55 113.66,68.67 113.66,69.38 113.53,69.51 113.53,70.99 113.18,71.34 113.18,71.55 113.53,71.9 113.53,73.75 114.06,74.28 114.06,77.57 113.94,77.68 113.75,77.68 113.63,77.79 113.63,78.02 113.75,78.14 113.94,78.14 114.06,78.25 114.06,78.59 113.94,78.71 113.65,78.71 113.53,78.82 113.53,79.05 113.65,79.17 113.94,79.17 114.06,79.28 114.06,79.51 113.94,79.62 113.65,79.62 113.53,79.74 113.53,79.97 113.65,80.08 113.94,80.08 114.06,80.19 114.06,80.42 113.94,80.54 113.65,80.54 113.53,80.65 113.53,81.11 115.63,83.21 115.88,83.46 115.88,90.18 119.94,94.24 119.94,94.4
  BOTTOM w0.102: JDIM3.225 113.17,51.31 112.85,51.64 112.85,51.93 113.32,52.41 v1(113.61,52.41)
M_B_DQ51: length 75.6
  TOP w0.089: U3.R8 129.36,109.45 v1(129.12,109.21)
  TOP w0.102: v1(116.91,53.52) 117.48,54.1 118.17,54.1 118.32,53.95 JDIM1.212
  IN1 w0.079: v1(129.12,109.21) 129.58,108.75 129.58,108.49 128.79,107.7 128.79,103.76 124.29,99.26 124.29,99.06
  IN1 w0.114: 124.29,99.06 124.29,97.37 121.44,94.52 121.44,93.7 117.32,89.58 117.32,82.86 116.29,81.83 116.29,81.59 116.18,81.49 115.94,81.49 115.82,81.37 115.82,81.14 115.94,81.03 116.17,81.03 116.29,80.91 116.29,80.68 116.17,80.57 116.05,80.57 115.94,80.45 115.94,80.23 116.05,80.11 116.17,80.11 116.29,80 116.29,79.77 116.17,79.65 116.05,79.65 115.94,79.54 115.94,79.31 116.05,79.2 116.17,79.2 116.29,79.08 116.29,78.85 116.17,78.74 116.05,78.74 115.94,78.63 115.94,77.56 115.5,77.12 115.5,55.33 116.31,54.51 116.31,53.68 116.46,53.52 v1(116.91,53.52)
  BOTTOM w0.102: v1(116.91,53.52) 116.7,53.73 116.26,54.17 115.83,54.17 115.67,54.01 115.67,52.96 115.9,52.74 115.9,51.93 115.67,51.71 JDIM3.215
M_B_DQ52: length 75.4
  TOP w0.089: v1(129.1,111.15) 129.23,111.15 129.56,110.82 U3.R10
  TOP w0.102: v1(116.89,55.54) 117.36,55.54 118.57,56.76 JDIM1.211
  IN1 w0.079: v1(129.1,111.15) 129.25,111.15 129.46,110.94 129.46,110.1 129.81,109.74 129.81,108.49 129.25,107.92 129.25,105.3 128.99,105.05 128.99,103.73 124.64,99.38 124.64,99.17
  IN1 w0.114: 124.64,99.17 124.64,97.36 121.78,94.5 121.78,93.56 117.66,89.44 117.66,82.72 116.63,81.69 116.63,77.77 115.89,77.03 115.89,74.59 116,74.47 116.52,74.47 116.63,74.36 116.63,74.14 116.5,74.02 116,74.02 115.89,73.9 115.89,73.67 116,73.56 116.51,73.56 116.63,73.45 116.63,73.22 116.51,73.1 116,73.1 115.89,72.99 115.89,72.76 116,72.65 116.51,72.65 116.63,72.53 116.63,72.3 116.51,72.19 116,72.19 115.89,72.07 115.89,71.9 116.08,71.71 116.08,71.52 115.89,71.34 115.89,56.22 116.13,55.98 116.13,55.8 115.94,55.61 115.94,55.37 116.18,55.13 116.48,55.13 v1(116.89,55.54)
  BOTTOM w0.102: JDIM3.216 115.42,57.4 116.07,56.75 116.07,55.94 116.46,55.54 v1(116.89,55.54)
M_B_DQ53: length 76.7
  TOP w0.089: v1(128.19,111.07) U3.P10
  TOP w0.102: JDIM1.225 115.07,55.91 114.68,55.52 113.71,55.52 v1(113.61,55.62)
  IN1 w0.079: 119.82,95.11 120.04,95.11 122.52,97.59 122.52,101.07 123.21,101.75 123.97,101.75 125.87,103.65 126.01,103.65 126.67,104.32 126.67,107.86 127.56,108.75 127.56,109.82 127.82,110.08 127.82,110.98 127.91,111.07 v1(128.19,111.07)
  IN1 w0.114: v1(113.61,55.62) 113.33,55.34 113.03,55.34 112.83,55.53 112.83,57.74 112.57,58 112.57,58.17 112.81,58.41 112.81,61.29 112.67,61.43 112.29,61.43 112.15,61.57 112.15,64.67 112.29,64.81 112.5,64.81 112.62,64.93 112.62,65.23 112.45,65.4 112.26,65.4 112.15,65.51 112.15,65.74 112.36,65.95 112.36,66.17 112.15,66.39 112.15,69.34 112.85,70.04 112.85,70.7 112.49,71.06 112.49,71.31 112.39,71.42 112.31,71.42 112.15,71.58 112.15,71.75 112.3,71.9 112.52,71.9 112.7,72.08 112.7,72.24 112.58,72.36 112.26,72.36 112.15,72.47 112.15,72.75 112.31,72.91 112.69,72.91 112.81,73.03 112.81,75.67 113,75.86 113.19,75.86 113.37,76.04 113.37,76.67 113.21,76.83 112.92,76.83 112.81,76.94 112.81,81.35 115.09,83.64 115.09,90.39 119.82,95.11
  BOTTOM w0.102: JDIM3.228 112.42,57.57 112.6,57.4 112.6,55.61 112.81,55.4 113.39,55.4 v1(113.61,55.62)
M_B_DQ54: length 70
  TOP w0.089: v1(129.09,108.55) 129.32,108.55 U3.R7
  TOP w0.102: JDIM1.216 117.32,51.21 117.45,51.34 117.45,51.64 v1(116.87,52.23)
  IN1 w0.079: 123.87,99.04 123.87,99.09 128.59,103.81 128.59,107.78 129.09,108.29 v1(129.09,108.55)
  IN1 w0.114: 123.87,99.04 123.87,97.3 121.09,94.52 121.09,93.84 116.97,89.72 116.97,83.01 115.15,81.19 115.15,80.84 115.27,80.73 115.44,80.73 115.56,80.61 115.56,80.39 115.44,80.27 115.27,80.27 115.15,80.16 115.15,79.93 115.27,79.81 115.41,79.81 115.53,79.69 115.53,79.47 115.42,79.36 115.27,79.36 115.15,79.24 115.15,79.01 115.27,78.9 115.43,78.9 115.55,78.79 115.55,78.56 115.43,78.44 115.27,78.44 115.15,78.33 115.15,78.11 115.27,78 115.43,78 115.55,77.88 115.55,77.65 115.42,77.53 115.27,77.53 115.15,77.41 115.15,55.19 115.97,54.37 115.97,53.13 116.03,53.07 v1(116.87,52.23)
  BOTTOM w0.102: JDIM3.211 116.67,51.12 116.45,51.34 116.45,51.81 v1(116.87,52.23)
M_B_DQ55: length 74.1
  TOP w0.089: U3.P8 128.48,109.45 v1(128.15,109.77)
  TOP w0.102: JDIM1.229 114.07,57.34 114.64,56.77 114.64,56.18 114.44,55.97 114.02,55.97 v1(113.6,56.38)
  IN1 w0.079: v1(128.15,109.77) 127.73,109.35 127.73,108.68 127.08,108.03 127.08,103.2 122.81,98.93 122.81,97.59 119.96,94.74
  IN1 w0.114: 119.96,94.74 115.44,90.22 115.44,83.5 113.19,81.25 113.19,77.51 113.71,76.99 113.71,75.58 113.56,75.43 113.3,75.43 113.19,75.31 113.19,75.09 113.51,74.77 113.51,74.31 113.19,73.99 113.19,72.05 112.83,71.69 112.83,71.2 113.19,70.84 113.19,69.88 112.74,69.43 112.74,69.27 112.86,69.16 113.13,69.16 113.24,69.04 113.24,68.88 113.06,68.7 112.62,68.7 112.49,68.57 112.49,68.36 112.6,68.24 113.04,68.24 113.15,68.13 113.15,67.9 113.04,67.79 112.6,67.79 112.49,67.67 112.49,67.45 112.61,67.32 113,67.32 113.12,67.21 113.12,66.99 113,66.87 112.61,66.87 112.49,66.75 112.49,66.53 112.6,66.41 113.03,66.41 113.17,66.28 113.17,66.07 113.05,65.96 112.83,65.96 112.72,65.84 112.72,65.61 112.83,65.5 113.07,65.5 113.19,65.39 113.19,63 112.49,62.3 112.49,62.12 113.19,61.42 113.19,57.34 113.17,57.34 113.17,56.53 113.33,56.38 v1(113.6,56.38)
  BOTTOM w0.102: v1(113.6,56.38) 113.6,56.21 113.38,55.99 112.95,55.99 112.8,56.15 112.8,56.86 113.42,57.48 JDIM3.224
M_B_DQ56: length 79.5
  TOP w0.089: v1(125.48,111.74) 125.9,111.42 U3.L11
  TOP w0.102: JDIM1.250 108.82,51.02 109.36,51.55 109.36,51.97 v1(108.94,52.38)
  IN1 w0.079: v1(125.48,111.74) 124.59,110.85 124.59,109.87 122.93,108.21 122.93,107.78 122.55,107.41
  IN1 w0.114: 122.55,107.41 121.79,106.65 120.59,106.65 120.2,106.25 119.97,106.03 115.3,106.03 113.64,104.37 112.93,104.37 112.53,103.97 112.53,103.26 111.12,101.85 111.12,85.22 108.2,82.3 108.2,81.83 108.05,81.68 107.73,81.68 107.61,81.57 107.61,81.3 107.84,81.07 108.08,81.07 108.2,80.96 108.2,80.73 108.08,80.61 107.54,80.61 107.43,80.5 107.43,80.27 107.54,80.16 108.06,80.16 108.18,80.04 108.18,79.81 108.06,79.7 107.54,79.7 107.43,79.58 107.43,53.89 v1(108.94,52.38)
  BOTTOM w0.102: JDIM3.245 108.17,51.22 108.05,51.35 108.05,51.81 108.65,52.42 108.88,52.42 108.92,52.38 v1(108.94,52.38)
M_B_DQ57: length 80.2
  TOP w0.089: v1(126.36,111.72) 126.49,111.72 U3.M11
  TOP w0.102: v1(112.04,56.2) 112.2,56.2 112.47,56.48 112.47,57.1 112.07,57.5 JDIM1.237
  IN1 w0.079: 123.42,102.29 123.87,102.29 125.6,104.02 125.85,104.02 126.27,104.44 126.27,107.93 127.19,108.85 127.19,109.86 126.89,110.16 126.89,110.89 126.83,110.95 126.83,112.08 126.77,112.14 126.54,112.14 126.36,111.97 v1(126.36,111.72)
  IN1 w0.114: v1(112.04,56.2) 111.88,56.2 111.38,56.7 111.38,56.97 111.6,57.19 111.6,57.53 111.38,57.75 111.38,58.31 111.65,58.58 111.65,58.82 111.42,59.05 111.42,59.17 111.63,59.38 111.83,59.38 111.96,59.51 111.96,60.63 111.38,61.21 111.38,73.29 111.5,73.41 111.73,73.41 111.84,73.52 111.84,73.75 111.73,73.87 111.5,73.87 111.38,73.98 111.38,74.24 111.5,74.36 111.85,74.36 111.96,74.47 111.96,74.7 111.85,74.81 111.5,74.81 111.38,74.93 111.38,75.14 111.5,75.26 111.85,75.26 111.96,75.37 111.96,76.52 111.85,76.63 111.5,76.63 111.38,76.74 111.38,76.97 111.5,77.09 111.85,77.09 111.96,77.2 111.96,77.43 111.85,77.54 111.5,77.54 111.38,77.66 111.38,77.92 111.52,78.06 111.84,78.06 111.96,78.18 111.96,80.69 111.62,81.03 111.62,81.25 112.05,81.68 114.33,83.96 114.33,100.6 116.6,102.87 121.08,102.87 121.58,102.37 121.58,102.05 121.71,101.92 122.01,101.92 122.12,102.02 122.12,102.18 122.23,102.29 123.42,102.29
  BOTTOM w0.102: v1(112.04,56.2) 111.27,56.97 111.27,57.4 111.42,57.55 JDIM3.232
M_B_DQ58: length 76.4
  TOP w0.089: v1(125.51,109.13) 125.85,108.8 U3.L7
  TOP w0.102: JDIM1.249 109.07,57.49 109.67,56.9 109.67,56.48 109.24,56.04 v1(108.94,56.04)
  IN1 w0.079: v1(125.51,109.13) 125.49,109.15 124.72,109.15 123.52,107.95 123.52,106.92
  IN1 w0.114: 123.52,106.92 121.59,105 115.72,105 112.15,101.43 112.15,84.8 109.26,81.91 109.26,75.78 108.95,75.47 108.57,75.47 108.46,75.35 108.46,72.81 108.57,72.7 108.87,72.7 109.05,72.51 109.05,72.35 108.93,72.24 108.57,72.24 108.46,72.12 108.46,71.9 108.57,71.78 109.05,71.78 109.16,71.67 109.16,71.44 109.05,71.32 108.57,71.32 108.46,71.21 108.46,70.98 108.57,70.87 109.05,70.87 109.16,70.75 109.16,70.52 109.05,70.41 108.57,70.41 108.46,70.3 108.46,69.95 108.57,69.84 109.07,69.84 109.22,69.69 109.22,69.53 109.08,69.38 108.57,69.38 108.46,69.27 108.46,61.65 109.26,60.85 109.26,58.92 108.47,58.12 108.47,56.39 108.81,56.04 v1(108.94,56.04)
  BOTTOM w0.102: v1(108.94,56.04) 108.92,56.04 108.89,56.08 108.52,56.08 107.92,56.68 JDIM3.246
M_B_DQ59: length 77.3
  TOP w0.089: U3.M8 126.49,109.78 v1(126.42,109.78)
  TOP w0.102: v1(112.04,52.51) 112.04,52.69 112.2,52.84 112.44,52.84 112.63,52.66 112.63,51.7 112.32,51.4 JDIM1.236
  IN1 w0.079: 125.2,105.69 125.2,107.93 125.47,108.19 126.04,108.19 126.83,108.99 126.83,109.37 v1(126.42,109.78)
  IN1 w0.114: v1(112.04,52.51) 112.4,52.51 112.7,52.81 112.7,53.32 111.63,54.39 111.63,55.48 110.7,56.42 110.7,81.29 113.65,84.24 113.65,100.89 116.31,103.55 123.06,103.55 125.2,105.69
  BOTTOM w0.102: v1(112.04,52.51) 111.98,52.57 111.33,52.57 111.17,52.42 111.17,52.21 111.28,52.11 111.42,52.11 111.52,52.01 111.52,51.81 111.42,51.71 111.28,51.71 111.17,51.6 JDIM3.233
M_B_DQ60: length 79.4
  TOP w0.089: U3.L10 125.9,110.78 v1(125.49,111.09)
  TOP w0.102: JDIM1.246 109.82,52.64 109.42,53.05 v1(108.93,53.05)
  IN1 w0.079: 122.65,107.03 122.82,107.2 122.82,107.22 123.14,107.54 123.14,108.14 124.8,109.8 124.8,110.4 v1(125.49,111.09)
  IN1 w0.114: 122.65,107.03 121.31,105.68 115.44,105.68 111.47,101.71 111.47,85.08 108.54,82.16 108.54,79.69 107.77,78.92 107.77,78.58 107.88,78.46 108.46,78.46 108.58,78.35 108.58,78.12 108.46,78.01 107.88,78.01 107.77,77.89 107.77,55.96 108.53,55.2 108.53,54.86 108.42,54.74 107.98,54.74 107.85,54.61 107.85,54.41 107.98,54.29 108.42,54.29 108.53,54.17 108.53,53.28 108.76,53.05 v1(108.93,53.05)
  BOTTOM w0.102: v1(108.93,53.05) 108.86,53.05 107.17,51.36 JDIM3.249
M_B_DQ61: length 79.8
  TOP w0.089: U3.M10 126.49,111.07 v1(126.36,111.07)
  TOP w0.102: JDIM1.233 113.07,55.52 112.78,55.22 112.38,55.22 v1(112.04,55.56)
  IN1 w0.079: 123.39,102.63 123.9,102.63 125.45,104.18 125.77,104.18 126.05,104.46 126.05,107.95 127.01,108.91 127.01,109.8 126.72,110.09 126.72,110.71 v1(126.36,111.07)
  IN1 w0.114: 123.39,102.63 122.93,102.63 122.78,102.78 122.42,102.78 122.27,102.63 122.09,102.63 121.89,102.83 121.89,103.04 121.72,103.21 116.46,103.21 113.99,100.74 113.99,84.1 111.04,81.15 111.04,80.81 111.15,80.69 111.47,80.69 111.59,80.58 111.59,80.35 111.47,80.24 111.15,80.24 111.04,80.12 111.04,79.89 111.15,79.78 111.47,79.78 111.59,79.67 111.59,79.44 111.47,79.32 111.15,79.32 111.04,79.21 111.04,78.98 111.15,78.86 111.47,78.86 111.59,78.75 111.59,78.52 111.47,78.41 111.15,78.41 111.04,78.29 111.04,56.56 v1(112.04,55.56)
  BOTTOM w0.102: v1(112.04,55.56) 111.1,55.56 110.42,56.23 JDIM3.236
M_B_DQ62: length 75.9
  TOP w0.089: U3.M7 126.77,108.8 v1(126.43,109.13)
  TOP w0.102: JDIM1.232 113.32,51.41 112.84,51.9 112.84,53.05 112.69,53.2 112.11,53.2 v1(112.04,53.27)
  IN1 w0.079: v1(126.43,109.13) 126.43,108.82 125.97,108.35 125.32,108.35 124.86,107.89 124.86,105.84 124.73,105.71
  IN1 w0.114: v1(112.04,53.27) 111.29,54.03 111.29,55.34 110.35,56.27 110.35,81.44 113.3,84.38 113.3,101.03 116.17,103.9 122.92,103.9 124.73,105.71
  BOTTOM w0.102: JDIM3.237 110.17,51.12 110.9,51.85 110.9,52.43 111.74,53.27 v1(112.04,53.27)
M_B_DQ63: length 79.1
  TOP w0.089: v1(125.48,109.78) 125.6,109.78 U3.L8
  TOP w0.102: JDIM1.245 110.07,57.11 110.31,56.88 110.31,56.35 109.92,55.96 109.92,55.31 109.67,55.06 109.23,55.06 v1(108.93,55.36)
  IN1 w0.079: v1(125.48,109.78) 125.08,109.78 123.35,108.04 123.35,107.39 123.17,107.22 123.17,107.06 123.14,107.03
  IN1 w0.114: 123.14,107.03 121.45,105.34 115.58,105.34 111.81,101.57 111.81,84.94 108.92,82.05 108.92,79.59 108.49,79.15 108.49,78.92 108.92,78.49 108.92,77.82 108.77,77.66 108.27,77.66 108.11,77.51 108.11,77.3 108.23,77.18 108.81,77.18 108.92,77.07 108.92,76.84 108.81,76.72 108.23,76.72 108.11,76.61 108.11,76.38 108.23,76.27 108.81,76.27 108.92,76.15 108.92,75.92 108.81,75.81 108.23,75.81 108.11,75.7 108.11,59.71 108.6,59.22 108.6,58.84 108.11,58.35 108.11,56.1 108.85,55.36 v1(108.93,55.36)
  BOTTOM w0.102: JDIM3.250 106.92,57.55 107.41,57.06 107.41,55.86 107.91,55.36 v1(108.93,55.36)
M_B_DQSN0: length 82.2
  TOP w0.089: v1(157.94,110.94) U3.BN9
  TOP w0.102: JDIM1.11 170.57,57.37 170.48,57.27 170.48,54.52 169.86,53.91 169.65,53.91 v1(169.29,53.54)
  IN1 w0.127: v1(157.94,110.94) 158.11,111.11 158.11,111.28 158.53,111.71 160.72,111.71 161.97,110.45 163.11,110.45 163.48,110.08 165.03,110.08 165.64,109.47 165.8,109.47 172.04,103.23 172.04,95.94 167.66,91.57 167.66,66.93 170.04,64.56 170.04,54.03 169.76,53.75 169.5,53.75 v1(169.29,53.54)
  BOTTOM w0.102: v1(169.29,53.54) 169.29,53.97 169.11,54.14 168.71,54.14 168.58,54.01 168.58,53.54 168.75,53.38 168.75,51.91 168.5,51.66 168.5,51.41 168.67,51.23 JDIM3.11
M_B_DQSN1: length 77.9
  TOP w0.089: v1(156.51,111.07) U3.BL9
  TOP w0.102: JDIM1.32 165.32,51.33 165.37,51.38 165.37,52.75 165.14,52.98 165.14,53.19 165.22,53.28 165.34,53.28 165.6,53.53 165.6,53.94 165.17,54.36 164.75,54.36 v1(164.5,54.61)
  IN1 w0.079: 158.9,106.8 158.9,106.82 158.85,106.86 158.85,108.58 158.45,108.99 157.79,108.99 157.7,108.9 157.13,108.9 156.79,109.24 156.79,109.82 156.91,109.93 156.91,110.51 156.51,110.91 v1(156.51,111.07)
  IN1 w0.127: v1(164.5,54.61) 164.27,54.39 164.16,54.39 164.07,54.47 164.07,55.51 164.31,55.75 164.31,65.22 164.1,65.44 164.1,90.71 163.83,90.98 162.86,90.98 162.73,91.1 162.73,91.49 162.86,91.61 163.83,91.61 164.1,91.88 164.1,92.46 163.83,92.73 162.9,92.73 162.77,92.86 162.77,93.24 162.89,93.37 163.83,93.37 164.1,93.63 164.1,94.43 161.07,97.45 161.07,101 161.56,101.48 161.56,102.72 158.9,105.38 158.9,106.8
  BOTTOM w0.102: JDIM3.32 163.42,57.59 163.13,57.3 163.13,57.15 163.56,56.71 163.56,54.86 164.14,54.27 164.38,54.27 164.5,54.39 v1(164.5,54.61)
M_B_DQSN2: length 71.5
  TOP w0.089: v1(153.79,110.42) 154.21,110.12 U3.BG9
  TOP w0.102: JDIM1.53 160.07,57.45 159.97,57.35 159.97,57.15 159.61,56.79 159.61,55.89 160.16,55.33 160.16,54.27 159.92,54.03 159.51,54.03 v1(159.27,53.8)
  IN1 w0.079: v1(153.79,110.42) 153.45,110.08 153.45,107.74 153.88,107.3 153.88,103.63 155.94,101.57 155.94,99.23 155.98,99.19 155.98,99.18
  IN1 w0.127: v1(159.27,53.8) 159.51,54.03 159.68,54.03 160.09,54.43 160.09,56.64 159.75,56.98 159.75,70.9 158.94,71.71 158.94,94.54 155.98,97.49 155.98,99.18
  BOTTOM w0.102: v1(159.27,53.8) 159.27,54.09 159.06,54.31 158.77,54.31 157.99,53.53 157.99,51.4 158.17,51.21 JDIM3.53
