# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ48: length 38.2
  TOP w0.168: v2(69.81,109.73) 69.85,109.69 UG1.AJ48 ; VRAM8.U13 v2(98.41,109.54)
  IN1 w0.127: v2(69.81,109.73) 69.86,109.68 71.1,109.68 71.27,109.51 71.73,109.51 71.94,109.72 72.73,109.72 73.07,109.37 77.77,109.37 84.42,116.02 95.99,116.02 98.89,113.13 98.89,110.02 v2(98.41,109.54)
VMA_DQ49: length 40.5
  TOP w0.168: v2(98.46,108.06) 98.4,108.06 VRAM8.U11 ; v2(68.07,108.91) 68.08,108.92 68.12,108.92 UG1.AJ46
  IN1 w0.127: v2(98.46,108.06) 98.4,108.06 98.02,108.43 98.02,110.68 98.09,110.75 98.09,113.17 95.77,115.49 84.64,115.49 77.99,108.84 72.45,108.84 72.26,109.02 71.36,109.02 70.34,109.34 68.5,109.34 v2(68.07,108.91)
VMA_DQ50: length 42.6
  TOP w0.168: VRAM8.V12 98.77,109.18 v2(99.14,108.81) ; v2(68.71,109.71) 68.76,109.66 68.8,109.66 69.15,109.31 UG1.AJ47
  IN1 w0.127: v2(99.14,108.81) 99.51,108.81 99.82,109.12 99.82,112.95 99.75,113.02 99.39,113.38 96.52,116.25 96.52,116.71 96.51,116.72 96.51,116.74 96.32,116.93 95.99,116.93 95.99,116.93 84.57,116.93 77.55,109.91 73.28,109.91 72.93,110.25 72.52,110.25 72.51,110.26 71.53,110.26 71.12,110.67 70.65,110.67 70.56,110.58 69.36,110.58 69.12,110.34 69.12,110.12 68.71,109.71 v2(68.71,109.71)
VMA_DQ51: length 31.9
  TOP w0.168: v2(96.14,110.31) VRAM8.P13 ; v2(70.9,108.23) 70.87,108.26 70.84,108.26 UG1.AK49
  IN1 w0.127: v2(70.9,108.23) 71.32,108.09 71.93,108.09 72.25,107.77 78.43,107.77 84.75,114.09 93.74,114.09 94.52,113.31 95.43,113.31 95.78,112.96 95.78,110.68 v2(96.14,110.31)
VMA_DQ52: length 33.1
  TOP w0.168: v2(68.82,106.81) 68.82,106.83 UG1.AM47 ; VRAM8.P12 95.77,109.18 95.48,109.47 v2(95.39,109.56)
  IN1 w0.127: v2(68.82,106.81) 69.43,107.18 69.72,107.18 70.42,107.46 70.88,107.37 71.51,107.24 78.65,107.24 84.97,113.56 93.15,113.56 95.02,111.68 95.02,109.93 v2(95.39,109.56)
VMA_DQ53: length 38.6
  TOP w0.168: v2(97.58,108.81) 97.59,108.81 97.59,108.81 97.64,108.81 98.02,109.18 VRAM8.U12 ; UG1.AM46 68.45,107.15 68.11,107.55 v2(68.11,107.56)
  IN1 w0.127: v2(68.11,107.56) 68.13,107.57 68.22,107.73 68.47,107.99 68.79,108.31 70.7,108.63 70.73,108.65 71.9,108.65 72.24,108.31 78.21,108.31 84.52,114.62 95.89,114.62 97.27,113.24 97.27,109.12 97.36,109.02 v2(97.58,108.81)
VMA_DQ54: length 29.5
  TOP w0.168: v2(70.22,106.82) 69.85,106.48 UG1.AN48
  TOP w0.216: v2(94.64,110.31) VRAM8.N13
  IN1 w0.127: v2(70.22,106.82) 71.49,106.71 71.49,106.71 78.87,106.71 85.19,113.02 92.22,113.02 93.74,111.51 93.96,111.51 94.27,111.2 94.27,110.68 v2(94.64,110.31)
VMA_DQ55: length 28.6
  TOP w0.168: UG1.AN49 70.86,106.13 v2(70.89,106.13)
  TOP w0.216: VRAM8.M13 v2(93.89,109.56)
  IN1 w0.127: v2(70.89,106.13) 70.93,106.17 79.09,106.17 85.41,112.49 90.43,112.49 90.71,112.21 91.08,112.21 91.18,112.31 91.72,112.31 92.77,111.27 92.77,110.09 92.93,109.93 93.52,109.93 v2(93.89,109.56)
VMA_DQ56: length 39.9
  TOP w0.168: v2(98.39,102.06) VRAM8.V3 ; v2(66.7,107.5) UG1.AM44
  IN4 w0.102: 75.56,107.81 72.86,107.81 72.62,108.05 71.24,108.05 70.73,107.55 70.04,107.55 69.66,107.92 69.28,107.92 69.06,107.71 69.06,107.44 68.94,107.32 68.55,107.32 68.41,107.17 67.03,107.17 v2(66.7,107.5)
  IN4 w0.127: v2(98.39,102.06) VRAM8.V3 98.77,104.55 97.28,106.04 95.92,106.04 95.3,106.66 93.98,106.66 93.72,106.91 91.55,106.91 90.52,107.93 90.52,109.01 90.35,109.18 82.76,109.18 81.39,107.81 75.56,107.81
VMA_DQ57: length 44.5
  TOP w0.168: v2(98.39,103.56) 98.02,103.18 VRAM8.U4 ; v2(67.38,106.81) 67.75,107.15 UG1.AM45
  IN2 w0.14: v2(98.39,103.56) 98.02,103.93 98.02,105.28 98.47,105.73 98.47,106.75 98.08,107.14 98.08,108.96 97.86,109.18 95.94,109.18 95.77,109.36 95.77,112.69 95.31,113.15 84.69,113.15 78.71,107.17 72.84,107.17 72.31,106.64 71.2,106.64 70.5,107.34 69.84,107.34 69.68,107.19 67.76,107.19 v2(67.38,106.81)
VMA_DQ58: length 39.4
  TOP w0.168: VRAM8.U2 v2(97.64,101.31) ; UG1.AN45 67.75,106.45 67.33,106.03 v2(66.78,106.03)
  IN4 w0.102: 75.56,103.22 74.95,103.22 74.57,103.6 73.4,103.6 73.12,103.87 73,103.87 72.99,103.87 72.03,103.87 71.54,104.37 69,104.37 67.34,106.03 v2(66.78,106.03)
  IN4 w0.127: v2(97.64,101.31) 97.64,101.12 97.27,100.74 97.27,100.32 96.62,99.67 93.68,99.67 93.44,99.44 89.91,99.44 89.02,100.33 89.02,103.01 88.84,103.19 88.42,103.19 88.26,103.34 88.26,103.76 87.96,104.06 86.98,104.06 86.69,104.36 86.39,104.65 84.4,104.65 82.96,103.22 75.56,103.22
VMA_DQ59: length 35.6
  TOP w0.168: UG1.AN46 68.13,106.13 v2(68.13,106.07) ; VRAM8.U3 v2(97.64,102.81)
  IN4 w0.102: 75.56,107.21 72.56,107.21 72.55,107.2 69.43,107.2 69.17,106.94 69.17,106.61 69,106.43 68.49,106.43 v2(68.13,106.07)
  IN4 w0.127: 75.56,107.21 81.72,107.21 82.93,108.43 89.61,108.43 89.89,108.15 89.89,107.69 90.51,107.06 90.51,106.67 90.63,106.56 92.03,106.02 92.06,106 95.2,106 95.7,105.51 96.97,105.51 97.27,105.21 97.27,103.18 v2(97.64,102.81)
VMA_DQ60: length 28.7
  TOP w0.168: v2(70.21,105.44) 69.85,105.08 UG1.AR48 ; v2(95.39,102.06) VRAM8.P2
  IN4 w0.102: 75.56,105.95 71.43,105.95 71.24,105.76
  IN4 w0.127: v2(70.21,105.44) 70.52,105.76 71.24,105.76 ; v2(95.39,102.06) 95.19,102.06 94.82,102.43 94.49,102.43 94.27,102.65 94.27,103.15 92.88,104.54 92.38,105.04 88.52,106.62 88.09,106.85 83.09,106.85 82.19,105.95 75.56,105.95
VMA_DQ61: length 30.9
  TOP w0.168: UG1.AN47 69.54,106 v2(69.54,105.99) ; v2(96.14,102.81) VRAM8.P3
  IN4 w0.102: 75.56,106.57 70.71,106.57 70.6,106.46 69.88,106.46 69.54,106.12 v2(69.54,105.99)
  IN4 w0.127: 75.56,106.57 81.94,106.57 83.05,107.68 88.9,107.68 89.02,107.56 89.02,107.11 89.82,106.48 92.34,105.41 94.24,105.41 95.77,103.88 95.77,103.38 96.14,103.01 v2(96.14,102.81)
VMA_DQ62: length 28.9
  TOP w0.168: UG1.AR47 69.26,104.93 69.43,104.75 v2(69.49,104.75)
  TOP w0.216: VRAM8.M2 v2(93.89,102.06)
  IN4 w0.102: v2(69.49,104.75) 69.49,104.77 69.59,104.87 71.96,104.87 72.62,105.53 74.53,105.53 74.76,105.3 75.56,105.3
  IN4 w0.127: 75.56,105.3 82.41,105.3 83.43,106.32 88.08,106.32 89.51,105.82 91.03,105.02 91.2,104.93 91.56,104.93 92.02,104.47 92.02,102.58 92.16,102.44 93.51,102.44 v2(93.89,102.06)
VMA_DQ63: length 46
  TOP w0.168: UG1.AR46 v2(68.75,105.43)
  TOP w0.216: VRAM8.N2 v2(94.64,101.31)
  IN2 w0.14: v2(68.75,105.43) 68.76,105.43 69.08,105.75 69.08,106.28 69.2,106.41 70.32,106.41 70.47,106.26 70.47,105.89 70.64,105.72 71.45,105.72 71.82,106.08 72.59,106.08 73.13,106.62 78.94,106.62 84.85,112.53 90.35,112.53 90.65,112.24 91.15,112.24 91.44,112.53 94.28,112.53 95.02,111.79 95.02,108.59 95.18,108.43 97.08,108.43 97.27,108.25 97.27,107.75 97.47,107.54 97.47,106.39 96.51,105.43 95.99,105.43 95.02,104.45 95.02,101.68 v2(94.64,101.31)
VMA_WCK01: length 42
  TOP w0.122: UG1.U45 67.75,117.65 67.75,117.88 67.58,118.05 67.41,118.05 v2(67.38,118.03) ; v2(96.89,124.06) VRAM6.D4
  IN2 w0.102: v2(96.89,124.06) 96.54,123.7 91.49,123.7 90.96,124.23 90.96,127.16 90.47,127.66 85.29,127.66 83.16,125.54 83.16,123.79 75.19,115.81 70.95,115.81 70.75,116.01 70.75,116.4 70.34,116.81 69.52,116.81 68.82,117.51 68.7,117.51 68.37,117.84 67.84,117.84 67.61,117.61 67.29,117.61 67.15,117.75 67.15,117.85 67.33,118.03 v2(67.38,118.03)
VMA_WCK01#: length 42.2
  TOP w0.122: VRAM6.D5 96.52,123.65 v2(96.89,123.29) ; UG1.U44 66.73,117.97 v2(66.69,117.97)
  IN2 w0.102: v2(96.89,123.29) 96.68,123.49 96.67,123.49 96.64,123.52 96.64,123.52 96.63,123.51 96.63,123.51 96.61,123.5 91.4,123.5 90.76,124.14 90.76,127.08 90.38,127.45 85.37,127.45 83.37,125.45 83.37,123.7 75.27,115.6 70.86,115.6 70.55,115.92 70.55,116.32 70.25,116.61 69.43,116.61 68.73,117.31 68.62,117.31 68.28,117.64 67.92,117.64 67.69,117.41 67.2,117.41 66.95,117.66 66.95,117.87 66.84,117.97 v2(66.69,117.97)
VMA_WCK23: length 27.5
  TOP w0.122: v2(88.65,119.51) 88.39,119.51 88.27,119.38 VRAM6.R11 ; v2(67.41,113.12) 67.38,113.15 67.38,113.53 67.51,113.66 67.68,113.66 67.75,113.59 UG1.AC45
  IN4 w0.102: 75.56,112.43 72.83,112.43 72.47,112.79 70.41,112.79 69.72,113.48 69.33,113.48 69.08,113.23 68.58,113.23 68.27,113.54 67.42,113.54 67.29,113.41 67.29,113.24 v2(67.41,113.12)
  IN4 w0.114: 75.56,112.43 78.68,112.43 84.6,118.35 84.6,118.37 86.14,119.91 88.53,119.91 88.65,119.8 v2(88.65,119.51)
VMA_WCK23#: length 27.7
  TOP w0.122: v2(88.67,120.53) 88.67,120.33 VRAM6.R10 ; UG1.AC44 67.02,113.45 v2(66.68,113.11)
  IN4 w0.102: v2(66.68,113.11) 66.71,113.09 66.89,113.09 67.09,113.29 67.09,113.5 67.33,113.74 68.35,113.74 68.66,113.43 68.99,113.43 69.24,113.69 69.8,113.69 70.5,112.99 72.56,112.99 72.92,112.64 75.47,112.64 75.47,112.64 75.53,112.64 75.55,112.66 75.56,112.66
  IN4 w0.114: 75.56,112.66 78.59,112.66 86.05,120.13 88.38,120.13 88.67,120.41 v2(88.67,120.53)
VMA_WCK45: length 25.1
  TOP w0.122: v2(68.81,102.58) 68.88,102.65 68.92,102.65 69.04,102.77 69.04,102.84 UG1.AV47
  TOP w0.14: v2(88.64,103.56) 88.27,103.18 VRAM8.D4
  IN1 w0.102: 75.41,99.97 74.22,99.97 73.15,101.04 70.49,101.04 70.31,100.86 70.3,100.86
  IN1 w0.114: v2(88.64,103.56) 88.23,103.96 88.23,104.26 87.82,104.68 85.92,104.68 81.21,99.97 75.41,99.97 ; 70.3,100.86 70,100.86 69.14,101.73 69.14,101.84 68.71,102.26 68.71,102.47 68.81,102.57 v2(68.81,102.58)
VMA_WCK45#: length 25.2
  TOP w0.122: UG1.AV46 68.45,102.95 68.11,102.61 v2(68.09,102.61)
  TOP w0.14: v2(87.89,103.56) VRAM8.D5
  IN1 w0.102: 70.38,100.65 70.57,100.84 73.06,100.84 74.16,99.74
  IN1 w0.114: 70.38,100.65 69.91,100.65 68.92,101.64 68.92,101.75 68.5,102.17 68.5,102.38 68.26,102.61 v2(68.09,102.61) ; 74.16,99.74 81.31,99.74 86.02,104.45 87.72,104.45 88.01,104.17 88.01,103.67 v2(87.89,103.56)
VMA_WCK67: length 42
  TOP w0.122: UG1.AR45 67.75,105.05 v2(67.4,104.73) ; v2(96.14,108.06) VRAM8.R11
  IN2 w0.102: v2(96.14,108.06) 96.14,108.03 96.5,107.67 96.53,107.67 96.7,107.5 96.7,106.51 96.25,106.05 94.03,106.05 93.84,105.86 90.89,105.86 90.49,106.26 90.49,107.09 91.33,107.92 91.33,108.19 91.03,108.49 91.03,109.09 91.27,109.33 91.27,110.45 90.25,111.47 84.96,111.47 79.07,105.57 72.93,105.57 72.65,105.3 72.16,105.3 71.54,104.67 70.19,104.67 69.75,105.12 69.25,105.12 68.97,104.83 68.48,104.83 68.25,105.07 67.51,105.07 67.41,104.96 67.41,104.74 v2(67.4,104.73)
VMA_WCK67#: length 42
  TOP w0.122: v2(66.69,104.69) 67.05,105.05 UG1.AR44 ; v2(96.14,107.31) VRAM8.R10
  IN2 w0.102: v2(66.69,104.69) 66.82,104.69 67.4,105.27 68.33,105.27 68.57,105.04 68.89,105.04 69.17,105.32 69.83,105.32 70.28,104.87 71.45,104.87 72.08,105.5 72.56,105.5 72.84,105.78 78.99,105.78 84.88,111.67 90.33,111.67 91.47,110.53 91.47,109.24 91.23,109 91.23,108.58 91.53,108.28 91.53,107.84 90.7,107 90.7,106.34 90.97,106.07 93.76,106.07 93.94,106.25 96.16,106.25 96.5,106.59 96.5,107.41 96.44,107.47 96.41,107.47 96.39,107.5 96.25,107.5 96.14,107.39 v2(96.14,107.31)
VMA_WCKB01: length 44.7
  TOP w0.122: v2(96.89,119.56) VRAM6.D11 ; UG1.V45 67.57,116.95 67.45,116.83 v2(67.45,116.6)
  IN1 w0.114: v2(67.45,116.6) 67.22,116.6 67.1,116.72 67.1,116.9 67.83,117.63 68.27,117.63 68.78,117.12 68.86,117.12 69.37,116.61 70.34,116.61 70.45,116.5 70.45,116 70.84,115.62 71.93,115.62 72.17,115.37 75.33,115.37 79.94,119.98 79.94,120.65 82.52,123.23 82.52,124.96 85.01,127.46 90.35,127.46 91.01,126.8 91.01,123.88 91.61,123.27 92.35,123.27 92.36,123.26 92.76,123.26 93.62,122.4 94.37,122.4 95.87,120.89 95.87,120.38 96.47,119.78 96.67,119.78 v2(96.89,119.56)
VMA_WCKB01#: length 44.8
  TOP w0.122: VRAM6.D10 96.52,119.93 v2(96.89,120.31) ; v2(66.72,116.62) 67.05,116.95 UG1.V44
  IN1 w0.114: v2(66.72,116.62) 66.89,116.79 66.89,116.99 67.74,117.84 68.36,117.84 68.87,117.34 68.95,117.34 69.46,116.83 70.43,116.83 70.67,116.59 70.67,116.09 70.92,115.83 72.02,115.83 72.25,115.6 75.23,115.6 79.71,120.08 79.71,120.74 82.29,123.33 82.29,125.06 84.92,127.68 90.42,127.68 91.22,126.89 91.22,123.97 91.7,123.49 92.85,123.49 93.71,122.63 94.46,122.63 96.1,120.99 96.1,120.48 96.57,120.01 96.73,120.01 96.89,120.17 v2(96.89,120.31)
VMA_WCKB23: length 29
  TOP w0.122: VRAM6.R4 v2(88.64,124.06) ; UG1.AD46 68.45,112.75 v2(68.12,112.37)
  IN2 w0.102: v2(88.64,124.06) 89.12,123.58 89.25,123.45 89.25,122.87 88.93,122.55 87.04,122.55 76.83,112.34 72.61,112.34 72.01,112.94 70.63,112.94 70.15,113.42 69.82,113.42 69.68,113.55 69.45,113.55 68.96,113.07 68.83,113.07 68.13,112.36 v2(68.12,112.37)
VMA_WCKB23#: length 29.1
  TOP w0.102: v2(67.4,112.4) 67.54,112.4 67.75,112.61 UG1.AD45
  TOP w0.122: VRAM6.R5 88.64,123.31 v2(88.7,123.31)
  IN2 w0.102: v2(67.4,112.4) 67.62,112.4 67.73,112.52 67.73,112.66 67.84,112.77 68.24,112.77 68.75,113.27 68.81,113.27 69.29,113.75 69.77,113.75 69.9,113.62 70.23,113.62 70.71,113.14 72.1,113.14 72.7,112.54 76.75,112.54 86.96,122.75 88.85,122.75 89.05,122.95 89.05,123.31 88.95,123.41 88.8,123.41 v2(88.7,123.31)
VMA_WCKB45: length 24.5
  TOP w0.122: UG1.AW48 v2(69.52,101.86)
  TOP w0.14: VRAM8.D11 v2(87.89,108.06)
  IN2 w0.102: v2(69.52,101.86) 69.27,101.86 69.17,101.76 69.17,101.63 69.95,100.85 70.39,100.85 70.57,101.03 71.89,101.03 71.94,101.08 72.06,101.08 72.07,101.09 73.61,101.09 73.73,101.21 74.8,101.21 75.11,100.9 76.24,100.9 76.96,101.62 81.66,101.62 85.27,105.23 86.24,105.23 87.53,106.52 87.53,107.7 v2(87.89,108.06)
VMA_WCKB45#: length 24.6
  TOP w0.122: v2(68.56,101.58) 68.62,101.59 68.92,101.98 69.12,102.25 UG1.AW47
  TOP w0.14: VRAM8.D10 v2(87.9,107.28)
  IN2 w0.102: v2(87.9,107.28) 87.84,107.28 87.71,107.15 87.71,106.44 86.32,105.05 85.38,105.05 81.74,101.41 77.04,101.41 76.33,100.7 75.02,100.7 74.72,101 73.81,101 73.7,100.89 72.14,100.89 72.1,100.87 72.02,100.87 71.97,100.82 70.65,100.82 70.48,100.65 69.87,100.65 68.87,101.64 68.63,101.64 v2(68.56,101.58)
VMA_WCKB67: length 42.8
  TOP w0.122: UG1.AT45 67.75,104.35 67.38,103.98 67.38,103.44 v2(67.34,103.4) ; v2(96.89,103.56) 96.52,103.18 VRAM8.R4
  IN1 w0.102: 75.58,105.23 75.1,105.23 74.85,105.48 72.29,105.48 71.57,104.76 70.08,104.76 69.74,105.11 69.34,105.11 68.25,104.02 67.7,104.02 67.34,103.66 v2(67.34,103.4)
  IN1 w0.114: v2(96.89,103.56) 96.69,103.76 96.48,103.76 96.4,103.85 96.4,103.85 96.19,104.07 96.19,104.91 95.21,105.89 90.94,105.89 90.51,106.31 90.51,107.09 91.36,107.94 91.36,108.23 91.05,108.54 91.05,109.04 91.38,109.37 91.38,110.34 90.25,111.47 85.89,111.47 79.65,105.23 75.58,105.23
VMA_WCKB67#: length 42.9
  TOP w0.122: v2(66.87,103.7) 67.05,103.88 67.05,104.35 UG1.AT44 ; v2(96.88,104.34) 96.52,103.99 VRAM8.R5
  IN1 w0.102: v2(66.87,103.7) 67.09,103.7 67.62,104.22 68.17,104.22 69.25,105.31 69.82,105.31 70.16,104.98 70.16,104.98
  IN1 w0.114: v2(96.88,104.34) 96.88,104.14 96.75,104.02 96.56,104.02 96.41,104.16 96.41,105 95.3,106.11 91.03,106.11 90.74,106.41 90.74,107 91.59,107.85 91.59,108.33 91.28,108.64 91.28,108.96 91.61,109.3 91.61,110.43 90.34,111.7 85.8,111.7 79.56,105.46 75.17,105.46 74.94,105.7 72.2,105.7 71.48,104.98 70.16,104.98
VMB_CLK0: length 29.9
  TOP w0.122: UG1.H42 65.96,123.64 v2(66.07,123.53) ; VRAM3.J10 63.95,149.28 v2(63.92,149.28)
  IN1 w0.102: 66.09,130.12 66.09,129.05 66.85,128.3
  IN1 w0.114: v2(66.07,123.53) 65.87,123.73 65.69,123.73 65.22,124.2 65.22,124.99 66.52,126.3 66.52,126.97 66.85,127.3 66.85,128.3 ; v2(63.92,149.28) 63.92,149.24 63.77,149.09 63.58,149.09 63.22,148.73 63.22,147.4 64.15,146.47 64.15,139.33 66.09,137.39 66.09,130.12
VMB_CLK0#: length 30.1
  TOP w0.122: v2(65.97,124.3) 65.93,124.26 65.45,124.26 65.4,124.32 65.4,124.53 65.52,124.65 UG1.G42 ; VRAM3.K10 64.31,148.15 64.12,148.15 63.92,148.35 v2(63.92,148.53)
  IN1 w0.102: 67.06,128.3 67.06,128.31 67.06,128.32 67.06,128.38 66.93,128.5 66.92,128.5 66.32,129.11 66.32,130.12
  IN1 w0.114: 66.32,130.12 66.32,137.49 64.38,139.42 64.38,146.57 63.45,147.49 63.45,148.64 63.67,148.86 63.79,148.86 63.92,148.73 v2(63.92,148.53) ; 67.06,128.3 67.06,127.21 66.74,126.88 66.74,126.21 65.44,124.91 65.44,124.29 65.76,123.96 65.88,123.96 65.97,124.05 v2(65.97,124.3)
VMB_CLK1: length 31.9
  TOP w0.122: VRAM4.J10 75.9,148.16 v2(76.25,147.82) ; UG1.F47 v2(68.81,125.01)
  IN4 w0.102: v2(68.81,125.01) 68.81,125.18 69.02,125.39 69.14,125.39 69.36,125.61 69.36,128.25 70.28,129.17 70.28,129.8 71.24,130.77 71.24,131.84
  IN4 w0.114: 71.24,131.84 71.24,141.58 70.71,142.11 70.71,147.85 71.13,148.27 71.8,148.27 72.26,147.81 73.82,147.81 74.46,147.17 75,147.17 75.92,148.09 76.13,148.09 76.25,147.97 v2(76.25,147.82)
VMB_CLK1#: length 31.9
  TOP w0.122: v2(68.8,125.7) 68.8,125.7 UG1.E47 ; VRAM4.K10 76.18,148.91 76.3,148.79 76.3,148.57 v2(76.26,148.53)
  IN4 w0.102: v2(68.8,125.7) 68.91,125.59 69.06,125.59 69.16,125.69 69.16,128.34 70.07,129.25 70.07,129.89 71.04,130.85 71.04,131.75 71.03,131.76 71.03,131.81 71.01,131.83 71.01,131.84
  IN4 w0.114: 71.01,131.84 71.01,141.48 70.48,142.02 70.48,147.94 71.03,148.49 71.9,148.49 72.35,148.04 73.92,148.04 74.57,147.39 74.91,147.39 75.88,148.35 76.15,148.35 76.26,148.47 v2(76.26,148.53)
VMB_DQ0: length 35
  TOP w0.168: UG1.H32 58.65,123.95 58.93,123.64 58.96,123.6 v2(58.96,123.59) ; v2(57.95,150.78) VRAM3.F2
  IN2 w0.14: v2(58.96,123.59) 58.94,123.62 58.95,123.64 59.33,124.76 59.33,125.84 59.55,126.06 59.88,126.06 60.06,126.24 60.06,126.67 59.92,126.81 59.6,126.81 59.43,126.98 59.43,128.1 59.16,128.37 59.16,128.83 60.09,129.75 60.09,133.79 54.67,139.21 54.67,148.6 54.73,148.66 54.73,149.79 56.17,151.24 57.49,151.24 v2(57.95,150.78)
VMB_DQ1: length 35.7
  TOP w0.168: UG1.D32 58.65,126.75 58.31,127.11 v2(58.28,127.11) ; VRAM3.B4 v2(60.2,154.53)
  IN1 w0.127: v2(60.2,154.53) VRAM3.B4 56.56,154.16 54.2,151.79 54.2,149.86 54.4,149.65 54.4,149.03 54.21,148.83 54.21,140.14 59.31,135.03 59.31,131.51 58.56,130.76 58.56,129.15 58.76,128.96 58.76,128.2 58.65,128.09 58.65,127.61 58.28,127.25 v2(58.28,127.11)
VMB_DQ2: length 32.7
  TOP w0.122: v2(59.17,130.55) 59.53,130.19 59.53,129.03 59.35,128.85 UG1.A33
  TOP w0.168: v2(59.45,153.78) VRAM3.B3
  IN2 w0.14: v2(59.17,130.55) 58.81,130.91 58.81,133.53 53.43,138.9 53.43,149.99 54.29,150.84 54.29,151.73 56.72,154.16 59.07,154.16 v2(59.45,153.78)
VMB_DQ3: length 30.6
  TOP w0.122: UG1.B32 58.65,128.15 59,128.5 59,129.28 v2(59.08,129.36)
  TOP w0.168: VRAM3.E2 v2(58.7,151.53)
  IN2 w0.14: v2(59.08,129.36) 59.15,129.36 59.54,129.75 59.54,133.56 54.07,139.03 54.07,148.56 54.25,148.74 54.25,150.11 56.05,151.91 58.32,151.91 v2(58.7,151.53)
VMB_DQ4: length 38.4
  TOP w0.168: v2(58.14,125.81) 58.14,125.82 58.28,125.79 58.65,126.05 UG1.E32 ; VRAM3.B2 v2(58.7,154.53)
  IN2 w0.14: v2(58.7,154.53) 58.32,154.91 56.12,154.91 53.49,152.28 53.49,150.74 53.15,150.4 52.17,150.4 52.02,150.25 52.02,139.54 58.26,133.3 58.26,129.32 58.67,128.92 58.67,126.08 58.4,125.81 v2(58.14,125.81)
VMB_DQ5: length 36.1
  TOP w0.168: v2(58.24,124.36) 58.36,124.36 58.65,124.65 UG1.G32 ; v2(59.45,152.28) VRAM3.E3
  IN1 w0.127: v2(59.45,152.28) VRAM3.E3 56.56,151.91 55.44,150.8 55.44,150.12 56.08,149.48 56.08,149.01 55.27,148.2 55.27,140.58 60.38,135.47 60.38,130.37 60.08,130.07 60.08,128.32 59.62,127.86 59.62,127.64 59.44,127.45 59.44,126.92 59.28,126.75 58.8,126.75 58.65,126.6 58.65,126.18 58.53,126.05 58.53,124.53 58.36,124.36 v2(58.24,124.36)
VMB_DQ6: length 40.8
  TOP w0.168: v2(59.45,155.28) VRAM3.A3 ; v2(56.9,122.85) 57.23,123.25 UG1.J30
  IN1 w0.127: v2(59.45,155.28) 59.07,154.91 56.35,154.91 53.66,152.22 53.66,150.04 53.3,149.68 53.3,149.16 53.67,148.78 53.67,139.91 58.78,134.81 58.78,131.6 58.05,130.87 58.05,129.21 57.8,128.96 57.8,128.47 57.92,128.35 57.92,126.16 57.29,125.53 57.29,124.08 57.24,124.03 57.24,123.19 v2(56.9,122.85)
VMB_DQ7: length 31
  TOP w0.168: v2(58.7,150.03) VRAM3.G2 ; UG1.F32 58.65,125.3 v2(58.95,125)
  IN1 w0.127: v2(58.95,125) 58.97,125 59.33,125.36 59.33,125.87 59.51,126.05 59.86,126.05 60.07,126.25 60.07,126.78 60.4,127.12 60.4,129.44 60.91,129.95 60.91,135.69 55.86,140.75 55.86,147.77 56.99,148.9 57.42,148.9 57.57,149.05 57.57,149.54 57.7,149.66 58.33,149.66 v2(58.7,150.03)
VMB_DQ8: length 34.1
  TOP w0.168: v2(66.2,151.53) VRAM3.E13 ; v2(61.15,124.3) 61.15,124.27 61.17,124.25 61.17,124.23 61.45,123.95 UG1.H36
  IN4 w0.102: v2(61.15,124.3) 61.41,124.56 61.41,124.86 61.46,124.97 61.46,125.31 61.5,125.35 61.5,125.88 61.69,126.07 61.98,126.07 62.37,126.46 62.37,126.75 62.63,127 62.89,128.96 62.89,131.84
  IN4 w0.127: v2(66.2,151.53) 65.83,151.16 64.94,151.16 64.78,151 63.08,151 61.86,149.78 61.86,146.45 61.34,145.93 60.84,145.93 60.58,145.67 60.58,140.22 62.89,137.91 62.89,131.84
VMB_DQ9: length 31.9
  TOP w0.168: v2(61.82,125.02) 61.45,124.65 UG1.G36 ; VRAM3.F13 v2(66.95,150.78)
  IN4 w0.102: v2(61.82,125.02) 62.14,125.34 62.54,125.34 62.81,125.6 62.81,126.05 62.65,126.21 62.65,126.53 63.12,127.01 63.12,127.37 63.54,128.44 63.54,131.84
  IN4 w0.127: v2(66.95,150.78) 66.58,150.41 64.53,150.41 64.28,150.17 64.28,149.93 64.07,149.72 63.61,149.72 63.35,149.45 63.35,146.68 62.05,145.38 62.05,139.78 63.54,138.28 63.54,131.84
VMB_DQ10: length 31.7
  TOP w0.168: VRAM3.G13 v2(66.2,150.03) ; UG1.J36 v2(61.79,123.59)
  IN4 w0.102: v2(61.79,123.59) 62.14,123.93 62.65,123.93 62.86,124.15 62.86,124.52 62.98,124.64 63.36,124.64 63.55,124.84 63.55,126.04 63.56,126.27 63.56,126.79 63.53,127.23 64.14,128.19 64.14,131.84
  IN4 w0.127: 64.14,131.84 64.14,132.29 64.22,132.37 64.22,138.61 62.68,140.15 62.68,144.95 63.63,145.89 63.77,145.89 64.32,146.43 64.32,148.38 64.32,148.38 64.32,148.69 64.32,148.69 64.32,148.74 64.5,148.93 64.95,148.93 65.1,149.07 65.1,149.55 65.2,149.66 65.61,149.66 65.98,150.03 v2(66.2,150.03)
VMB_DQ11: length 40.6
  TOP w0.168: VRAM3.B13 v2(66.95,154.53) ; v2(61.14,125.71) 61.17,125.68 61.17,125.65 61.2,125.62 61.2,125.6 61.45,125.35 UG1.F36
  IN2 w0.14: v2(66.95,154.53) 66.57,154.16 65.97,154.16 65.82,154.01 65.82,151.32 65.67,151.17 65.07,151.17 64.5,150.6 64.5,150.4 64.32,150.23 64.32,146.49 63.74,145.91 59.98,145.91 59.82,145.74 59.82,145.3 59.69,145.18 57.78,145.18 57.57,144.97 57.57,140.09 62.76,134.9 62.76,129.43 61.42,128.09 61.42,125.99 v2(61.14,125.71)
VMB_DQ12: length 36.4
  TOP w0.168: VRAM3.B12 65.45,153.79 v2(65.44,153.79) ; UG1.F33 59.65,125.66 v2(59.71,125.66)
  IN4 w0.102: 60.6,131.84 60.6,128.17 60.43,128 60.43,127.16 60.08,126.82 60.08,126.23 59.69,125.84
  IN4 w0.127: v2(59.71,125.66) 59.71,125.68 59.69,125.7 59.69,125.84 ; v2(65.44,153.79) 65.44,153.77 65.07,153.41 62.9,153.41 62.15,152.65 59.2,152.65 59.07,152.53 59.07,147.51 58.31,146.76 58.31,139.2 60.6,136.92 60.6,131.84
VMB_DQ13: length 39.7
  TOP w0.168: v2(64.68,154.54) 64.69,154.54 VRAM3.B11 ; UG1.D33 59.35,126.75 v2(59.81,127.21)
  IN2 w0.14: v2(59.81,127.21) 59.94,127.08 60.48,127.08 60.67,127.27 60.67,127.8 60.45,128.02 60.45,129.2 61.16,129.91 61.16,129.93 61.28,130.06 61.28,134.28 56.09,139.47 56.09,140.69 55.86,140.92 55.86,148.4 56.09,148.63 56.09,149.5 56.24,149.65 59.58,149.65 59.81,149.88 59.81,150.65 60.23,151.07 61.37,151.07 62.47,152.17 62.47,154.27 62.79,154.59 63.41,154.59 63.61,154.39 64.54,154.39 v2(64.68,154.54)
VMB_DQ14: length 43.4
  TOP w0.168: VRAM3.A12 v2(66.2,155.28) ; v2(58.27,122.96) 58.37,122.96 UG1.J32
  IN4 w0.102: 59.52,131.84 59.52,128.96 58.66,128.1 58.66,126.08 58.56,125.98 58.56,124.83 58.73,124.37 58.73,124.1 58.55,123.69 58.55,123.42 58.38,123 v2(58.27,122.96)
  IN4 w0.127: 59.52,131.84 59.52,135.4 56.8,138.13 56.8,146.74 57.57,147.52 57.57,153.95 57.77,154.15 61.92,154.15 62.92,155.16 64.06,155.16 64.3,154.91 65.82,154.91 v2(66.2,155.28)
VMB_DQ15: length 34.9
  TOP w0.168: v2(59.66,124.3) 59.66,124.34 59.35,124.65 UG1.G33 ; VRAM3.E12 65.79,151.91 v2(65.43,152.27)
  IN4 w0.102: 61.84,131.84 61.84,128.03 61.57,127.77 61.57,126.79 60.71,125.93 60.71,125.7 60.42,125.31 59.99,125.31 59.62,124.95 59.62,124.38 59.66,124.34 v2(59.66,124.3)
  IN4 w0.127: v2(65.43,152.27) 65.07,151.91 63.31,151.91 61.94,150.54 61.04,150.54 60.57,150.06 60.57,147.26 59.83,146.51 59.83,140 61.84,137.99 61.84,131.84
VMB_DQ16: length 17.1
  TOP w0.168: UG1.E45 67.75,126.05 67.4,126.4 v2(67.38,126.4) ; v2(66.2,141.78) 65.82,142.16 VRAM3.V12
  IN2 w0.14: v2(67.38,126.4) 67.38,126.45 67.64,126.7 67.64,128.51 67.6,128.55 67.6,137.4 66.37,138.63 66.37,141.6 v2(66.2,141.78)
VMB_DQ17: length 18.3
  TOP w0.168: v2(66.95,142.53) VRAM3.U13 ; UG1.D45 67.75,126.75 68.04,127.04 68.04,127.05 v2(68.07,127.08)
  IN4 w0.102: 69.15,131.84 69.15,130.49 67.93,129.27 67.93,127.22 v2(68.07,127.08)
  IN4 w0.127: v2(66.95,142.53) 67.34,142.14 67.99,142.14 69.15,140.98 69.15,131.84
VMB_DQ18: length 23.3
  TOP w0.168: VRAM3.P12 65.82,145.16 v2(66.2,144.78) ; UG1.F45 67.75,125.35 68.14,125.74 v2(68.14,125.76)
  IN4 w0.102: 69.88,131.84 69.88,130.35 68.8,129.28 68.8,127.28 67.95,126.42 67.95,126.02 68.14,125.83 v2(68.14,125.76)
  IN4 w0.127: 69.88,131.84 69.88,141.41 68.7,142.59 68.7,143.56 67.85,144.41 67.1,144.41 67.1,144.41 66.79,144.41 66.79,144.41 66.57,144.41 v2(66.2,144.78)
VMB_DQ19: length 24.4
  TOP w0.168: v2(67.42,124.98) 67.42,124.98 67.75,124.65 UG1.G45 ; VRAM3.M13 v2(66.95,147.03)
  IN2 w0.14: v2(66.95,147.03) 67.33,146.65 67.33,138.46 68.19,137.6 68.19,128.49 68.78,127.9 68.78,127.32 68.53,127.06 68.53,126.91 68.35,126.73 68.23,126.73 67.94,126.44 67.77,126.02 67.77,125.55 67.42,124.98 v2(67.42,124.98)
VMB_DQ20: length 17.8
  TOP w0.168: UG1.D42 65.72,126.75 v2(66.16,127.19) ; v2(65.45,142.53) VRAM3.U12
  IN4 w0.102: 66.71,131.84 66.71,131.39 66.13,130.81 66.13,128.12 65.96,127.95 65.96,127.39 v2(66.16,127.19)
  IN4 w0.127: v2(65.45,142.53) 65.45,142.51 65.02,142.09 65.02,141.22 66.71,139.53 66.71,131.84
VMB_DQ21: length 19.7
  TOP w0.168: UG1.E42 65.35,125.75 v2(65.35,125.7) ; v2(64.74,143.29) 64.75,143.28 64.75,143.25 65.07,142.94 VRAM3.U11
  IN4 w0.102: 65.6,126 65.6,131.47 65.97,131.84
  IN4 w0.127: v2(64.74,143.29) 64.74,143.24 64.36,142.87 64.36,141.13 66,139.49 66,131.88 65.97,131.84 ; v2(65.35,125.7) 65.35,125.75 65.6,126
VMB_DQ22: length 23.4
  TOP w0.168: v2(66.02,124.97) 65.65,125.33 UG1.F42 ; VRAM3.P13 66.57,145.16 v2(66.94,145.53)
  IN2 w0.14: v2(66.94,145.53) 66.94,145.37 66.57,145 66.57,143.81 66.43,143.67 66.02,143.67 65.83,143.47 65.83,138.4 66.46,137.76 67.05,137.18 67.05,128.13 67.29,127.89 67.29,127.39 67,127.11 67,126.52 66.02,125.54 v2(66.02,124.97)
VMB_DQ23: length 27.3
  TOP w0.168: v2(66.2,146.28) VRAM3.N13 ; v2(65.32,123.58) 65.29,123.58 64.95,123.92 UG1.H41
  IN2 w0.14: v2(65.32,123.58) 65.33,123.64 65.48,124.53 65.48,124.54 65.48,124.6 65.53,124.65 65.53,125.01 65.7,125.18 65.7,125.56 66.57,126.43 66.57,127.32 66.74,127.5 66.74,127.83 66.51,128.07 66.51,136.95 64.27,139.18 64.27,145.58 64.99,146.3 64.99,146.53 65.13,146.67 65.81,146.67 v2(66.2,146.28)
VMB_DQ24: length 20.1
  TOP w0.168: UG1.E41 64.95,126.09 64.66,126.38 64.66,126.39 v2(64.64,126.4) ; VRAM3.U4 v2(60.2,143.28)
  IN2 w0.14: v2(64.64,126.4) 64.64,126.71 65.01,127.08 65.01,128.18 65.05,128.21 65.05,135.85 60.57,140.33 60.57,142.71 60.2,143.08 v2(60.2,143.28)
VMB_DQ25: length 26.1
  TOP w0.168: v2(63.92,125.7) 63.9,125.7 UG1.F39 ; v2(59.45,145.55) 59.45,145.54 VRAM3.P3
  IN1 w0.127: v2(59.45,145.55) 59.8,145.9 61.32,145.9 61.98,145.24 61.98,139.79 64.89,136.88 64.89,126.94 64.72,126.77 64.1,126.77 64.06,126.81 63.77,126.81 63.54,126.58 63.54,126.08 v2(63.92,125.7)
VMB_DQ26: length 22.5
  TOP w0.168: VRAM3.P2 58.32,145.16 v2(58.7,144.78) ; v2(63.17,126.41) 63.53,126.05 UG1.E39
  IN1 w0.127: v2(63.17,126.41) 63.21,126.45 63.21,127.89 63.65,128.33 63.65,136.62 60.57,139.69 60.57,144.22 60.38,144.41 59.07,144.41 v2(58.7,144.78)
VMB_DQ27: length 23.9
  TOP w0.168: v2(63.96,127.19) 63.96,127.16 UG1.D39 ; v2(57.94,145.55) 58.3,145.91 VRAM3.N2
  IN1 w0.127: v2(63.96,127.19) 63.86,127.29 63.86,127.88 64.18,128.21 64.18,136.84 61.45,139.57 61.45,144.85 61.14,145.16 58.33,145.16 v2(57.94,145.55)
VMB_DQ28: length 28.8
  TOP w0.168: VRAM3.M2 58.68,146.29 v2(58.68,146.27) ; UG1.F38 v2(63.19,125.01)
  IN1 w0.127: v2(63.19,125.01) 63.19,125.09 63.42,125.32 64.4,125.32 64.71,125.45 64.86,125.59 64.86,125.72 65.42,126.29 65.42,137.1 62.51,140.01 62.51,145.46 61.54,146.43 60.22,146.43 59.95,146.7 59.15,146.7 58.71,146.27 v2(58.68,146.27)
VMB_DQ29: length 19.6
  TOP w0.168: v2(62.37,125.86) 62.41,125.85 UG1.E38 ; v2(59.45,142.53) VRAM3.U3
  IN1 w0.127: v2(59.45,142.53) 59.82,142.16 59.82,139.69 63.11,136.39 63.11,128.64 62.79,128.32 62.79,126.83 62.43,126.47 62.43,125.92 v2(62.37,125.86)
VMB_DQ30: length 18.5
  TOP w0.168: UG1.D36 61.45,126.75 61.45,126.93 61.95,127.44 v2(61.95,127.63) ; VRAM3.V3 v2(58.7,141.78)
  IN2 w0.14: v2(58.7,141.78) 58.5,141.59 58.5,140.08 63.41,135.17 63.41,129.16 61.95,127.7 v2(61.95,127.63)
VMB_DQ31: length 19.6
  TOP w0.168: VRAM3.U2 v2(57.95,142.53) ; UG1.E36 61.45,126.05 61.8,126.4 v2(61.8,126.43)
  IN1 w0.127: v2(57.95,142.53) 57.95,140.81 62.58,136.17 62.58,128.87 61.54,127.83 61.54,126.68 v2(61.8,126.43)
VMB_DQ32: length 29
  TOP w0.168: UG1.M50 71.54,120.77 v2(71.53,120.69) ; v2(80.75,143.28) 81.13,142.91 VRAM4.B3
  IN4 w0.102: 75.3,122.51 73.96,121.16 73.55,121.16 73.23,120.84 72.21,120.84 72.09,120.72
  IN4 w0.127: 75.3,122.51 79.46,126.67 79.46,131.96 81.13,133.63 81.13,142.38 81.13,142.38 81.13,142.91 v2(80.75,143.28) ; 72.09,120.72 71.56,120.72 v2(71.53,120.69)
VMB_DQ33: length 31
  TOP w0.168: UG1.P48 v2(69.5,120.13) ; v2(81.5,141.78) VRAM4.A3
  IN4 w0.102: v2(69.5,120.13) 69.5,120.13 69.76,120.39 69.87,120.49 70.44,120.49 70.57,120.63 71.06,120.63 71.65,120.04 73.22,120.04 73.77,120.59 74.16,120.59 75.24,121.67
  IN4 w0.127: 75.24,121.67 80.09,126.53 80.09,131.64 81.92,133.46 81.92,141.37 v2(81.5,141.78)
VMB_DQ34: length 30.1
  TOP w0.168: v2(81.54,145.56) 81.54,145.5 VRAM4.E2 ; UG1.M51 v2(72.31,121.51)
  IN2 w0.102: 74.95,123.55 74.71,123.31
  IN2 w0.14: v2(81.54,145.56) 81.54,145.56 81.13,145.16 80.58,145.16 80.38,144.95 80.38,144.66 80.4,144.63 80.4,143.7 80.38,143.68 80.38,141.46 78.16,139.24 78.16,130.17 76.88,128.89 76.88,125.48 74.95,123.55 ; 74.71,123.31 74.71,122.86 74.71,122.86 74.71,122.49 73.98,121.76 72.9,121.76 72.65,121.51 v2(72.31,121.51)
VMB_DQ35: length 28.3
  TOP w0.168: v2(70.9,121.54) 70.9,121.54 70.89,121.53 70.89,121.5 70.88,121.5 70.56,121.24 UG1.M49 ; v2(80,142.53) VRAM4.B4
  IN4 w0.102: 71.44,121.09 72.52,121.09 72.75,121.32 72.75,121.6 72.93,121.78 73.82,121.78 75.36,123.32
  IN4 w0.127: 71.44,121.09 71.05,121.49 71.01,121.49 70.95,121.54 v2(70.9,121.54) ; 75.36,123.32 76.07,124.03 76.07,124.4 78.64,126.98 78.64,138.35 80.38,140.09 80.38,142.16 v2(80,142.53)
VMB_DQ36: length 33.7
  TOP w0.168: VRAM4.B2 81.88,142.91 v2(82.25,143.28) ; v2(68.8,119.39) 68.81,119.4 68.81,119.41 UG1.P47
  IN4 w0.102: 75.56,121.24 74.32,120.01 73.54,120.01 73.27,119.74 69.89,119.74 69.86,119.77 69.2,119.77 68.82,119.39 v2(68.8,119.39)
  IN4 w0.127: 75.56,121.24 80.83,126.51 80.83,131.4 82.63,133.21 82.63,142.91 v2(82.25,143.28)
VMB_DQ37: length 34.4
  TOP w0.168: VRAM4.F2 81.88,145.91 v2(82.25,146.28) ; v2(73.17,119.23) UG1.P52
  IN4 w0.102: v2(73.17,119.23) 73.2,119.23 73.39,119.04 73.84,119.04 74.3,119.5 74.9,119.5
  IN4 w0.127: 74.9,119.5 81.57,126.17 81.57,131.22 83.4,133.05 83.4,145.76 83.25,145.91 82.63,145.91 v2(82.25,146.28)
VMB_DQ38: length 42.1
  TOP w0.168: v2(81.57,147.03) 81.57,146.97 81.88,146.66 VRAM4.G2 ; UG1.R46 68.41,119.05 v2(68.1,118.74)
  IN4 w0.127: v2(68.1,118.74) 68.38,119.02 69.82,119.02 69.83,119 71.18,119 71.38,119.2 72.51,119.2 73.02,118.68 74.03,118.68 74.33,118.98 75.19,118.98 82.21,126 82.21,130.83 84,132.63 84,145.91 83.25,146.66 82.41,146.66 82.41,146.66 82.1,146.66 82.1,146.66 81.93,146.66 v2(81.57,147.03)
VMB_DQ39: length 35.1
  TOP w0.168: v2(68.08,120.13) 68.11,120.11 68.11,120.09 68.45,119.75 UG1.P46 ; v2(80.75,144.78) 81.13,145.16 VRAM4.E3
  IN2 w0.14: v2(80.75,144.78) 81.14,144.4 81.14,141.17 78.83,138.86 78.83,129.87 77.58,128.63 77.58,125.41 75.18,123 75.18,122.27 73.86,120.96 72.36,120.96 71.71,120.32 71.36,120.32 71.03,120.65 70.63,120.65 70.45,120.47 69.91,120.47 69.75,120.63 69.41,120.63 69.12,120.34 69.12,119.99 68.93,119.81 68.41,119.81 v2(68.08,120.13)
VMB_DQ40: length 24.9
  TOP w0.168: v2(71.51,122.32) 71.5,122.28 71.37,122.22 UG1.L50 ; VRAM4.B12 v2(74.75,143.28)
  IN1 w0.127: v2(71.51,122.32) 71.53,122.32 71.57,122.36 72.52,122.36 72.86,122.7 72.86,123.14 72.79,123.21 72.79,124.06 73.04,124.3 73.85,124.3 75.28,125.73 75.28,140.96 75.13,141.11 75.13,142.72 74.75,143.1 v2(74.75,143.28)
VMB_DQ41: length 28
  TOP w0.168: v2(74.75,144.78) 74.38,145.16 VRAM4.E12 ; UG1.L51 72.08,121.85 73.02,122.8 73.9,122.8 v2(74.12,122.58)
  IN1 w0.127: v2(74.75,144.78) 75.13,144.41 75.73,144.41 75.87,144.27 75.87,143.15 76.22,142.8 76.6,142.8 76.92,142.48 76.92,141.54 76.39,141 76.39,125.34 74.11,123.06 74.11,122.82 v2(74.12,122.58)
VMB_DQ42: length 22.9
  TOP w0.168: VRAM4.B11 75.51,142.52 v2(75.51,142.52) ; v2(73.11,122.16) 72.8,121.85 UG1.L52
  IN1 w0.127: v2(75.51,142.52) 75.54,142.52 75.99,142.06 75.99,141.62 75.86,141.48 75.86,125.56 73.36,123.06 73.36,122.4 v2(73.11,122.16)
VMB_DQ43: length 23.9
  TOP w0.168: v2(70.12,122.33) 70.21,122.22 70.26,122.21 UG1.L49 ; v2(74.75,141.72) 74.6,141.87 74.6,141.93 74.38,142.16 VRAM4.A12
  IN1 w0.127: v2(70.12,122.33) 70.31,122.33 70.63,122.65 70.63,123.11 70.76,123.24 71.83,123.24 71.96,123.37 71.96,123.92 72.76,124.71 73.17,124.71 74.74,126.29 74.74,140.44 74.34,140.84 74.34,141.32 74.74,141.72 v2(74.75,141.72)
VMB_DQ44: length 35.4
  TOP w0.168: v2(68.09,121.47) 68.45,121.15 UG1.M46 ; VRAM4.E13 73.69,145.16 74.01,145.48 v2(74.01,145.53)
  IN1 w0.127: v2(74.01,145.53) 74.01,145.48 74.33,145.15 76.55,145.15 76.71,144.99 76.71,143.44 77.46,142.7 77.46,141.32 76.92,140.78 76.92,125.12 74.65,122.84 74.65,122.36 74.06,121.77 72.85,121.77 72.62,122 71.88,122 71.81,121.93 70.57,121.93 70.47,121.83 69.91,121.83 69.76,121.97 69.39,121.97 68.89,121.47 v2(68.09,121.47)
VMB_DQ45: length 26.9
  TOP w0.168: UG1.L47 69.08,121.85 67.83,123.12 v2(67.84,123.51) ; VRAM4.B13 v2(74,142.53)
  IN1 w0.127: v2(67.84,123.51) 69.43,123.51 69.91,123.98 71.33,123.98 72.76,125.41 72.76,125.77 73.13,126.14 73.57,126.14 74.21,126.78 74.21,140.05 73.63,140.63 73.63,142.16 v2(74,142.53)
VMB_DQ46: length 35.8
  TOP w0.168: UG1.M48 70.18,120.85 v2(70.2,120.85) ; VRAM4.F13 73.6,145.91 v2(73.23,146.28)
  IN1 w0.127: v2(73.23,146.28) 73.6,145.91 76.88,145.91 77.25,145.55 77.25,143.66 77.99,142.92 77.99,141.09 77.46,140.56 77.46,124.89 75.18,122.62 75.18,122.14 74.02,120.97 72.41,120.97 72.32,121.06 70.41,121.06 v2(70.2,120.85)
VMB_DQ47: length 39.3
  TOP w0.168: UG1.M47 68.8,120.86 v2(68.8,120.84) ; VRAM4.G13 v2(74,147.03)
  IN1 w0.127: v2(68.8,120.84) 68.85,120.88 69.51,120.88 69.91,120.48 70.42,120.48 70.61,120.67 71.02,120.67 71.48,120.2 72,120.2 72.17,120.03 73.24,120.03 73.61,120.4 74.2,120.4 75.72,121.91 75.72,122.4 77.99,124.67 77.99,140.34 78.52,140.87 78.52,143.14 77.78,143.88 77.78,146.24 77.09,146.93 75.88,146.93 75.62,146.67 75.15,146.67 74.79,147.03 v2(74,147.03)
VMB_DQ48: length 37.8
  TOP w0.102: v2(68.8,126.43) 68.8,126.43 68.84,126.38 69.48,126.38 UG1.D48
  TOP w0.168: v2(74.77,155.87) 74.77,155.3 VRAM4.V12
  IN1 w0.127: v2(68.8,126.43) 68.8,126.43 68.8,127.73 67.48,129.05 67.48,138.18 67.32,138.34 67.32,151.76 67.53,151.96 68.05,151.96 68.43,152.34 68.96,153.56 70.69,155.41 72.07,156.08 74.55,156.08 v2(74.77,155.87)
VMB_DQ49: length 27.9
  TOP w0.168: v2(71.57,127.83) 71.57,127.82 71.57,127.77 UG1.C50 ; v2(74,151.53) VRAM4.P12
  IN1 w0.127: v2(71.57,127.83) 71.57,129.93 71.69,130.04 71.69,135.65 70.3,137.05 70.3,146.43 70.53,146.66 70.53,147.61 71.32,148.4 71.32,149.13 71.55,149.36 71.85,149.36 72.11,149.62 72.11,150.96 72.31,151.15 73.63,151.15 v2(74,151.53)
VMB_DQ50: length 31.9
  TOP w0.168: UG1.C48 70.21,127.81 v2(70.21,127.81) ; v2(73.98,154.49) 74,154.49 73.67,154.16 VRAM4.U13
  IN2 w0.14: v2(70.21,127.81) 70.21,127.81 70.37,127.97 70.37,140.32 70.25,140.44 70.25,144.68 69.97,144.97 69.97,148.06 70.49,148.58 70.49,150.81 70.28,151.01 70.28,152.36 71.18,153.26 71.18,154.39 71.85,155.05 73.44,155.05 74,154.49 v2(73.98,154.49)
VMB_DQ51: length 28.7
  TOP w0.102: v2(70.91,128.49) 70.9,128.49 70.9,127.8 UG1.C49
  TOP w0.168: v2(73.25,152.28) VRAM4.P13
  IN1 w0.102: 69.77,130.12 69.77,129.62 v2(70.9,128.49)
  IN1 w0.127: 69.77,130.12 69.77,146.66 70,146.88 70,147.83 70.79,148.63 70.79,150.66 71.47,151.35 71.47,152.22 71.92,152.66 72.88,152.66 v2(73.25,152.28)
VMB_DQ52: length 33.6
  TOP w0.168: UG1.E49 70.2,126.4 v2(70.2,126.45) ; v2(74.75,153.78) VRAM4.U12
  IN1 w0.127: v2(74.75,153.78) 74.54,153.78 74.16,153.41 71.6,153.41 69.85,151.66 69.85,150.67 69.7,150.52 69.7,149.8 70.25,149.25 70.25,148.85 69.46,148.05 69.46,147.11 69.24,146.89 69.24,129.43 70.68,127.98 70.68,127.5 70.54,127.36 70.54,126.82 70.2,126.48 v2(70.2,126.45)
VMB_DQ53: length 27
  TOP w0.168: UG1.E50 71.6,126.4 71.6,126.43 v2(71.6,126.43) ; v2(73.26,150.74) 73.26,150.79 VRAM4.N13
  IN1 w0.127: v2(71.61,126.43) 71.76,126.43 72.08,126.76 72.56,126.76 72.71,126.91 72.71,139.19 72.02,139.88 72.02,147.08 72.24,147.3 72.24,147.67 72.88,148.31 72.88,150.36 v2(73.26,150.74)
VMB_DQ54: length 28.7
  TOP w0.168: VRAM4.M13 v2(74,150.03) ; UG1.F49 70.89,125.69 v2(70.89,125.69)
  IN1 w0.127: v2(74,150.03) 73.63,149.66 73.63,147.77 73.29,147.43 73.03,147.43 72.83,147.23 72.83,140.11 73.57,139.36 73.57,127.54 73.01,126.97 73.01,126.9 73.01,126.9 73.01,126.34 72.53,125.86 72.53,125.67 72.16,125.29 71.3,125.29 v2(70.89,125.69)
VMB_DQ55: length 38.8
  TOP w0.168: v2(75.5,154.53) 75.13,154.16 VRAM4.U11 ; v2(70.14,124.99) 70.14,124.99 70.14,125.06 UG1.F48
  IN2 w0.14: v2(75.5,154.53) 75.34,154.53 74.4,155.47 74.4,155.82 74.23,155.99 71.61,155.99 70.45,154.84 70.45,153.51 69.47,152.53 69.47,150.14 70.06,149.56 70.06,148.78 69.39,148.11 69.39,140.43 69.73,140.09 69.73,129.76 70.13,129.36 70.13,128.38 69.74,127.99 69.74,125.4 70.14,124.99 v2(70.14,124.99)
VMB_DQ56: length 36.4
  TOP w0.168: VRAM4.P3 81.13,151.91 v2(80.75,152.28) ; v2(71.55,124.91) 71.55,124.91 UG1.F50
  IN2 w0.14: v2(71.55,124.91) 71.85,124.91 73.02,126.08 73.36,126.08 73.79,126.51 73.79,130.24 74.69,131.14 74.69,139.51 73.63,140.58 73.63,147.28 73.79,147.44 74.31,147.44 74.5,147.25 75.03,147.25 75.88,148.1 75.88,150.62 77.17,151.91 80.18,151.91 80.55,152.28 v2(80.75,152.28)
VMB_DQ57: length 33.6
  TOP w0.168: v2(73.19,127.7) 73.19,127.29 UG1.D52 ; v2(80.75,153.78) 81.13,154.16 VRAM4.U3
  IN4 w0.102: v2(73.19,127.7) 73.2,127.7 73.63,128.12 73.63,130.19
  IN4 w0.127: v2(80.75,153.78) 80.38,153.41 78.9,153.41 77.61,152.13 77.61,149.83 77.91,149.53 77.91,146.7 76.37,145.16 73.75,145.16 73.63,145.03 73.63,130.19
VMB_DQ58: length 34.7
  TOP w0.168: VRAM4.M2 81.88,150.41 v2(81.5,150.03) ; UG1.J50 71.26,123.14 v2(71,122.82)
  IN4 w0.102: 74.56,124.98 73.87,124.29 72.5,124.29 71.99,123.78 71.99,123.37 71.83,123.21 71.27,123.21 71,122.93 v2(71,122.82)
  IN4 w0.127: 74.56,124.98 74.56,125.75 76.36,127.56 76.36,140.26 77.94,141.84 77.94,144.88 78.97,145.91 80.16,145.91 80.38,146.13 80.38,146.65 80.26,146.77 80.26,147.36 80.38,147.49 80.38,147.94 80.6,148.16 80.91,148.16 81.13,148.38 81.13,149.66 v2(81.5,150.03)
VMB_DQ59: length 41.2
  TOP w0.168: UG1.H48 v2(69.51,124.29) ; v2(81.5,154.53) 81.13,154.91 VRAM4.V3
  IN4 w0.102: 72.07,131.75 72.07,129.86 71.74,129.53 71.74,129.34 71.31,128.9 70.62,128.9 69.74,128.02 69.74,125.23 69.57,125.06 69.57,124.35 v2(69.51,124.29)
  IN4 w0.127: v2(81.5,154.53) 81.12,154.91 78.67,154.91 76.89,153.13 76.89,149.57 76.68,149.36 76.68,147.63 75.62,146.57 75.23,146.57 75.14,146.65 72.13,146.65 71.84,146.36 71.84,142.39 72.07,142.15 72.07,131.75
VMB_DQ60: length 33.2
  TOP w0.168: UG1.H51 72.67,124.67 v2(73.69,124.67) ; VRAM4.N2 81.88,151.16 v2(82.25,150.78)
  IN4 w0.102: 75.56,127.51 73.69,125.64 v2(73.69,124.67)
  IN4 w0.127: 75.56,127.51 75.75,127.7 75.75,140.45 77.52,142.22 77.52,144.91 79.63,147.02 79.63,148.75 79.79,148.91 80.22,148.91 80.38,149.08 80.38,150.19 80.6,150.41 80.6,150.41 80.91,150.41 80.91,150.41 81.35,150.41 81.35,150.41 81.66,150.41 81.66,150.41 81.88,150.41 v2(82.25,150.78)
VMB_DQ61: length 37.9
  TOP w0.168: v2(81.5,151.53) 81.88,151.91 VRAM4.P2 ; v2(72.38,122.78) UG1.J51
  IN2 w0.14: v2(72.38,122.78) 72.79,123.2 72.79,123.98 73.11,124.29 73.89,124.29 74.71,125.12 74.71,125.52 75.42,126.23 75.42,129.79 76.29,130.66 76.29,139.9 75.12,141.08 75.12,144.98 75.3,145.16 76.49,145.16 77.48,146.15 77.48,150.01 78.27,150.8 79.14,150.8 79.52,150.41 80.91,150.41 81.14,150.65 81.14,150.99 81.5,151.35 v2(81.5,151.53)
VMB_DQ62: length 38.5
  TOP w0.168: v2(70.97,124.35) 70.95,124.35 70.55,123.95 UG1.H49 ; VRAM4.U4 v2(80,154.53)
  IN4 w0.102: 72.84,130.98 72.84,129.19 72.72,129.07 72.72,126.19 71.84,125.31 70.91,125.31 70.6,124.99 70.6,124.72 v2(70.97,124.35)
  IN4 w0.127: v2(80,154.53) 79.63,154.16 78.78,154.16 77.21,152.59 77.21,149.54 77.5,149.25 77.5,147.19 77.17,146.87 76.43,146.87 75.46,145.9 73.06,145.9 72.84,145.68 72.84,130.98
VMB_DQ63: length 40.3
  TOP w0.168: VRAM4.U2 81.88,154.16 v2(82.25,153.78) ; v2(73.17,123.53) 73.16,123.6 UG1.H52
  IN4 w0.102: 73.28,123.48 73.67,123.48 74.81,124.62 74.81,125.25 75.56,126
  IN4 w0.127: 75.56,126 76.99,127.42 76.99,139.81 78.56,141.38 78.56,144.68 78.72,144.84 79.65,144.84 79.97,145.17 80.92,145.17 81.14,145.39 81.14,147.2 81.35,147.41 82.43,147.41 82.63,147.61 82.63,151.77 82.76,151.89 83.56,151.89 83.87,152.2 83.87,153.64 83.35,154.16 82.63,154.16 v2(82.25,153.78) ; 73.28,123.48 73.23,123.53 v2(73.17,123.53)
VMB_WCK01: length 38.3
  TOP w0.122: v2(59.69,122.89) 59.35,123.25 UG1.J33 ; VRAM3.D4 v2(60.2,153.03)
  IN1 w0.114: v2(59.69,122.89) 59.67,122.9 59.33,123.49 59.33,123.78 59.02,124.08 59.02,124.52 59.8,125.29 60.27,125.29 60.56,125.57 60.56,126.01 60.9,126.35 60.9,128.04 61.54,128.69 61.54,136 56.55,140.99 56.55,146.5 57.47,147.42 60.35,147.42 60.56,147.64 60.56,152.46 60.34,152.68 60.34,152.89 v2(60.2,153.03)
VMB_WCK01#: length 38.5
  TOP w0.102: VRAM3.D5 60.74,152.49 60.96,152.49 61.06,152.6 61.06,152.89 v2(60.92,153.03)
  TOP w0.122: UG1.H33 59.35,123.95 59.35,123.72 59.47,123.6 v2(59.7,123.6)
  IN1 w0.102: 61.77,130.12 61.77,128.61 61.72,128.56
  IN1 w0.114: 61.72,128.56 61.11,127.95 61.11,126.26 60.77,125.92 60.77,125.48 60.36,125.07 59.88,125.07 59.25,124.44 59.25,124.16 59.7,123.71 v2(59.7,123.6) ; 61.77,130.12 61.77,136.1 56.78,141.08 56.78,146.41 57.57,147.19 60.44,147.19 60.79,147.54 60.79,152.55 60.57,152.77 60.57,152.92 60.69,153.03 v2(60.92,153.03)
VMB_WCK23: length 26.1
  TOP w0.122: v2(63.87,122.88) 63.87,122.93 UG1.J39 ; VRAM3.R11 65.07,144.44 64.76,144.75 64.76,144.76 v2(64.74,144.78)
  IN4 w0.102: v2(63.87,122.88) 64.71,122.88 64.94,123.11 64.94,123.72 65.39,124.17 65.39,125.08 64.96,125.51 64.96,125.84 65.23,126.11 65.23,127.72 65.02,127.93 65.02,131.65 65.05,131.68
  IN4 w0.114: v2(64.74,144.78) 64.73,144.77 64.72,144.77 64.1,144.14 63.68,144.14 63.35,143.81 63.35,142.02 63.57,141.8 63.57,140.99 63.58,140.97 63.58,140.9 65.24,139.24 65.24,131.92 65.22,131.91 65.22,131.85 65.05,131.68
VMB_WCK23#: length 26.3
  TOP w0.122: v2(63.87,123.58) 63.87,123.63 UG1.H39 ; v2(63.76,144.85) 64.2,144.41 VRAM3.R10
  IN4 w0.102: 64.89,131.84 64.81,131.77 64.81,127.85 65.03,127.63 65.03,126.19 64.76,125.92 64.76,125.42 65.19,124.99 65.19,124.25 64.73,123.8 64.73,123.19 64.62,123.08 64.22,123.08 63.87,123.43 v2(63.87,123.58)
  IN4 w0.114: 64.89,131.84 64.99,131.95 64.99,132 65.01,132.02 65.01,139.15 63.36,140.8 63.36,141.71 63.13,141.94 63.13,143.9 63.59,144.36 64.01,144.36 64.08,144.43 64.08,144.53 v2(63.76,144.85)
VMB_WCK45: length 32.7
  TOP w0.122: v2(80.04,144.05) 80.38,144.39 VRAM4.D4 ; UG1.L46 68.45,121.85 68.08,122.16 v2(68.07,122.22)
  IN4 w0.102: 75.56,124.78 75.54,124.77 75.52,124.77 75.38,124.62 75.38,124.21 74.13,122.96 73.39,122.96 72.57,122.14 72.32,122.14 71.89,121.71 71.32,121.71 71.04,121.99 70.65,121.99 70.34,121.68 69.94,121.68 69.72,121.9 69.04,121.9 68.26,122.68 67.93,122.68 67.84,122.59 67.84,122.45 v2(68.07,122.22)
  IN4 w0.114: v2(80.04,144.05) 79.84,144.05 79.69,143.9 79.69,143.56 79.57,143.43 79.57,140.89 77.97,139.29 77.97,127.19 75.56,124.78
VMB_WCK45#: length 32.6
  TOP w0.122: VRAM4.D5 79.61,144.43 79.42,144.43 79.29,144.3 79.29,144.04 v2(79.3,144.03) ; UG1.L45 67.75,121.85 v2(67.41,122.22)
  IN4 w0.102: 75.4,124.95 75.38,124.93 75.38,124.91 75.17,124.7 75.17,124.29 74.04,123.16 73.31,123.16 72.49,122.35 72.24,122.35 71.8,121.91 71.41,121.91 71.13,122.2 70.57,122.2 70.26,121.88 70.02,121.88 69.8,122.1 69.13,122.1 68.34,122.89 67.85,122.89 67.64,122.68 67.64,122.45 v2(67.41,122.22)
  IN4 w0.114: 75.4,124.95 77.74,127.29 77.74,139.38 79.34,140.99 79.34,141.86 79.34,141.87 79.35,141.88 79.35,143.52 79.48,143.65 79.48,143.92 79.39,144.01 79.31,144.01 v2(79.3,144.03)
VMB_WCK67: length 41.7
  TOP w0.122: v2(68.57,124.41) 68.6,124.38 68.64,124.38 UG1.H47 ; v2(75.5,152.28) 75.13,152.66 VRAM4.R11
  IN1 w0.114: v2(68.57,124.41) 68.6,124.38 68.77,124.38 69.54,125.15 69.54,127.84 68.38,129.01 68.38,150.78 69,151.4 69,152.06 69.36,152.43 69.36,152.54 70.95,154.13 71.12,154.13 72.21,155.23 75.66,155.23 76.12,154.77 76.12,152.82 75.88,152.57 75.76,152.57 75.5,152.31 v2(75.5,152.28)
VMB_WCK67#: length 41.7
  TOP w0.122: v2(75.49,153.04) 75.88,152.66 VRAM4.R10 ; v2(68,124.17) 68,124.15 68.08,124.08 UG1.H46
  IN1 w0.114: v2(68,124.17) 68,124.15 68.25,123.9 68.91,123.9 69.14,124.13 69.14,124.44 69.76,125.06 69.76,127.93 68.61,129.08 68.61,150.69 69.22,151.3 69.22,151.97 69.59,152.34 69.59,152.45 71.05,153.9 71.21,153.9 72.31,155 75.57,155 75.89,154.67 75.89,152.91 75.78,152.8 75.69,152.8 75.49,153 v2(75.49,153.04)
VMB_WCKB01: length 39.9
  TOP w0.122: UG1.G35 60.71,124.65 v2(60.37,124.32) ; VRAM3.D11 64.7,153.03 v2(64.7,153.04)
  IN2 w0.102: v2(60.37,124.32) 60.6,124.55 60.6,124.69 60.44,124.85 60.44,125.36 60.57,125.48 60.57,125.92 61,126.35 61,128.84 61.93,129.77 61.93,134.56 56.72,139.77 56.72,141.15 56.34,141.53 56.34,146.23 56.97,146.86 59.8,146.86 60.59,147.65 60.59,150.04 60.99,150.44 61.63,150.44 63.1,151.91 63.1,153.12 63.6,153.62 64.18,153.62 64.4,153.4 64.4,153.24 64.6,153.04 v2(64.7,153.04)
VMB_WCKB01#: length 40
  TOP w0.122: VRAM3.D10 63.95,153.03 v2(63.95,153.04) ; v2(60.39,123.59) UG1.H35
  IN2 w0.102: v2(63.95,153.04) 64.06,153.04 64.19,153.17 64.19,153.31 64.09,153.42 63.68,153.42 63.3,153.04 63.3,151.82 61.71,150.24 61.07,150.24 60.79,149.96 60.79,147.57 59.88,146.66 57.06,146.66 56.55,146.15 56.55,141.62 56.92,141.24 56.92,139.85 62.13,134.64 62.13,129.69 61.2,128.76 61.2,126.27 60.77,125.84 60.77,125.39 60.65,125.27 60.65,124.93 60.83,124.75 60.83,124.66 60.83,124.66 60.83,124.5 60.79,124.45 60.79,124.45 60.73,124.39 60.73,124.14 60.44,123.64 60.42,123.6 v2(60.39,123.59)
VMB_WCKB23: length 24.9
  TOP w0.122: v2(64.57,124.97) 64.6,125 64.6,125 UG1.F41 ; VRAM3.R4 v2(60.2,144.78)
  IN2 w0.102: v2(60.2,144.78) 60.34,144.78 60.45,144.68 60.45,144.48 60.7,144.23 61.31,144.23 61.49,144.05 61.49,140.79 65.67,136.6 65.67,127.91 65.56,127.8 65.56,126.76 65.4,126.59 65.4,126.58 64.79,125.97 64.79,125.29 64.97,125.12 64.97,124.81 64.85,124.69 64.64,124.69 64.53,124.79 64.53,124.94 v2(64.57,124.97)
VMB_WCKB23#: length 25
  TOP w0.122: VRAM3.R5 v2(60.95,144.79) ; v2(64.62,124.32) UG1.G41
  IN2 w0.102: v2(64.62,124.32) 64.79,124.49 64.93,124.49 65.17,124.73 65.17,125.2 64.99,125.38 64.99,125.88 65.6,126.49 65.6,126.51 65.77,126.68 65.77,127.72 65.88,127.83 65.88,136.69 61.69,140.88 61.69,144.13 61.39,144.43 60.78,144.43 60.65,144.56 60.65,144.7 60.74,144.79 v2(60.95,144.79)
VMB_WCKB45: length 32.4
  TOP w0.122: v2(75.5,144.04) 75.13,144.41 VRAM4.D11 ; v2(66.72,120.82) 66.72,120.88 67.05,121.15 UG1.M44
  IN2 w0.102: v2(66.72,120.82) 66.73,120.88 67.31,121.22 67.83,121.22 67.93,121.12 68.27,121.12 68.59,121.44 69.08,121.44 69.37,121.16 69.68,121.16 70.65,122.13 71.17,122.13 71.34,121.96 71.86,121.96 72.29,122.39 72.51,122.39 72.94,122.83 73.44,122.83 74.14,123.53 74.14,123.92 76.05,125.82 76.05,129.39 77.13,130.46 77.13,140 75.87,141.25 75.87,143.66 v2(75.5,144.04)
VMB_WCKB45#: length 32.6
  TOP w0.122: v2(76.29,144.04) 75.88,144.41 VRAM4.D10 ; UG1.M45 67.89,121.15 67.98,121.05 67.98,120.91 67.86,120.79 67.45,120.79 v2(67.42,120.82)
  IN2 w0.102: v2(67.42,120.82) 67.42,120.93 67.51,121.02 67.74,121.02 67.85,120.91 68.35,120.91 68.68,121.24 69,121.24 69.28,120.96 69.76,120.96 70.73,121.93 71.09,121.93 71.25,121.76 71.95,121.76 72.38,122.19 72.59,122.19 73.03,122.62 73.53,122.62 74.34,123.44 74.34,123.83 76.25,125.74 76.25,129.3 77.33,130.38 77.33,140.08 76.08,141.33 76.08,143.83 v2(76.29,144.04)
VMB_WCKB67: length 48.1
  TOP w0.122: v2(80,153.03) VRAM4.R4 ; v2(69.47,122.92) 69.15,123.19 UG1.J47
  IN2 w0.102: v2(80,153.03) 79.71,152.73 79.71,152.53 79.48,152.3 78.73,152.3 78.12,152.91 78.12,154.28 75.87,156.53 71.21,156.53 68.57,153.9 68.57,140.22 69.1,139.69 69.1,129.37 69.43,129.04 69.43,124.75 69.14,124.45 69.14,123.25 v2(69.47,122.92)
VMB_WCKB67#: length 48.1
  TOP w0.122: UG1.J46 68.56,123.25 68.69,123.12 v2(68.85,122.91) ; VRAM4.R5 79.58,152.66 v2(79.21,153.03)
  IN2 w0.102: v2(79.21,153.03) 79.51,152.74 79.51,152.61 79.4,152.51 78.82,152.51 78.33,153 78.33,154.37 75.96,156.74 71.12,156.74 68.37,153.98 68.37,140.13 68.89,139.61 68.89,129.29 69.23,128.96 69.23,124.83 68.93,124.54 68.93,123.04 68.85,122.96 v2(68.85,122.91)
VMC_CLK0: length 33.8
  TOP w0.122: UG1.G15 46.88,124.53 47.07,124.36 v2(47.11,124.36) ; v2(33.33,149.28) VRAM1.J10
  IN1 w0.114: v2(33.33,149.28) 33.33,149.08 33.23,148.97 32.93,148.97 32.68,148.72 32.68,147.43 33.5,146.61 33.5,145.17 33.38,145.05 33.38,144.22 33.5,144.1 33.5,141.01 39.22,135.29 41.06,135.29 46.59,129.76 46.59,127.25 46.84,127.01 46.84,126.28 46.51,125.95 46.51,125.38 46.76,125.12 46.76,124.71 v2(47.11,124.36)
VMC_CLK0#: length 33.8
  TOP w0.102: UG1.F15 46.72,125.32 46.72,125.07 46.85,124.94 v2(47.14,124.94)
  TOP w0.122: v2(33.33,148.53) 33.3,148.49 33.3,148.32 33.49,148.12 33.67,148.12 VRAM1.K10
  IN1 w0.102: 44.88,131.79 46.81,129.87 46.81,127.34 47.05,127.1 47.05,126.19 46.73,125.86 46.73,125.46 46.89,125.3 47.05,125.3 47.17,125.41 47.35,125.41 47.43,125.33 47.43,125.21 47.17,124.94 v2(47.14,124.94)
  IN1 w0.114: 44.88,131.79 41.15,135.52 39.31,135.52 33.73,141.11 33.73,144.2 33.61,144.32 33.61,144.95 33.73,145.08 33.73,146.7 32.91,147.52 32.91,148.63 33.03,148.74 33.24,148.74 33.27,148.72 33.33,148.65 v2(33.33,148.53)
VMC_CLK1: length 35.9
  TOP w0.122: v2(45.61,147.82) 45.38,147.82 45.26,147.94 VRAM2.J10 ; v2(51.28,123.61) 51.27,123.62 51.23,123.62 UG1.H21
  IN4 w0.102: 48.92,131.84 48.92,129.11 50.02,128.01 50.02,126.56 50.51,126.06 50.51,125.5 49.53,124.52 49.53,124.19 50.19,123.53 50.19,123.38 50.39,123.19 50.67,123.19 50.8,123.32 51.16,123.32 51.28,123.43 v2(51.28,123.61)
  IN4 w0.114: v2(45.61,147.82) 45.65,147.85 45.65,148.07 45.53,148.18 45.32,148.18 44.84,147.7 44.84,147.63 44.39,147.17 43.85,147.17 43.5,147.53 42.34,147.53 41.25,146.45 41.25,141 48.92,133.33 48.92,131.84
