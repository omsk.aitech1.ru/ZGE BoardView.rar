# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PC350  EV@330u/2V_7343H1.9  [CC7343]  32.91 70.15 270 bottom
PC351  G3@330u/2V_7343H1.9  [CC7343]  28.09 70.15 270 bottom
PC352  G3@330u/2V_7343H1.9  [CC7343]  23.26 70.15 270 bottom
PC353  G3@10u/25V_8  [C0805]  41.55 61 270 bottom
PC354  G3@10u/25V_8  [C0805]  31.9 61 270 bottom
PC355  G3@2.2u/10V_4  [C0402]  22.51 59.09 270 bottom
PC356  10u/25V_8  [C0805]  233.57 59.47 180 bottom
PC357  EV@10u/25V_8  [C0805]  85.21 58.92 270 bottom
PC358  EV@10u/25V_8  [C0805]  75.56 58.92 270 bottom
PC359  EV@10u/25V_8  [C0805]  65.91 58.92 270 bottom
PC360  EV@10u/25V_8  [C0805]  56.25 58.92 270 bottom
PC361  EV@10u/25V_8  [C0805]  46.6 58.92 270 bottom
PC362  EV@10u/25V_8  [C0805]  36.95 58.92 270 bottom
PC363  G3@10u/25V_8  [C0805]  27.3 58.92 270 bottom
PC364  EV@10u/25V_8  [C0805]  82.57 58.84 270 bottom
PC365  EV@10u/25V_8  [C0805]  72.92 58.84 270 bottom
PC366  EV@10u/25V_8  [C0805]  63.26 58.84 270 bottom
PC367  EV@10u/25V_8  [C0805]  53.61 58.84 270 bottom
PC368  EV@10u/25V_8  [C0805]  43.96 58.84 270 bottom
PC369  EV@10u/25V_8  [C0805]  34.31 58.84 270 bottom
PC370  G3@10u/25V_8  [C0805]  24.91 59.02 270 bottom
PC371  EV@2.2u/10V_4  [C0402]  88.08 58.82 0 bottom
PC372  EV@2.2u/10V_4  [C0402]  78.43 58.82 0 bottom
PC373  EV@2.2u/10V_4  [C0402]  68.78 58.82 0 bottom
PC374  EV@2.2u/10V_4  [C0402]  59.12 58.82 0 bottom
PC375  EV@2.2u/10V_4  [C0402]  49.47 58.82 0 bottom
PC376  EV@2.2u/10V_4  [C0402]  39.82 58.82 0 bottom
PC377  G3@2.2u/10V_4  [C0402]  30.17 58.82 0 bottom
PC378  G3@2.2u/10V_4  [C0402]  22.88 61.26 270 bottom
PC379  *0.1u/50V_4  [C0402]  225.7 57.83 90 bottom
PC380  EV@2.2u/10V_4  [C0402]  88.08 57.67 0 bottom
PC381  EV@2.2u/10V_4  [C0402]  78.43 57.67 0 bottom
PC382  EV@2.2u/10V_4  [C0402]  68.78 57.67 0 bottom
PC383  EV@2.2u/10V_4  [C0402]  59.12 57.67 0 bottom
PC384  EV@2.2u/10V_4  [C0402]  49.47 57.67 0 bottom
PC385  EV@2.2u/10V_4  [C0402]  39.82 57.67 0 bottom
PC386  G3@2.2u/10V_4  [C0402]  30.17 57.67 0 bottom
PC387  1u/25V_4  [C0402]  233.93 55.59 180 bottom
PC388  G3@0.1u/50V_4  [C0402]  25.62 55.19 90 bottom
PC389  EV@10u/25V_6  [C0603]  81.76 54.98 90 bottom
PC390  EV@10u/25V_6  [C0603]  72.66 55.03 90 bottom
PC391  EV@10u/25V_6  [C0603]  63.01 55.03 90 bottom
PC392  EV@10u/25V_6  [C0603]  53.36 55.03 90 bottom
PC393  EV@10u/25V_6  [C0603]  43.71 55.03 90 bottom
PC394  EV@10u/25V_6  [C0603]  34.05 55.03 90 bottom
PC395  G3@10u/25V_6  [C0603]  24.4 55.03 90 bottom
PC396  EV@0.1u/50V_4  [C0402]  83.08 54.88 90 bottom
PC397  EV@0.1u/50V_4  [C0402]  73.88 54.8 90 bottom
PC398  EV@0.1u/50V_4  [C0402]  64.23 54.8 90 bottom
PC399  EV@0.1u/50V_4  [C0402]  54.58 54.8 90 bottom
PC400  EV@0.1u/50V_4  [C0402]  44.93 54.8 90 bottom
PC401  EV@0.1u/50V_4  [C0402]  35.27 54.8 90 bottom
PC402  EV@0.1u/25V_6  [C0603]  66.36 54.73 0 bottom
PC403  EV@0.1u/25V_6  [C0603]  85.97 54.53 0 bottom
PC404  EV@0.1u/25V_6  [C0603]  75.99 54.58 0 bottom
PC405  EV@0.1u/25V_6  [C0603]  56.71 54.68 0 bottom
PC406  EV@0.1u/25V_6  [C0603]  47.06 54.68 0 bottom
PC407  EV@0.1u/25V_6  [C0603]  37.41 54.68 0 bottom
PC408  G3@0.1u/25V_6  [C0603]  27.76 54.68 0 bottom
PC409  *47p/50V_4  [C0402]  78.8 52.73 270 bottom
PC410  *47p/50V_4  [C0402]  75.69 53.16 0 bottom
PC411  *EV@1000p/50V_2  [C0201]  38.83 52.57 0 bottom
PC412  0.1u/50V_4  [C0402]  63.65 51.6 90 bottom
PC413  *100p/50V_4  [C0402]  64.92 51.6 270 bottom
PC414  *EV@1000p/50V_2  [C0201]  43.86 50.64 90 bottom
PC415  EV@220p/50V_2  [C0201]  46.81 47.92 0 bottom
PC416  *EV@47p/50V_2  [C0201]  46.5 40.09 180 bottom
PC417  *EV@47p/50V_2  [C0201]  45.23 38.65 180 bottom
PC418  EV@1000p/50V_2  [C0201]  44.34 35.86 270 bottom
PC419  EV@1000p/50V_2  [C0201]  43.33 35.86 270 bottom
PC420  EV@1000p/25V_2  [C0201]  44.09 33.06 270 bottom
PC421  EV@1000p/25V_2  [C0201]  43.07 33.06 270 bottom
PC422  EV@0.015u/25V_4  [C0402]  44.98 32.7 90 bottom
PC423  1000p/50V_2  [C0201]  241.22 28.74 90 bottom
PC424  1000p/50V_2  [C0201]  240.05 28.74 90 bottom
PC425  1000p/50V_2  [C0201]  79.09 28.67 90 bottom
PC426  1000p/50V_2  [C0201]  78.33 28.67 90 bottom
PC427  10u/6.3V_4  [C0402_2]  82.04 27.68 90 bottom
PC428  0.1u/50V_4  [C0402]  80.94 27.68 90 bottom
PC429  0.1u/50V_4  [C0402]  76.4 27.68 90 bottom
PC430  10u/6.3V_4  [C0402_2]  75.25 27.68 90 bottom
PC431  10u/6.3V_4  [C0402_2]  238.14 27.09 90 bottom
PC432  0.1u/50V_4  [C0402]  242.84 27.02 90 bottom
PC433  1u/25V_4  [C0402]  80.92 25.57 270 bottom
PC434  1u/25V_4  [C0402]  76.47 25.57 270 bottom
PC435  1u/25V_4  [C0402]  238.17 25.31 270 bottom
PC436  1u/25V_4  [C0402]  243.02 25.29 270 bottom
PC437  *0.1u/50V_4  [C0402]  80.27 23.66 90 bottom
PC438  0.1u/50V_4  [C0402]  77.97 23.61 90 bottom
PC439  0.1u/50V_4  [C0402]  240.94 23.41 90 bottom
PC440  *0.1u/50V_4  [C0402]  239.92 23.41 90 bottom
PC441  *0.1u/50V_4  [C0402]  75.71 23.11 180 bottom
PC442  22u/25V_8  [C0805]  222.5 58.85 90 top
PC443  10u/25V_8  [C0805]  233.58 57.49 180 bottom
PC444  EV@1u/25V_4  [C0402]  22.55 92.78 270 top
PC445  EV@10u/6.3V_6  [C0603]  21.86 98.49 180 top
PC447  *EV@0.1u/50V_4  [C0402]  22.58 94.79 180 bottom
PC448  EV@1000p/50V_4  [C0402]  20.54 95.14 0 bottom
PC449  0.47u/6.3V_2  [C0201]  163.49 26.19 90 top
PD1  P4SMAFJ20A  [D-3_8X2_5]  126.54 162.42 90 top
PD2  EV@1SS355  [D-SOD323-1_85X1_25-0_95H]  94.48 90.77 180 top
PD3  SS2040HE  [D-2_8X1_78]  226.08 59.25 0 top
PD4  PDZ5.6B  [D-SOD323-1_7X1_25-PMEG4005AEA]  75.33 52.37 270 top
PD5  PDZ5.6B  [D-SOD323-1_7X1_25-PMEG4005AEA]  77.74 52.37 90 top
PD6  BAT54CW  [SOT23-1_7-65-3P]  87.2 48.79 0 top
PD7  *EV@RB500V-40  [D-SOD323-1_85X1_25-0_95H]  30.66 39.97 0 top
PJ1  JPD113D-DB570-7H  [DCJK-JPD113D-DB570-7H-5P]  121.55 172.6 180 top
PJ22  50458-01001-V02  [WTB-50458-01001-V02-10P-L]  75.18 45.47 180 bottom
PL1  EV@0.36uH/30A_10x10x4  [L10X10-3_8]  31.77 166.79 270 top
PL2  4.7uH/3.5A_5x5x3  [L4_5X4_7-2_8H]  107.61 153.05 270 top
PL3  0.47uH/17.5A_7x7x3  [L6_6X6_6-6_05-2_8H]  122.88 152.26 270 top
PL4  0.22uH/50A_10x10x4  [L10X10-3_8]  132.17 150.92 270 top
PL5  0.22uH/50A_10x10x4  [L10X10-3_8]  143.33 150.92 270 top
PL6  0.22uH/50A_10x10x4  [L10X10-3_8]  154.53 150.92 270 top
PL7  0.22uH/50A_10x10x4  [L10X10-3_8]  165.42 150.92 270 top
PL8  EV@0.36uH/30A_10x10x4  [L10X10-3_8]  14.06 150.49 0 top
PL9  EV@1uH_5x5x1.8  [L5_1X5_2-1_6H]  10.58 87.62 90 top
PL10  2.2uH_2.5x2.0x1.2  [L2_5X2-1_2H]  98.52 71.44 270 top
PL11  G3@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  18.43 70.27 90 top
PL12  G3@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  28.09 70.27 90 top
PL13  EV@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  37.74 70.27 90 top
PL14  EV@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  47.39 70.27 90 top
PL15  EV@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  57.04 70.27 90 top
PL16  EV@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  66.69 70.27 90 top
PL17  EV@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  76.35 70.27 90 top
PL18  EV@0.22uH/45A_12x8x4  [L11_5X7_9-3_8H]  86 70.27 90 top
PL19  3.3uH_5x5x1.8  [L5_1X5_2-1_6H]  231.29 57.12 90 top
PL20  6.8uH_7x7x3  [L6_6X6_6-2_8H]  73.93 46.4 180 top
PL21  1uH_5x5x1.8  [L5_1X5_2-1_6H]  168.22 23.62 90 top
PL22  2.2uH_10x10x4  [L10X10-3_8]  107.22 16.3 270 top
PL23  2.2uH_10x10x4  [L10X10-3_8]  135.17 16.3 90 top
PL24  0.68uH/15.5A_7x7x3  [L6_6X6_6-2_8H]  169.57 14.15 90 top
PL25  1uH/11A_7x7x3  [L6_6X6_6-2_8H]  144.26 13.69 90 top
PQ1  EV@2N7002K  [SOT23-2-95-3P]  8.53 171.52 90 top
PQ2  EV@AOE6936  [POWER-5X6-1_27-10P]  23.13 170.86 270 top
PQ3  EV@AOE6936  [POWER-5X6-1_27-10P]  23.11 165.37 270 top
PQ4  AONS32304  [POWER-5_2X5_55-1_27-5P]  114.42 161.26 0 top
PQ5  AONS32304  [POWER-5_2X5_55-1_27-5P]  121.58 161.26 180 top
PQ6  EV@AOE6936  [POWER-5X6-1_27-10P]  9.67 159.17 180 top
PQ7  EV@AOE6936  [POWER-5X6-1_27-10P]  15.44 159.17 180 top
PQ8  *2N7002K  [SOT23-2-95-3P]  179.09 157.01 0 top
PQ9  2N7002K  [SOT23-2-95-3P]  180.61 152.82 0 top
PQ10  AO3404  [SOT23-2_38-95-3P]  177.06 151.81 270 top
PQ11  2N7002K  [SOT23-2-95-3P]  180.61 148.76 0 top
PQ12  EMF20B02V  [POWER-3X3-65-6P-0_9H]  105.94 144.69 180 top
PQ13  AO3414  [SOT23-2_38-95-3P]  112.46 140.06 0 top
PQ14  EV@2N7002K  [SOT23-2-95-3P]  109.57 95.83 0 top
PQ15  EV@DMG1012T-7  [SOT23-1_38-5-3P]  108.73 92.83 0 top
PQ16  EV@2N7002K  [SOT23-2-95-3P]  112.63 92.75 180 top
PQ17  EV@AON7408  [DFN-8L-3X3-65-5P-0_9H]  99.64 92.29 90 top
PQ18  2N7002KTB  [SOT23-1_38-5-3P]  214.22 60.39 180 top
PQ19  2N7002K  [SOT23-2-95-3P]  180.92 59.1 0 top
PQ20  AO3404  [SOT23-2_38-95-3P]  188.61 56.94 180 top
PQ21  2N7002K  [SOT23-2-95-3P]  184.8 55.16 270 top
PQ22  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  239.54 52.37 0 top
PQ23  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  182.43 52.11 0 top
PQ24  AONS32314  [POWER-5_2X5_55-1_27-5P]  190.12 49.48 180 top
PQ25  2N7002KW  [SOT23-1_7-65-3P]  98.58 49.41 90 top
PQ26  *EV@2N7002KTB  [SOT23-1_38-5-3P]  25.07 47.01 0 top
PQ27  AON7752  [DFN-8L-3X3-65-5P-0_9H]  80.66 46.52 90 top
PQ28  EV@2N7002K  [SOT23-2-95-3P]  31.72 44.92 180 top
PQ29  *EV@DMG1012T-7  [SOT23-1_38-5-3P]  28.95 44.7 270 top
PQ30  AON7408  [DFN-8L-3X3-65-5P-0_9H]  80.66 42.59 90 top
PQ31  EV@DMG1012T-7  [SOT23-1_38-5-3P]  31.56 41.87 270 top
PQ32  AONS32304  [POWER-5_2X5_55-1_27-5P]  65.68 41.7 90 top
PQ33  EV@METR3904-G  [SOT23-2-95-3P]  37.2 37.38 270 top
PQ34  AONY36354  [POWER-5X6-1_27-7P-0_8H]  126.99 14.41 180 top
PQ35  AON6996  [POWER-5_2X5_55-1_27-7P-1H]  163.23 13.94 180 top
PQ36  AON6996  [POWER-5_2X5_55-1_27-7P-1H]  150.81 13.91 0 top
PQ37  AONY36354  [POWER-5X6-1_27-7P-0_8H]  115.33 13.86 180 top
PQ38  EV@METR3904-G  [SOT23-2-95-3P]  8.5 171.47 270 bottom
PQ39  EV@DMG1012T-7  [SOT23-1_38-5-3P]  11.55 171.36 0 bottom
PQ40  EV@2N7002KTB  [SOT23-1_38-5-3P]  11.58 168.82 90 bottom
PQ41  2N7002K  [SOT23-2-95-3P]  180.36 155.36 0 bottom
PQ42  2N7002K  [SOT23-2-95-3P]  180.61 151.68 0 bottom
PQ43  PMZ370UNE  [ESD3-0_985X0_585]  106.11 142.01 270 bottom
PQ44  EV@2N7002KW  [SOT23-1_7-65-3P]  19.2 96.94 180 bottom
PQ45  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  16.07 94.83 270 bottom
PQ46  AO3404  [SOT23-2_38-95-3P]  94 72.29 180 bottom
PQ47  AO3415  [SOT23-2_38-95-3P]  229.25 57.83 180 bottom
PQ48  2N7002K  [SOT23-2-95-3P]  223.41 57.83 180 bottom
PQ49  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  218.08 57.61 0 bottom
PQ50  2N7002KW  [SOT23-1_7-65-3P]  90.98 56.6 270 bottom
PQ51  *2N7002K  [SOT23-2-95-3P]  220.24 54.52 0 bottom
PQ52  PJA3411  [SOT23-2-95-3P]  90.57 53.25 270 bottom
PQ53  PJA3411  [SOT23-2-95-3P]  95.24 50.41 90 bottom
PQ54  2N7002KW  [SOT23-1_7-65-3P]  91.59 50.21 180 bottom
PQ55  EV@2N7002KW  [SOT23-1_7-65-3P]  38.67 37.05 270 bottom
PQ56  AO3404  [SOT23-2_38-95-3P]  11.35 37.23 0 top
PQ57  2N7002K  [SOT23-2-95-3P]  247.08 17.89 90 bottom
PQ58  *DDTC144EUA-7-F  [SOT23-1_7-65-3P]  179.34 36.62 180 bottom
PQ59  *2N7002K  [SOT23-2-95-3P]  177.44 18.08 90 bottom
PR1  EV@1M_5%_2  [R0201]  7.87 173.55 180 top
PR2  EV@100K_1%_2  [R0201]  9.59 173.55 180 top
PR3  EV@0_1%_6  [R0603]  18.54 173.42 180 top
PR4  *EV@2.2_5%_6  [R0603]  35.71 173.27 0 top
PR5  *Short_0201  [S0201]  11.4 172.84 90 top
PR6  *EV@12K_1%_2  [R0201]  12.16 172.84 270 top
PR7  *EV@10K_1%_2  [R0201]  12.9 172.84 270 top
PR8  EV@15K_1%_2  [R0201]  13.73 172.84 90 top
PR9  7.5K_1%_4  [R0402]  171.6 174.31 0 top
PR10  1K_1%_2  [R0201]  174.59 174.08 0 top
PR11  EV@1_5%_6  [R0603]  18.51 171.9 180 top
PR12  EV@75K_1%_2  [R0201]  10.81 171.67 0 top
PR13  49.9_1%_4  [R0402]  179.01 172.58 90 top
PR14  10_1%_4  [R0402]  180.74 172.58 270 top
PR15  1K_1%_2  [R0201]  173.4 172.53 0 top
PR16  *EV@100K_1%_2  [R0201]  10.81 170.91 0 top
PR17  *Short_0201  [S0201]  179.85 172.2 90 top
PR18  4.02K_1%_4  [R0402]  167.46 171.39 180 top
PR19  78.7K_1%_4  [R0402]  168.85 171.03 90 top
PR20  4.02K_1%_4  [R0402]  169.89 171.03 270 top
PR21  EV@82.5K_1%_4  [R0402]  7.87 169.36 180 top
PR22  *10K_1%_2  [R0201]  181.77 170.61 0 top
PR23  1K_1%_2  [R0201]  171.75 170.48 270 top
PR24  78.7K_1%_4  [R0402]  167.43 170.35 180 top
PR25  *Short_0201  [S0201]  181.77 169.82 0 top
PR26  EV@21K_1%_2  [R0201]  9.16 168.11 90 top
PR27  EV@10K_1%_2  [R0201]  10.05 168.52 270 top
PR28  1K_1%_2  [R0201]  168.7 169.36 90 top
PR29  49.9_1%_2  [R0201]  169.46 169.36 90 top
PR30  78.7K_1%_4  [R0402]  167.43 169.33 180 top
PR31  4.02K_1%_4  [R0402]  167.43 168.34 180 top
PR32  EV@1_5%_6  [R0603]  9.59 165.19 0 top
PR33  3K_1%_4  [R0402]  169.79 167.35 0 top
PR34  EV@0_5%_2  [R0201]  11.75 165.8 180 top
PR35  *Short_0201  [S0201]  14.6 165.55 270 top
PR36  *Short_0402  [S0402]  144.95 167.02 0 top
PR37  *Short_0402  [S0402]  165.65 167.02 180 top
PR38  *Short_0402  [S0402]  154.93 166.95 180 top
PR39  *Short_0402  [S0402]  136.49 166.18 180 top
PR40  75K_1%_2  [R0201]  169.11 166.49 180 top
PR41  EV@10K_1%_2  [R0201]  14.73 164.66 0 top
PR42  3.3_1%_6  [R0603]  163.62 166.03 270 top
PR43  3.3_1%_6  [R0603]  143.02 166.01 270 top
PR44  3.3_1%_6  [R0603]  152.93 165.95 270 top
PR45  EV@402K_1%_4  [R0402]  8.38 166.39 0 top
PR46  3.3_1%_6  [R0603]  132.76 165.85 270 top
PR47  2.2_1%_4  [R0402]  165.96 165.62 270 top
PR48  2.2_1%_4  [R0402]  145.36 165.6 270 top
PR49  165K_1%_4  [R0402]  168.75 165.57 0 top
PR50  2.2_1%_4  [R0402]  155.11 165.55 270 top
PR51  2.2_1%_4  [R0402]  135.05 165.42 270 top
PR52  *Short_0201  [S0201]  166.9 165.27 270 top
PR53  *Short_0201  [S0201]  146.3 165.24 270 top
PR54  *Short_0201  [S0201]  155.95 165.19 270 top
PR55  *Short_0201  [S0201]  135.96 165.04 270 top
PR56  2K_1%_2  [R0201]  181.4 164.05 0 top
PR57  *Short_0201  [S0201]  136.77 163.59 270 top
PR58  *Short_0201  [S0201]  147.34 163.52 180 top
PR59  *Short_0201  [S0201]  157.27 163.39 180 top
PR60  *Short_0201  [S0201]  168.04 163.31 180 top
PR61  2K_1%_2  [R0201]  181.4 163.29 0 top
PR62  EV@0_1%_6  [R0603]  10.86 163.16 180 top
PR63  *Short_0201  [S0201]  147.34 162.75 180 top
PR64  *Short_0201  [S0201]  136.95 162.7 180 top
PR65  *Short_0201  [S0201]  157.27 162.63 180 top
PR66  *Short_0201  [S0201]  168.04 162.55 180 top
PR67  0.005_1%_2512  [RC2512]  108.55 161.08 90 top
PR68  78.7K_1%_4  [R0402]  169.74 162.12 270 top
PR69  *Short_0201  [S0201]  105.68 161.45 180 top
PR70  *Short_0201  [S0201]  105.67 160.69 180 top
PR71  *0_5%_2  [R0201]  178.85 161.29 0 top
PR72  *Short_0201  [S0201]  172.51 161.03 180 top
PR73  4.02K_1%_4  [R0402]  170.1 160.75 180 top
PR74  4.3K_1%_4  [R0402]  177.6 160.51 270 top
PR75  20K_1%_2  [R0201]  178.98 160.43 270 top
PR76  10_1%_4  [R0402]  171.44 160.34 270 top
PR77  15K_1%_2  [R0201]  172.48 160.27 0 top
PR78  220K_NTC_4_5%  [R0402]  168.46 159.23 180 top
PR79  10_1%_4  [R0402]  124.73 157.95 180 top
PR80  *22_5%_8  [R0805]  176.17 157.65 90 top
PR81  10_1%_4  [R0402]  158.59 157.47 270 top
PR82  10_1%_4  [R0402]  137.05 157.45 270 top
PR83  10_1%_4  [R0402]  147.82 157.37 270 top
PR84  301K_1%_2  [R0201]  97.82 157.23 0 top
PR85  1M_5%_6  [R0603]  181.5 157.01 270 top
PR86  *Short_0402  [S0402]  115.79 156.35 180 top
PR87  1K_5%_2  [R0201]  98.35 156.34 270 top
PR88  *Short_0402  [S0402]  104.06 155.4 0 top
PR89  *Short_0201  [S0201]  114.55 155.34 270 top
PR90  *Short_0201  [S0201]  113.81 155.31 270 top
PR91  22_5%_8  [R0805]  176.17 154.73 180 top
PR92  *Short_0201  [S0201]  97.95 154.59 180 top
PR93  *Short_0201  [S0201]  112.08 154.09 0 top
PR94  *Short_0201  [S0201]  122.9 153.94 90 top
PR95  *Short_0201  [S0201]  97.93 153.88 180 top
PR96  *Short_0201  [S0201]  154.65 153.53 90 top
PR97  *Short_0201  [S0201]  132.3 153.51 90 top
PR98  *Short_0201  [S0201]  165.45 153.51 90 top
PR99  *Short_0201  [S0201]  143.4 153.48 90 top
PR100  2.2_1%_4  [R0402]  111.73 153.2 0 top
PR101  20.5K_1%_4  [R0402]  174.01 152.44 270 top
PR102  15K_1%_2  [R0201]  97.95 152.38 180 top
PR103  *Short_0201  [S0201]  172.1 152.19 90 top
PR104  *Short_0402  [S0402]  104.08 151.79 0 top
PR105  *Short_0201  [S0201]  97.86 151.65 180 top
PR106  3.3_1%_6  [R0603]  111.55 150.64 0 top
PR107  499K_1%_2  [R0201]  98.64 150.68 270 top
PR108  *Short_0201  [S0201]  122.88 150.54 270 top
PR109  22_5%_8  [R0805]  177.33 148.61 180 top
PR110  *Short_0201  [S0201]  132.17 148.43 270 top
PR111  *Short_0201  [S0201]  165.5 148.4 270 top
PR112  *Short_0201  [S0201]  154.5 148.38 270 top
PR113  *Short_0201  [S0201]  143.38 148.33 270 top
PR114  100K_NTC_4_1%  [R0402]  118.79 147.96 90 top
PR115  *EV@2.2_5%_6  [R0603]  7.69 155.16 270 bottom
PR116  10K_5%_4  [R0402]  173.5 145.84 270 top
PR117  220K_NTC_4_5%  [R0402]  171.77 145.53 0 top
PR118  100_1%_4  [R0402]  126.74 143.22 0 top
PR119  *Short_0201  [S0201]  128.03 143.22 270 top
PR120  100_1%_4  [R0402]  126.74 142.21 0 top
PR121  *Short_0201  [S0201]  128.01 142.15 90 top
PR122  100_1%_4  [R0402]  131.59 138.83 90 top
PR123  100_1%_4  [R0402]  132.58 138.83 90 top
PR125  300_5%_6  [R0603]  108.77 140.46 90 top
PR128  *Short_0201  [S0201]  131.57 137.61 0 top
PR129  *Short_0201  [S0201]  132.58 137.61 180 top
PR130  *Short_0201  [S0201]  110.84 138.57 180 top
PR131  *Short_0805  [S0805]  17.85 98.81 0 top
PR132  EV@5.6_5%_8  [R0805]  105.17 96.69 180 top
PR133  EV@100_1%_4  [R0402]  93.74 96.43 0 top
PR134  EV@100_1%_4  [R0402]  95.73 96.14 0 top
PR135  EV@47_1%_4  [R0402]  96.89 94.1 90 top
PR136  *Short_0201  [S0201]  90.95 93.31 270 top
PR137  EV@10K_1%_2  [R0201]  90.98 92.27 270 top
PR138  EV@10K_1%_2  [R0201]  93.87 92.22 180 top
PR139  EV@100K_1%_2  [R0201]  108.07 91.25 0 top
PR140  EV@1M_5%_2  [R0201]  109.31 91.37 0 top
PR142  EV@10K_1%_2  [R0201]  91.43 90.89 180 top
PR143  *Short_0201  [S0201]  7.03 87.27 0 top
PR144  EV@100K_1%_2  [R0201]  7.13 89.14 270 top
PR145  *Short_0201  [S0201]  7.23 84.68 180 top
PR146  *EV@2.2_5%_6  [R0603]  12.21 83.23 180 top
PR147  EV@10_5%_6  [R0603]  7.24 78.11 270 top
PR148  *Short_0603  [S0603]  95.35 78.12 180 top
PR149  100K_1%_2  [R0201]  94.63 76.52 180 top
PR150  *Short_0201  [S0201]  94.63 75.68 0 top
PR151  15K_1%_4  [R0402]  92.96 75.99 270 top
PR152  47.5K_1%_4  [R0402]  92.96 74.18 270 top
PR153  G3@0_5%_2  [R0201]  23.39 71.8 90 top
PR154  G3@0_5%_2  [R0201]  32.91 71.8 90 top
PR155  *Short_0201  [S0201]  42.69 71.8 90 top
PR156  *Short_0201  [S0201]  52.22 71.8 90 top
PR157  *Short_0201  [S0201]  61.87 71.8 90 top
PR158  *Short_0201  [S0201]  71.77 71.8 90 top
PR159  *Short_0201  [S0201]  81.43 71.8 90 top
PR160  *Short_0201  [S0201]  90.7 71.8 90 top
PR161  *Short_0201  [S0201]  93.24 71.19 180 top
PR162  *Short_0201  [S0201]  93.24 70.43 0 top
PR163  *0_5%_2  [R0201]  93.24 69.69 0 top
PR164  *Short_0201  [S0201]  96.46 69.92 0 top
PR165  EV@2.2_5%_6  [R0603]  51.71 63.41 0 top
PR166  EV@2.2_5%_6  [R0603]  61.36 63.41 0 top
PR167  G3@2.2_5%_6  [R0603]  32.4 63.29 0 top
PR168  EV@2.2_5%_6  [R0603]  42.06 63.29 0 top
PR169  EV@2.2_5%_6  [R0603]  71.01 63.29 0 top
PR170  EV@2.2_5%_6  [R0603]  80.66 63.29 0 top
PR171  G3@2.2_5%_6  [R0603]  23.01 63.03 0 top
PR172  22_5%_8  [R0805]  179.81 62.47 90 top
PR173  EV@2.2_5%_6  [R0603]  90.64 63.32 0 top
PR174  100K_1%_2  [R0201]  92.87 59.93 90 top
PR175  10_1%_6  [R0603]  96.71 59.29 90 top
PR176  22_5%_8  [R0805]  216.47 59.16 270 top
PR177  G3@2_1%_4  [R0402]  22.52 58.92 90 top
PR178  1M_5%_6  [R0603]  184.17 58.84 180 top
PR179  *Short_0201  [S0201]  94.76 58.59 90 top
PR180  *Short_0201  [S0201]  95.52 58.59 90 top
PR181  316K_1%_4  [R0402]  92.6 58.08 180 top
PR182  10K_1%_2  [R0201]  97.94 58.46 270 top
PR183  *0_5%_2  [R0201]  98.7 58.46 270 top
PR184  *Short_0201  [S0201]  99.46 58.46 270 top
PR185  *Short_0402  [S0402]  240.3 58.21 270 top
PR186  G3@2_1%_4  [R0402]  32.23 58.03 90 top
PR187  EV@2_1%_4  [R0402]  41.88 58.03 90 top
PR188  EV@2_1%_4  [R0402]  51.53 58.03 90 top
PR189  EV@2_1%_4  [R0402]  61.18 58.03 90 top
PR190  EV@2_1%_4  [R0402]  70.83 58.03 90 top
PR191  EV@2_1%_4  [R0402]  80.49 58.03 90 top
PR192  EV@2_1%_4  [R0402]  90.14 58.03 90 top
PR193  22.6K_1%_4  [R0402]  99.41 59.96 270 top
PR194  10K_1%_2  [R0201]  98.77 57.5 180 top
PR195  1M_5%_6  [R0603]  182.34 55.85 90 top
PR196  *10K_1%_2  [R0201]  98.57 56.63 270 top
PR197  *0_5%_2  [R0201]  99.31 56.63 270 top
PR198  20K_1%_4  [R0402]  239.29 56.43 270 top
PR199  174K_1%_4  [R0402]  240.3 56.43 90 top
PR200  G3@0_5%_2  [R0201]  32.23 56.23 180 top
PR201  *Short_0201  [S0201]  41.88 56.23 0 top
PR202  *Short_0201  [S0201]  51.53 56.23 0 top
PR203  *Short_0201  [S0201]  61.18 56.23 0 top
PR204  *Short_0201  [S0201]  70.83 56.23 0 top
PR205  *Short_0201  [S0201]  80.05 55.87 270 top
PR206  *Short_0201  [S0201]  90.16 56.32 180 top
PR207  G3@0_5%_2  [R0201]  23.18 55.21 180 top
PR208  *0_5%_2  [R0201]  234.71 55.16 180 top
PR209  G3@100K_1%_2  [R0201]  15.63 54.76 180 top
PR210  EV@2.2_1%_6  [R0603]  66.36 54.73 180 top
PR211  G3@2.2_1%_6  [R0603]  27.76 54.68 180 top
PR212  EV@2.2_1%_6  [R0603]  37.41 54.68 180 top
PR213  EV@2.2_1%_6  [R0603]  47.06 54.68 180 top
PR214  EV@2.2_1%_6  [R0603]  56.71 54.68 180 top
PR215  EV@2.2_1%_6  [R0603]  76.02 54.68 180 top
PR216  EV@2.2_1%_6  [R0603]  85.67 54.68 180 top
PR217  1M_5%_6  [R0603]  180.86 54.86 90 top
PR218  100K_5%_4  [R0402]  239.29 54.27 0 top
PR219  G3@0_5%_2  [R0201]  19.81 54.63 90 top
PR220  G3@0_5%_2  [R0201]  20.62 54.63 90 top
PR221  *G3@30K_1%_2  [R0201]  21.38 54.63 90 top
PR222  G3@0_5%_2  [R0201]  29.46 54.63 90 top
PR223  G3@0_5%_2  [R0201]  30.27 54.63 90 top
PR224  *G3@30K_1%_2  [R0201]  31.03 54.63 90 top
PR225  *Short_0201  [S0201]  39.11 54.63 270 top
PR226  *Short_0201  [S0201]  39.92 54.63 270 top
PR227  *EV@30K_1%_2  [R0201]  40.68 54.63 90 top
PR228  *Short_0201  [S0201]  48.76 54.63 270 top
PR229  *Short_0201  [S0201]  49.57 54.63 270 top
PR230  *EV@30K_1%_2  [R0201]  50.34 54.63 90 top
PR231  *Short_0201  [S0201]  58.41 54.63 270 top
PR232  *Short_0201  [S0201]  59.23 54.63 270 top
PR233  *EV@30K_1%_2  [R0201]  59.99 54.63 90 top
PR234  *Short_0201  [S0201]  68.07 54.63 270 top
PR235  *Short_0201  [S0201]  68.88 54.63 270 top
PR236  *EV@30K_1%_2  [R0201]  69.64 54.63 90 top
PR237  *Short_0201  [S0201]  77.72 54.63 270 top
PR238  *Short_0201  [S0201]  78.53 54.63 270 top
PR239  *EV@30K_1%_2  [R0201]  79.29 54.63 90 top
PR240  *Short_0201  [S0201]  87.37 54.6 270 top
PR241  *Short_0201  [S0201]  88.18 54.55 270 top
PR242  *EV@30K_1%_2  [R0201]  88.94 54.6 90 top
PR243  *Short_0603  [S0603]  90.7 54.52 0 top
PR244  G3@100K_1%_2  [R0201]  25.83 54.45 180 top
PR245  EV@100K_1%_2  [R0201]  35.48 54.45 180 top
PR246  EV@100K_1%_2  [R0201]  45.13 54.45 180 top
PR247  EV@100K_1%_2  [R0201]  54.78 54.45 180 top
PR248  EV@100K_1%_2  [R0201]  64.43 54.45 180 top
PR249  EV@100K_1%_2  [R0201]  74.09 54.45 180 top
PR250  EV@100K_1%_2  [R0201]  83.74 54.45 180 top
PR251  *Short_0201  [S0201]  234.71 54.27 180 top
PR252  *Short_0201  [S0201]  98.69 53.97 180 top
PR253  *Short_0201  [S0201]  98.69 53.26 180 top
PR254  *Short_0201  [S0201]  98.08 52.41 90 top
PR255  *Short_0201  [S0201]  43.88 51.68 90 top
PR256  EV@100K_1%_2  [R0201]  47.03 51.68 90 top
PR257  G3@2.2_1%_6  [R0603]  15.19 51.66 0 top
PR258  137K_1%_4  [R0402]  98.15 51.42 0 top
PR259  20_1%_6  [R0603]  87.64 51.34 0 top
PR260  *EV@2.4K_1%_2  [R0201]  34.95 51.31 270 top
PR261  EV@18.7K_1%_4  [R0402]  45.97 51.28 270 top
PR262  *EV@0_5%_2  [R0201]  35.68 51.25 270 top
PR263  *Short_0201  [S0201]  96.28 51.1 90 top
PR264  EV@20K_1%_2  [R0201]  44.85 51.02 270 top
PR265  EV@10K_1%_4  [R0402]  39.49 50.92 270 top
PR266  EV@90.9K_1%_4  [R0402]  40.63 50.92 270 top
PR267  EV@18.7K_1%_4  [R0402]  41.75 50.89 270 top
PR268  EV@20K_1%_2  [R0201]  42.87 50.89 270 top
PR269  4.02K_1%_4  [R0402]  94.13 50.84 270 top
PR270  4.02K_1%_4  [R0402]  95.27 50.71 270 top
PR271  EV@0.005_1%_2037  [RC2037]  25.32 50.66 0 top
PR272  EV@0.005_1%_2037  [RC2037]  30.07 50.66 0 top
PR273  EV_SP@12.4K_1%_2  [R0201]  43.86 50.64 90 top
PR274  EV@2.4K_1%_2  [R0201]  37.51 50.51 270 top
PR275  *Short_0201  [S0201]  38.5 50.51 90 top
PR276  100K_1%_2  [R0201]  96.26 50.21 180 top
PR277  100K_1%_2  [R0201]  100.37 48.61 0 top
PR278  *Short_0201  [S0201]  47.77 49.95 270 top
PR279  EV@2K_1%_2  [R0201]  46.91 49.6 0 top
PR280  100K_1%_2  [R0201]  96.12 49.35 270 top
PR281  *EV@100K_1%_2  [R0201]  35.07 49.14 180 top
PR282  *Short_0201  [S0201]  96.85 48.97 270 top
PR283  *Short_0201  [S0201]  45.03 48.81 180 top
PR284  EV@1K_1%_2  [R0201]  36.95 48.71 90 top
PR285  *Short_0201  [S0201]  186.12 48.71 0 top
PR286  *Short_0201  [S0201]  66.82 48.05 90 top
PR287  EV@402_1%_4  [R0402]  47.8 48.02 90 top
PR288  *Short_0201  [S0201]  45.03 47.95 180 top
PR289  *0_5%_2  [R0201]  186.12 47.95 0 top
PR290  *EV@0_5%_2  [R0201]  46.81 47.92 180 top
PR291  *Short_0201  [S0201]  97.94 47.54 180 top
PR292  *Short_0201  [S0201]  31.97 47.79 180 top
PR293  EV@10K_1%_2  [R0201]  33.11 47.79 180 top
PR294  *Short_0201  [S0201]  29.86 47.67 270 top
PR295  *Short_0201  [S0201]  30.63 47.67 270 top
PR296  0.005_1%_2037  [RC2037]  66.82 47.54 90 top
PR297  *Short_0201  [S0201]  34.94 47.41 180 top
PR298  *Short_0201  [S0201]  27.27 47.34 90 top
PR299  *Short_0201  [S0201]  27.98 47.34 90 top
PR300  *Short_0201  [S0201]  45.03 47.08 180 top
PR301  *EV@100K_1%_2  [R0201]  28.85 47.11 180 top
PR302  *Short_0201  [S0201]  66.82 47.03 270 top
PR303  *Short_0603  [S0603]  62.7 47.02 270 top
PR304  EV@10K_1%_2  [R0201]  33.11 47.06 180 top
PR305  *Short_0201  [S0201]  34.94 46.52 180 top
PR306  *EV@1M_5%_2  [R0201]  28.85 46.35 180 top
PR307  *Short_0201  [S0201]  45.03 46.22 180 top
PR308  EV@10K_1%_2  [R0201]  34.94 45.63 0 top
PR309  *Short_0201  [S0201]  45.03 45.36 180 top
PR310  *4.7_5%_6  [R0603]  83.97 45.25 180 top
PR311  EV@10K_1%_2  [R0201]  33.93 44.75 270 top
PR312  EV@10K_1%_2  [R0201]  34.94 44.75 180 top
PR313  *Short_0201  [S0201]  45.03 44.49 180 top
PR314  *Short_0201  [S0201]  33.8 43.86 0 top
PR315  EC@6.19K_1%_2  [R0201]  34.94 43.86 0 top
PR316  EV_SP@0_5%_2  [R0201]  45.03 43.63 0 top
PR317  EV@20.5K_1%_4  [R0402]  35.18 42.93 180 top
PR318  EV_SP@0_5%_2  [R0201]  45.03 42.76 0 top
PR319  EV@4.32K_1%_4  [R0402]  35.17 41.91 180 top
PR320  EV@10K_1%_2  [R0201]  29.73 40.97 180 top
PR321  EV@150K_1%_2  [R0201]  38.19 40.96 90 top
PR322  *Short_0201  [S0201]  38.93 40.96 90 top
PR323  *Short_0201  [S0201]  39.67 40.96 90 top
PR324  *Short_0201  [S0201]  40.4 40.96 90 top
PR325  *Short_0201  [S0201]  41.14 40.96 90 top
PR326  *Short_0201  [S0201]  41.88 40.96 90 top
PR327  *Short_0201  [S0201]  42.61 40.96 90 top
PR328  *Short_0201  [S0201]  43.35 40.96 90 top
PR329  EV@16.5K_1%_4  [R0402]  35.2 40.94 180 top
PR330  *EV@100K_1%_2  [R0201]  45.03 40.87 180 top
PR331  EV@2.2_5%_6  [R0603]  46.88 40.89 90 top
PR332  *EV@0_5%_2  [R0201]  32.86 40.08 270 top
PR333  EV@681K_1%_4  [R0402]  45.03 40.03 180 top
PR334  EV@309_1%_4  [R0402]  34.23 39.67 0 top
PR335  EV@324K_1%_4  [R0402]  40.53 38.78 90 top
PR336  EV@365K_1%_4  [R0402]  43.58 38.78 270 top
PR337  EV@90.9K_1%_4  [R0402]  39.49 38.75 270 top
PR338  *Short_0201  [S0201]  46.25 38.4 270 top
PR339  *Short_0201  [S0201]  47.01 38.4 270 top
PR340  EV@10K_1%_2  [R0201]  41.38 38.29 90 top
PR341  EV@1K_1%_2  [R0201]  40.15 37.25 180 top
PR342  *EV@0_5%_4  [R0402]  48.41 37.18 0 top
PR343  *EV@10K_1%_2  [R0201]  40.15 36.54 180 top
PR344  *EV@10K_1%_2  [R0201]  47.62 36.14 90 top
PR345  *Short_0201  [S0201]  48.02 35.09 0 top
PR346  *Short_0201  [S0201]  40.05 34.41 0 top
PR347  *Short_0201  [S0201]  48.02 34.33 0 top
PR348  *Short_0402  [S0402]  38.5 34.2 270 top
PR349  *EV@10K_1%_2  [R0201]  40.02 33.7 0 top
PR350  EV@487_1%_4  [R0402]  48.41 33.32 180 top
PR351  *Short_0201  [S0201]  40.02 32.93 180 top
PR352  EV@487_1%_4  [R0402]  48.41 32.3 180 top
PR353  EV@10K_1%_2  [R0201]  40.02 32.17 0 top
PR354  *EV@0_5%_2  [R0201]  47.14 31.92 90 top
PR355  *Short_0805  [S0805]  93.17 30.6 270 top
PR356  *Short_0805  [S0805]  95.2 30.6 270 top
PR357  EV@75K_1%_2  [R0201]  43.83 30.52 90 top
PR358  EV@75K_1%_2  [R0201]  46.63 30.52 90 top
PR359  *Short_0402  [S0402]  41.67 30.14 270 top
PR360  EV@100_1%_4  [R0402]  42.82 30.14 90 top
PR361  *Short_0402  [S0402]  44.72 30.14 270 top
PR362  EV@100_1%_4  [R0402]  45.74 30.14 90 top
PR363  EV_SP@127_1%_4  [R0402]  40.02 30.01 180 top
PR364  *0_5%_2  [R0201]  159.53 29.38 180 top
PR365  *Short_0201  [S0201]  156.36 28.95 270 top
PR366  100K_1%_2  [R0201]  153.56 28.44 270 top
PR367  *0_5%_2  [R0201]  156.59 28.03 180 top
PR368  10_5%_6  [R0603]  170.56 27.99 90 top
PR369  *Short_0603  [S0603]  116.29 27.98 90 top
PR370  10K_1%_4  [R0402]  159.58 27.93 270 top
PR371  *Short_0201  [S0201]  97.43 27.91 0 top
PR372  499K_1%_4  [R0402]  154.45 27.8 90 top
PR373  *Short_0201  [S0201]  153.6 27.46 270 top
PR374  *Short_0201  [S0201]  158.46 27.45 270 top
PR375  *Short_0201  [S0201]  152.41 27.31 0 top
PR376  *0_5%_2  [R0201]  156.58 27.3 180 top
PR377  15.8K_1%_4  [R0402]  122.07 27.22 270 top
PR378  78.7K_1%_4  [R0402]  117.49 27.19 270 top
PR379  9.31K_1%_4  [R0402]  118.48 27.19 270 top
PR380  6.49K_1%_4  [R0402]  119.47 27.19 90 top
PR381  10K_1%_2  [R0201]  120.49 26.81 90 top
PR382  4.3K_1%_4  [R0402]  161.64 26.47 90 top
PR383  *Short_0201  [S0201]  176.83 26.35 90 top
PR384  57.6K_1%_2  [R0201]  164.21 26.2 270 top
PR385  1K_1%_2  [R0201]  162.72 26.2 90 top
PR386  100K_1%_2  [R0201]  164.94 26.19 270 top
PR388  *0_5%_2  [R0201]  152.77 26.18 180 top
PR389  8.2K_1%_4  [R0402]  159.45 26.18 90 top
PR390  *Short_0603  [S0603]  114.95 25.92 180 top
PR391  10K_1%_4  [R0402]  123.46 25.7 180 top
PR392  100K_1%_2  [R0201]  116.86 25.57 0 top
PR393  100_5%_2  [R0201]  160.34 25.44 270 top
PR394  *Short_0402  [S0402]  152.37 25.21 180 top
PR395  *Short_0402  [S0402]  97.58 25.04 180 top
PR396  *Short_0201  [S0201]  99.59 24.93 180 top
PR397  *Short_0201  [S0201]  116.86 24.81 180 top
PR398  63.4K_1%_2  [R0201]  123.84 24.81 0 top
PR399  10K_1%_4  [R0402]  161.27 24.5 90 top
PR400  *0_5%_6  [R0603]  114.95 24.4 180 top
PR401  *Short_0201  [S0201]  149.14 24.4 0 top
PR402  10K_1%_2  [R0201]  116.86 24.04 180 top
PR403  *Short_0201  [S0201]  123.84 24.04 0 top
PR404  *Short_0201  [S0201]  159.51 23.59 180 top
PR405  205K_1%_4  [R0402]  152.47 23.46 180 top
PR406  *Short_0201  [S0201]  98.06 23.18 180 top
PR407  20.5K_1%_4  [R0402]  176.83 22.96 90 top
PR408  470K_1%_2  [R0201]  160.67 22.9 270 top
PR409  1_1%_6  [R0603]  124.61 21.89 0 top
PR410  1_1%_6  [R0603]  116.1 21.86 0 top
PR411  *Short_0805  [S0805]  94.92 20.9 270 top
PR412  *Short_0805  [S0805]  92.71 21.2 270 top
PR413  10K_1%_4  [R0402]  175.65 21.14 90 top
PR414  2.2_5%_6  [R0603]  152.43 20.32 90 top
PR415  *Short_0201  [S0201]  172.29 19.77 90 top
PR416  100K_1%_2  [R0201]  173.13 19.74 90 top
PR417  *Short_0201  [S0201]  173.91 19.72 90 top
PR418  *2.2_5%_6  [R0603]  169.52 19.54 0 top
PR419  *Short_0603  [S0603]  118.76 19.07 90 top
PR420  *Short_0201  [S0201]  172.61 18.76 180 top
PR421  *Short_0603  [S0603]  165.2 18.64 90 top
PR422  *4.7_5%_6  [R0603]  101.11 16.81 270 top
PR423  *4.7_5%_6  [R0603]  131.47 9.93 0 top
PR424  *4.7_5%_6  [R0603]  166.04 9.79 0 top
PR425  *4.7_5%_6  [R0603]  149.39 9.78 180 top
PR426  EV@1M_5%_2  [R0201]  11.17 173.02 90 bottom
PR427  EV@100K_1%_2  [R0201]  9.8 173.27 270 bottom
PR428  *Short_0201  [S0201]  12.21 172.89 0 bottom
PR429  10K_1%_2  [R0201]  177.54 173.24 180 bottom
PR430  10_1%_4  [R0402]  175.74 172.91 90 bottom
PR431  45.3_1%_4  [R0402]  178.63 172.74 270 bottom
PR432  14K_1%_2  [R0201]  176.65 172.61 90 bottom
PR433  *Short_0201  [S0201]  182.01 172.58 90 bottom
PR434  100_1%_4  [R0402]  180.69 172.48 270 bottom
PR435  *110_1%_4  [R0402]  179.67 172.48 270 bottom
PR436  *Short_0201  [S0201]  177.54 172.43 180 bottom
PR437  2.61K_1%_4  [R0402]  172.68 172.28 90 bottom
PR438  *Short_0201  [S0201]  179.14 170.35 0 bottom
PR439  37.4K_1%_4  [R0402]  178.1 169.26 90 bottom
PR440  44.2K_1%_4  [R0402]  176.04 169.26 270 bottom
PR441  16.9K_1%_4  [R0402]  175.08 169.26 270 bottom
PR442  *Short_0201  [S0201]  179.85 168.11 180 bottom
PR443  SP@26.1K_1%_4  [R0402]  174.47 167.81 0 bottom
PR444  EV@22_5%_8  [R0805]  11.32 165.9 270 bottom
PR445  *Short_0201  [S0201]  179.85 167.4 180 bottom
PR446  *Short_0201  [S0201]  179.88 166.69 180 bottom
PR447  SP@41.2K_1%_4  [R0402]  171.17 166.24 270 bottom
PR448  *Short_0201  [S0201]  179.88 165.98 180 bottom
PR449  *Short_0201  [S0201]  179.88 165.27 180 bottom
PR450  *Short_0201  [S0201]  179.88 164.56 180 bottom
PR451  *Short_0201  [S0201]  178.96 164.56 90 bottom
PR452  130K_1%_2  [R0201]  178.2 164.56 270 bottom
PR453  24.9K_1%_2  [R0201]  176.62 164.56 270 bottom
PR454  *1K_1%_2  [R0201]  174.8 164.56 90 bottom
PR455  130K_1%_2  [R0201]  177.44 164.53 270 bottom
PR456  SP@140K_1%_4  [R0402]  175.71 164.18 90 bottom
PR457  1K_1%_4  [R0402]  173.6 160.39 90 bottom
PR458  2.2_5%_6  [R0603]  174.85 159.99 90 bottom
PR459  *Short_0201  [S0201]  28.29 157.73 180 bottom
PR460  2.2_1%_6  [R0603]  134 157.19 0 bottom
PR461  *Short_0201  [S0201]  29.28 157.9 0 bottom
PR462  2.2_1%_6  [R0603]  144.65 157.12 0 bottom
PR463  2.2_1%_6  [R0603]  155.29 157.09 0 bottom
PR464  EV@100_1%_2  [R0201]  28.42 157.01 0 bottom
PR465  2.2_1%_6  [R0603]  165.96 156.86 0 bottom
PR466  1M_5%_6  [R0603]  176.17 155.74 180 bottom
PR467  1M_5%_6  [R0603]  176.17 154.22 180 bottom
PR468  2.2_1%_6  [R0603]  118.89 153.33 0 bottom
PR469  22_5%_8  [R0805]  177.82 151.81 270 bottom
PR470  200K_1%_2  [R0201]  105.57 144.41 90 bottom
PR471  49.9K_1%_4  [R0402]  106.17 143.36 180 bottom
PR472  *Short_0201  [S0201]  107.14 141.68 270 bottom
PR473  10K_5%_4  [R0402]  106 140.39 0 bottom
PR474  EV@22_5%_8  [R0805]  21.99 98.67 0 bottom
PR475  EV@1M_5%_2  [R0201]  15.26 97.45 0 bottom
PR476  EV@1M_5%_2  [R0201]  15.26 96.74 180 bottom
PR477  *Short_0201  [S0201]  19.07 94.4 180 bottom
PR478  EV@100K_1%_2  [R0201]  18.06 94.72 90 bottom
PR479  *Short_0402  [S0402]  18.02 92.9 90 bottom
PR480  *Short_0201  [S0201]  7 90.69 180 bottom
PR481  EV@20.5K_1%_4  [R0402]  7.39 82.49 0 bottom
PR482  EV@10K_1%_4  [R0402]  6.62 80.69 90 bottom
PR483  *Short_0603  [S0603]  225.95 59.6 180 bottom
PR484  *Short_0201  [S0201]  92.83 57.65 90 bottom
PR485  100K_1%_4  [R0402]  226.84 57.83 90 bottom
PR486  *100K_1%_6  [R0603]  220.62 57.7 270 bottom
PR487  *102K_1%_4  [R0402]  94.66 60.34 90 bottom
PR488  *100K_1%_2  [R0201]  96.39 58 0 bottom
PR489  *10K_1%_2  [R0201]  95.21 58.54 0 bottom
PR490  *31.6K_1%_2  [R0201]  95.59 59.5 90 bottom
PR491  10K_5%_4  [R0402]  226.46 56.3 0 bottom
PR492  100K_1%_2  [R0201]  98.22 57.14 0 bottom
PR493  100K_1%_2  [R0201]  92.71 54.93 0 bottom
PR494  *Short_0201  [S0201]  223.67 55.03 180 bottom
PR495  *0_5%_2  [R0201]  222.52 55.03 0 bottom
PR496  *220_5%_8  [R0805]  216.17 54.91 180 bottom
PR497  *Short_0201  [S0201]  97.64 55.3 0 bottom
PR498  *Short_0201  [S0201]  97.64 56.03 0 bottom
PR499  866K_1%_4  [R0402]  95.4 52.62 180 bottom
PR500  1M_5%_2  [R0201]  88.46 50.71 0 bottom
PR501  100_5%_2  [R0201]  77.74 52.37 270 bottom
PR502  100_5%_2  [R0201]  75.84 52.11 180 bottom
PR503  1M_5%_2  [R0201]  74.06 52.24 90 bottom
PR504  100_5%_2  [R0201]  73.17 52.24 90 bottom
PR505  *0_5%_2  [R0201]  72.28 52.24 270 bottom
PR506  EV@10_1%_2  [R0201]  35.22 51.97 0 bottom
PR507  10K_1%_2  [R0201]  92.98 51.91 180 bottom
PR508  1M_5%_6  [R0603]  237 51.73 90 bottom
PR509  1M_5%_6  [R0603]  235.48 51.73 270 bottom
PR510  *100K_1%_6  [R0603]  233.95 51.73 90 bottom
PR511  *Short_0201  [S0201]  38.85 51.78 0 bottom
PR512  *Short_0402  [S0402]  232.43 51.48 90 bottom
PR513  *Short_0201  [S0201]  35.31 51.19 0 bottom
PR514  *Short_0201  [S0201]  37.09 51.19 0 bottom
PR515  *Short_0201  [S0201]  35.45 50.05 0 bottom
PR516  1M_5%_2  [R0201]  89.69 49.98 90 bottom
PR517  EV@10_1%_2  [R0201]  35.43 49.14 0 bottom
PR518  *EV@0_5%_2  [R0201]  46.81 48.78 180 bottom
PR519  *EV@100K_1%_2  [R0201]  43.27 48.56 0 bottom
PR520  *Short_0201  [S0201]  34.94 48.3 180 bottom
PR521  *EV@22_5%_8  [R0805]  20.78 48.16 90 bottom
PR522  *EV@100K_1%_2  [R0201]  43.27 47.77 0 bottom
PR523  *EV@0_5%_2  [R0201]  46.81 47.06 180 bottom
PR524  *EV@100K_1%_2  [R0201]  43.27 46.98 0 bottom
PR525  *EV@0_5%_2  [R0201]  46.81 46.19 180 bottom
PR526  *EV@100K_1%_2  [R0201]  43.27 46.19 0 bottom
PR527  *Short_0201  [S0201]  34.94 45.69 0 bottom
PR528  *EV@100K_1%_2  [R0201]  43.27 45.41 0 bottom
PR529  EV@100K_1%_2  [R0201]  28.49 45.38 0 bottom
PR530  *EV@0_5%_2  [R0201]  46.81 45.33 180 bottom
PR531  *Short_0201  [S0201]  31.26 45.25 270 bottom
PR532  *Short_0201  [S0201]  34.94 44.75 0 bottom
PR533  *EV@100K_1%_2  [R0201]  43.27 44.62 0 bottom
PR534  *EV@0_5%_2  [R0201]  46.81 44.47 180 bottom
PR535  EV@10K_1%_2  [R0201]  31.59 44.24 0 bottom
PR536  EV@1M_5%_2  [R0201]  30.5 43.98 270 bottom
PR537  *EV_SP@100K_1%_2  [R0201]  43.27 43.83 0 bottom
PR538  *EV@0_5%_2  [R0201]  46.81 43.73 180 bottom
PR539  *EV_SP@100K_1%_2  [R0201]  43.27 43.04 0 bottom
PR540  *EV@0_5%_2  [R0201]  46.81 42.99 180 bottom
PR541  EV@180K_1%_2  [R0201]  43.35 40.96 90 bottom
PR542  EV@37.4K_1%_2  [R0201]  42.61 40.96 90 bottom
PR543  EV@37.4K_1%_2  [R0201]  41.88 40.96 90 bottom
PR544  EV@27.4K_1%_2  [R0201]  41.14 40.96 90 bottom
PR545  EV_SP@36K_1%_2  [R0201]  40.4 40.96 90 bottom
PR546  *EV@100K_1%_2  [R0201]  39.67 40.96 90 bottom
PR547  *EV@100K_1%_2  [R0201]  38.93 40.96 90 bottom
PR548  *Short_0201  [S0201]  45.11 40.97 180 bottom
PR549  *EV@0_5%_2  [R0201]  47.12 38.42 90 bottom
PR550  *EV@0_5%_2  [R0201]  46.36 38.42 90 bottom
PR551  EV@100K_1%_2  [R0201]  40.47 37.5 90 bottom
PR552  *EV@10K_1%_2  [R0201]  41.85 35.86 0 bottom
PR553  *EV@30.1K_1%_2  [R0201]  42.69 34.97 0 bottom
PR554  *Short_0201  [S0201]  45.48 34.17 0 bottom
PR555  *EV@10K_1%_2  [R0201]  42.69 33.95 180 bottom
PR556  EV_SP@127_1%_4  [R0402]  45.99 32.7 90 bottom
PR557  EV@49.9K_1%_2  [R0201]  40.18 32.07 180 bottom
PR560  *Short_0805  [S0805]  84.4 28.16 0 bottom
PR561  *Short_0805  [S0805]  72.99 28.03 0 bottom
PR562  *Short_0805  [S0805]  84.4 26.15 0 bottom
PR563  *Short_0201  [S0201]  138.86 26.12 90 bottom
PR564  *Short_0201  [S0201]  141.46 26.06 90 bottom
PR565  *Short_0805  [S0805]  72.99 25.75 0 bottom
PR566  *Short_0402  [S0402]  79.27 23.66 90 bottom
PR567  *Short_0201  [S0201]  73.81 23.66 90 bottom
PR568  *Short_0402  [S0402]  242.46 23.41 180 bottom
PR569  *Short_0201  [S0201]  81.17 23.28 90 bottom
PR570  *Short_0201  [S0201]  239.03 23.16 90 bottom
PR571  EV@57.6K_1%_2  [R0201]  13.63 165.63 270 top
PR572  *EV@57.6K_1%_2  [R0201]  12.75 165.35 180 top
PR573  *EV@41.2K_1%_2  [R0201]  10.41 167.34 0 top
PR574  *EV@49.9_1%_2  [R0201]  11.41 164.26 180 top
PR575  *Short_0402  [S0402]  14.29 79.54 270 top
PR576  *Short_0402  [S0402]  21.33 99.74 180 top
PR578  *Short_0201  [S0201]  21.22 93.24 270 bottom
PR579  22_5%_8  [R0805]  246.23 13.89 270 bottom
PR580  *1M_5%_6  [R0603]  180.99 40.17 0 bottom
PR581  *22_5%_8  [R0805]  175.66 15.15 270 bottom
PR582  *1M_5%_6  [R0603]  179.7 38.65 0 bottom
PU1  EV@RT8816BGQW  [WQFN20-3X3-4-21P]  13.73 169.13 180 top
PU2  NCP81205FMNTXG  [QFN52-6X6-4-53P-1H-SMT]  176.83 166.51 270 top
PU3  NCP302045MNTWG  [QFN33-5X5-5-19P]  143.71 161.43 180 top
PU4  NCP302045MNTWG  [QFN33-5X5-5-19P]  164.43 161.36 180 top
PU5  NCP302045MNTWG  [QFN33-5X5-5-19P]  133.27 161.31 180 top
PU6  NCP302045MNTWG  [QFN33-5X5-5-19P]  153.66 161.31 180 top
PU7  MP8858GQ-0001-Z  [QFN16-3X3-5-MP8858]  100.83 153.58 180 top
PU8  NCP302045MNTWG  [QFN33-5X5-5-19P]  116 151.63 270 top
PU9  TMP708AIDBVR  [SOT23-5-2_8-95-5P-G708]  172.99 149.14 90 top
PU10  EV@G9336ADJTP1U  [TSOT23-6-2_8-95-6P-1H]  93.8 94.23 180 top
PU11  EV@JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  20.34 94.02 0 top
PU12  EV@M5671RE1U  [DFN10-3X3-5-11P-G5318]  8.55 82.16 180 top
PU13  G5719CTB1U  [SOT23-6-2_8-95-6P-G5126TB1U]  95.34 72.79 270 top
PU14  G3@QD9619AQR1  [QFN39-6X5-45-21P-1H]  18.74 59.2 90 top
PU15  G3@QD9619AQR1  [QFN39-6X5-45-21P-1H]  28.39 59.2 90 top
PU16  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  38.04 59.2 90 top
PU17  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  47.69 59.2 90 top
PU18  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  57.35 59.2 90 top
PU19  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  67 59.2 90 top
PU20  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  76.65 59.2 90 top
PU21  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  86.3 59.2 90 top
PU22  TPS61087DRCR  [QFN10-3X3-5-16P]  236.49 57.32 90 top
PU23  BQ24780SRUYR  [QFN28-4X4-4-38P]  95.4 54.78 0 top
PU24  EV@UP9512PQGJ  [QFN40-5X5-4-41P-UP9511]  40.15 45.66 0 top
PU25  EV@US5650QQKI  [QFN32-4X4-4-33P-ISL95812HRZ-SMT]  44.09 34.46 0 top
PU26  JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  94.78 25.55 90 top
PU27  RT8231BGQW  [WQFN20-3X3-4-21P]  156.1 24.1 90 top
PU28  TPS51225RUKR  [QFN20-3X3-4-26P]  120.41 23.26 180 top
PU29  RT8237CZQW_2  [DFN10-3X3-5-11P-RT9296]  163.43 22.92 180 top
PU30  M5671RE1U  [DFN10-3X3-5-11P-G5318]  173.37 22.71 0 top
PU31  JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  78.71 26.36 180 bottom
PU32  JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  240.61 26.23 180 bottom
Q1  2N7002K  [SOT23-2-95-3P]  39.69 161.23 0 top
Q2  2N7002KTB  [SOT23-1_38-5-3P]  76.47 160.98 0 top
Q3  2N7002KTB  [SOT23-1_38-5-3P]  79.01 160.98 0 top
Q4  DMG1012T-7  [SOT23-1_38-5-3P]  176.02 136.21 0 top
Q5  METR3904-G  [SOT23-2-95-3P]  111.4 130.85 0 top
Q6  DMG301NU-7  [SOT23-2-95-3P]  107.59 130.22 270 top
Q7  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  178.2 120.44 180 top
Q8  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  167.91 119.93 0 top
Q9  PJX8838  [SOT563-1_6-5-6P-PJX138K]  178.83 116.5 90 top
Q10  METR3904-G  [SOT23-2-95-3P]  166.74 113.71 180 top
Q11  DMG1012T-7  [SOT23-1_38-5-3P]  178.71 113.2 180 top
Q12  2N7002KTB  [SOT23-1_38-5-3P]  168.44 111.02 270 top
Q13  DMG1012T-7  [SOT23-1_38-5-3P]  178.71 110.91 180 top
Q14  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  178.71 108.37 0 top
Q15  DMG1012T-7  [SOT23-1_38-5-3P]  178.33 105.62 270 top
Q16  PJX138K  [SOT563-1_6-5-6P-PJX138K]  107.26 103.73 0 top
Q17  DMG1012T-7  [SOT23-1_38-5-3P]  178.33 102.91 270 top
Q19  PJX8838  [SOT563-1_6-5-6P-PJX138K]  9.72 67.86 180 top
Q20  2N7002K  [SOT23-2-95-3P]  8.91 63.16 180 top
Q21  2N7002KDW  [SOT363-2_1-65-6P]  8.15 59.73 90 top
Q22  *2N7002KTB  [SOT23-1_38-5-3P]  252.24 58.33 0 top
Q23  *PJA3413  [SOT23-2-95-3P]  9.42 56.05 180 top
Q24  2N7002K  [SOT23-2-95-3P]  11.32 52.49 270 top
Q25  METR3904-G  [SOT23-2-95-3P]  12.49 49.17 270 top
Q26  *2N7002KTB  [SOT23-1_38-5-3P]  53.97 44.52 90 top
Q27  *2N7002KTB  [SOT23-1_38-5-3P]  236.49 42.54 180 top
Q28  2N7002KTB  [SOT23-1_38-5-3P]  54.25 41.19 180 top
Q29  2N7002KTB  [SOT23-1_38-5-3P]  64.84 37.23 180 top
Q30  *PJ4N3KDW  [SC70-2_1-65-6P]  95.75 36.97 0 top
Q31  CNV@AO3413  [SOT23-2_38-95-3P]  50.45 35.08 0 top
Q32  *2N7002KTB  [SOT23-1_38-5-3P]  89.55 34.2 0 top
Q33  PJX8838  [SOT563-1_6-5-6P-PJX138K]  95.27 33.9 0 top
Q34  *PJA138K  [SOT23-2-95-3P]  191.79 31.41 180 top
Q35  PJX138K  [SOT563-1_6-5-6P-PJX138K]  193.99 20.74 0 top
Q36  *PJA3413  [SOT23-2-95-3P]  52.57 19.24 180 top
Q37  *PJA138K  [SOT23-2-95-3P]  243.48 18.64 270 top
Q38  PJX138K  [SOT563-1_6-5-6P-PJX138K]  193.18 18.56 0 top
Q39  M_KB@2N7002KTB  [SOT23-1_38-5-3P]  89.83 17.8 90 top
Q40  2N7002K  [SOT23-2-95-3P]  82.47 16.5 0 top
Q41  *2N7002KTB  [SOT23-1_38-5-3P]  201.24 16.32 0 top
Q42  *2N7002KTB  [SOT23-1_38-5-3P]  85.39 15.92 0 top
Q43  2N7002K  [SOT23-2-95-3P]  51.71 15.71 180 top
Q44  2N7002K  [SOT23-2-95-3P]  56.15 15.79 180 top
Q45  BSS84DW  [SOT363-2_1-65-6P]  65.42 15.41 270 top
Q46  PJX8838  [SOT563-1_6-5-6P-PJX138K]  60.04 15.13 180 top
Q47  *PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  253.76 14.62 270 top
Q48  *PJX8838  [SOT563-1_6-5-6P-PJX138K]  88.82 14.52 180 top
Q49  2N7002KTB  [SOT23-1_38-5-3P]  203.85 14.49 0 top
Q50  BSS84DW  [SOT363-2_1-65-6P]  69.23 13.88 0 top
Q51  2N7002KDW  [SOT363-2_1-65-6P]  74.31 13.76 0 top
Q52  2N7002KDW  [SOT363-2_1-65-6P]  79.39 13.76 0 top
Q53  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  8.83 10.96 270 top
Q54  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  11.5 10.96 270 top
Q55  *2N7002KDW  [SOT363-2_1-65-6P]  214.25 10.73 0 top
Q56  2N7002KTB  [SOT23-1_38-5-3P]  74.44 162.83 180 bottom
Q57  PJX8838  [SOT563-1_6-5-6P-PJX138K]  78.38 160.93 180 bottom
Q58  2N7002KTB  [SOT23-1_38-5-3P]  74.31 159.53 180 bottom
Q59  *METR3904-G  [SOT23-2-95-3P]  26.06 158.79 0 bottom
Q60  PJX8838  [SOT563-1_6-5-6P-PJX138K]  78.38 158.39 180 bottom
Q61  *PJX8838  [SOT563-1_6-5-6P-PJX138K]  22.88 150.28 0 bottom
Q62  SSM6N43FU  [SC70-2_1-65-6P]  9.29 141.39 180 bottom
Q63  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  27.07 104.36 180 bottom
Q64  PJA138K  [SOT23-2-95-3P]  15.06 101.8 270 bottom
Q65  *SSM6N43FU  [SC70-2_1-65-6P]  10.46 79.72 0 bottom
Q66  2N7002KDW  [SOT363-2_1-65-6P]  180.63 65.73 180 bottom
Q67  METR3904-G  [SOT23-2-95-3P]  193.67 60.44 90 bottom
Q68  2N7002K  [SOT23-2-95-3P]  192.7 57.12 90 bottom
Q69  *2N7002KTB  [SOT23-1_38-5-3P]  252.24 50.84 270 bottom
Q70  PJX138K  [SOT363-2_1-65-6P-PJ4N3KDW]  202.33 50.84 180 bottom
Q71  PJA3413  [SOT23-2-95-3P]  18.52 45.35 270 bottom
Q72  2N7002KTB  [SOT23-1_38-5-3P]  186.4 35.58 0 bottom
Q73  PJA138K  [SOT23-2-95-3P]  88.79 34.08 90 bottom
Q74  PJX8838  [SOT563-1_6-5-6P-PJX138K]  246.09 25.65 270 bottom
Q75  PJA3413  [SOT23-2-95-3P]  91.92 22.6 270 bottom
Q76  PJA3413  [SOT23-2-95-3P]  68.95 21.81 90 bottom
Q77  2N7002K  [SOT23-2-95-3P]  94.92 24.91 0 bottom
Q78  PJA138K  [SOT23-2-95-3P]  189.15 38.77 270 top
Q79  *AO3413  [SOT23-2_38-95-3P]  96.08 18.71 180 bottom
Q80  *DDTC144EUA-7-F  [SOT23-1_7-65-3P]  102.51 158.31 270 bottom
Q81  *EV@2N7002KW  [SOT23-1_7-65-3P]  102.38 155.36 180 bottom
QG1  *PJC138K  [SOT23-1_7-65-3P]  83.58 134.34 90 top
QG2  *PJC138K  [SOT23-1_7-65-3P]  92.92 132.83 90 top
QG3  DMG1012T-7  [SOT23-1_38-5-3P]  21.68 104.11 0 top
QG4  MMBT3904  [SOT23-2-95-3P]  17.76 101.57 180 top
QG5  DMG1012T-7  [SOT23-1_38-5-3P]  26.79 96.68 90 top
QG6  MMBT3904  [SOT23-2-95-3P]  29.59 95.86 180 top
QG7  MMBT3904  [SOT23-2-95-3P]  23.9 95.31 270 top
QG8  MMBT3904  [SOT23-2-95-3P]  25.87 91.62 270 top
QG9  DMG1012T-7  [SOT23-1_38-5-3P]  21.77 86.58 90 top
QG10  PJT138KA  [SOT363-2_1-65-6P-PJ4N3KDW]  26 86 0 top
QG11  PJX138K  [SOT363-2_1-65-6P-PJ4N3KDW]  31.26 82.59 180 top
QG12  2N7002KDW  [SOT363-2_1-65-6P]  35.58 82.59 180 top
QG13  DMG1012T-7  [SOT23-1_38-5-3P]  43.9 82.58 270 top
QG14  PJT138K  [SOT363-2_1-65-6P-PJ4N3KDW]  26.05 82.46 0 top
QG15  DMG1012T-7  [SOT23-1_38-5-3P]  38.75 80.94 0 top
QG16  PJT138KA  [SOT363-2_1-65-6P-PJ4N3KDW]  36.44 78.81 180 top
QG17  *PJC138K  [SOT23-1_7-65-3P]  21.86 147.74 90 bottom
QG18  PJT138KA  [SOT363-2_1-65-6P-PJ4N3KDW]  8.28 105.69 270 bottom
QG19  *PJC138K  [SOT23-1_7-65-3P]  14.7 104.94 180 bottom
QG20  *SSM6N43FU  [SC70-2_1-65-6P]  9.95 82.74 90 bottom
QG21  DMG1012T-7  [SOT23-1_38-5-3P]  44.62 83.46 0 bottom
QG22  DMG1012T-7  [SOT23-1_38-5-3P]  30.37 81.58 270 bottom
QG23  PJT138KA  [SOT363-2_1-65-6P-PJ4N3KDW]  47.39 79.52 0 bottom
QG24  2N7002K  [SOT23-2-95-3P]  29.81 77.36 270 bottom
QG25  *2N7002K  [SOT23-2-95-3P]  26.28 77.36 270 bottom
R1  *4.7K_5%_4  [R0402]  61.61 164.13 270 top
R3  4.7K_5%_4  [R0402]  59.45 164.15 90 top
R6  *4.7K_5%_4  [R0402]  60.52 164.15 90 top
R7  *short_0402  [S0402]  76.35 165.34 180 top
R9  *0_5%_4  [R0402]  76.35 164.38 0 top
R10  2.2K_5%_4  [R0402]  57.3 164.13 270 top
R11  2.2K_5%_4  [R0402]  58.31 164.13 270 top
R12  100K_1%_4  [R0402]  42.78 161.25 0 top
R13  *short_0603  [S0603]  73.32 162.91 180 top
R14  *short_0603  [S0603]  73.31 161.5 0 top
R15  *10K_1%_4  [R0402]  47.22 162.77 270 top
R16  *100K_5%_4  [R0402]  63.58 160.24 180 top
R17  *0_5%_4  [R0402]  65.31 160.26 180 top
R18  *short_0201  [S0201]  82.06 160.09 270 top
R19  *0_5%_6  [R0603]  73.22 160 0 top
R20  *short_0402  [S0402]  47.53 161.1 0 top
R21  10K_1%_2  [R0201]  75.46 162.46 0 top
R22  100K_5%_4  [R0402]  96.28 156.38 270 top
R23  1K_1%_4  [R0402]  91.23 148.53 0 top
R24  1K_1%_4  [R0402]  89.71 148.3 90 top
R25  *1K_1%_4  [R0402]  92.86 148.17 270 top
R26  1K_1%_4  [R0402]  93.87 148.17 270 top
R27  *1K_1%_4  [R0402]  94.89 148.17 90 top
R28  *1K_1%_4  [R0402]  95.9 148.17 270 top
R29  1K_1%_4  [R0402]  96.92 148.17 90 top
R30  *1K_1%_4  [R0402]  97.94 148.17 270 top
R31  100_1%_4  [R0402]  138.73 138.4 180 top
R32  100_1%_4  [R0402]  136.95 138.39 0 top
R33  *1M_5%_4  [R0402]  174.49 137.99 180 top
R34  100K_5%_4  [R0402]  177.79 136.03 270 top
R35  220_1%_4  [R0402]  164.1 134.28 180 top
R36  56.2_1%_4  [R0402]  165.88 134.28 180 top
R37  *short_0603  [S0603]  179.37 133.95 0 top
R38  *short_0402  [S0402]  164.1 133.26 180 top
R39  *54.9_1%_4  [R0402]  165.88 133.26 0 top
R40  *short_0402  [S0402]  179.7 132.71 0 top
R41  *short_0402  [S0402]  164.1 132.12 180 top
R42  100_1%_4  [R0402]  165.88 132.12 0 top
R43  *Short_0402  [S0402]  115.92 131.69 180 top
R44  100K_5%_4  [R0402]  177.69 131.61 0 top
R45  *10_5%_4  [R0402]  179.83 131.61 0 top
R46  1K_1%_4  [R0402]  114.18 131.61 0 top
R47  *short_0402  [S0402]  164.99 130.98 180 top
R48  *Short_0402  [S0402]  115.92 130.73 180 top
R49  100K_5%_4  [R0402]  177.69 130.6 0 top
R50  1K_1%_4  [R0402]  179.85 130.6 0 top
R51  *short_0402  [S0402]  114.18 130.6 180 top
R52  13_1%_4  [R0402]  163.53 130.4 270 top
R53  *short_0402  [S0402]  164.94 129.96 0 top
R54  33_1%_2  [R0201]  170.28 129.15 180 top
R55  1K_1%_4  [R0402]  113.94 129.62 180 top
R56  33_5%_4  [R0402]  179.85 129.58 0 top
R57  20_1%_4  [R0402]  163.85 128.82 0 top
R58  33_5%_4  [R0402]  179.85 128.57 0 top
R59  *short_0402  [S0402]  169.72 125.39 270 top
R60  *0_5%_4  [R0402]  169.67 128.08 0 top
R61  20_1%_4  [R0402]  113.97 128.3 0 top
R62  *100K_1%_4  [R0402]  115.75 128.3 0 top
R63  *Short_0402  [S0402]  110.74 127.56 180 top
R64  *short_0402  [S0402]  179.85 127.55 0 top
R65  *51_5%_4  [R0402]  163.85 126.66 0 top
R66  *short_0402  [S0402]  179.85 126.41 0 top
R67  1K_1%_4  [R0402]  167.66 125.41 90 top
R68  499_1%_4  [R0402]  163.9 125.37 0 top
R69  51_5%_4  [R0402]  166.01 124.88 0 top
R70  *short_0402  [S0402]  179.85 124.37 0 top
R71  *51_5%_4  [R0402]  163.92 123.84 0 top
R72  51_5%_4  [R0402]  166.01 123.84 0 top
R73  *51_5%_4  [R0402]  167.81 123.48 180 top
R74  *short_0402  [S0402]  179.85 123.36 0 top
R75  1K_1%_4  [R0402]  163.92 122.83 180 top
R76  *56.2_1%_4  [R0402]  167.81 122.47 180 top
