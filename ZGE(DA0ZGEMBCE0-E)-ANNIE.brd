# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPUT_CLK: length 143
  TOP w0.14: R274.2 78.66,38.1 78.54,38.21 78.54,38.83 78.64,38.93 78.64,38.97 v1(78.67,39)
  IN1 w0.086: v1(78.67,39) 78.34,39 78.04,39.3 76.48,39.3 75.83,39.95 75.44,39.95 75.08,40.3 71.33,40.3 70.01,41.62 64.8,41.62 60.72,45.7 59.37,45.7 59.07,46.01 53.53,46.01 53.14,46.4 47.9,46.4 46.88,47.41 46.88,48.05 46.39,48.54 45.51,48.54 45.3,48.33 45.3,44.41 44.78,43.89 43.73,43.89 42.32,42.48 39.15,42.48 38.88,42.21 36.67,42.21 36.16,42.72 35.1,42.72 35.03,42.79 33.78,42.79 33.48,42.48 32.53,42.48 31.87,43.15 31.87,43.49 31.53,43.82 28.4,43.82 26.18,46.04 25.4,46.04 25.2,46.24 23.18,46.24 17.14,52.29 17.14,56.15 13.03,60.26 13.03,69.46 12.36,70.13 12.36,75.36 11.76,75.96 11.76,76.92 12.17,77.32 12.17,77.84 12.62,78.29 12.62,84.73 13.92,86.02 15.34,86.02 16.57,87.25 16.57,88.86 15.34,90.09 15.34,92.9 15.39,92.95 15.39,98.43 14.47,99.36 14.47,102.37 13.52,103.31 9.1,103.31 8.12,102.34 v1(8.12,102.18)
  BOTTOM w0.14: QG18.3 7.63,103.78 v1(7.63,103.77) 7.63,102.89 8.12,102.4 v1(8.12,102.18)
GPUT_DATA: length 150.5
  TOP w0.14: R275.2 77.87,37.6 77.87,38.18 77.35,38.69 77.35,39.72 v1(77.3,39.77)
  IN1 w0.086: v1(7.49,102.33) 8.91,103.76 13.71,103.76 14.91,102.55 14.91,99.54 15.83,98.62 15.83,92.8 15.78,92.75 15.78,90.27 17.05,89.01 17.05,87.1 15.52,85.58 14.1,85.58 13.06,84.54 13.06,78.11 12.61,77.65 12.61,77.14 12.21,76.73 12.21,76.14 12.8,75.54 12.8,70.31 13.47,69.65 13.47,60.44 17.58,56.33 17.58,52.47 23.37,46.68 25.39,46.68 25.59,46.49 26.36,46.49 28.58,44.27 31.72,44.27 32.54,43.45 35.15,43.45 35.44,43.16 36.34,43.16 36.85,42.65 38.7,42.65 38.96,42.92 42.14,42.92 43.55,44.33 44.6,44.33 44.86,44.59 44.86,48.51 45.33,48.98 46.57,48.98 47.32,48.23 47.32,47.6 48.08,46.84 53.32,46.84 53.71,46.45 59.25,46.45 59.56,46.14 60.9,46.14 64.98,42.06 70.19,42.06 71.08,41.17 74.84,41.17 75.62,40.39 76.68,40.39 v1(77.3,39.77)
  BOTTOM w0.14: QG18.6 8.93,107.83 7.99,108.77 7.04,108.77 6.42,108.14 6.42,104.59 7.04,103.96 7.04,102.77 v1(7.49,102.33)
GSPI0_MOSI: length 11.3
  TOP w0.102: v1(218.19,22.1) 218.16,22.13 218.16,23.2 217.85,23.52 217.85,24.3 U14.BE30
  BOTTOM w0.102: 219.4,20.77 219.4,21.28 218.58,22.1 v1(218.19,22.1)
  BOTTOM w0.14: R1126.2 217.85,15.01 217.85,16.78 R1095.1 218.86,17.79 219.17,17.79 219.49,18.11 219.49,18.6 219.4,18.69 219.4,20.77
GSPI1_MOSI: length 11.9
  TOP w0.14: v1(216.49,26.55) 216.49,26.56 216.32,26.39 U14.BA26
  BOTTOM w0.102: 216.83,20.77 216.83,20.86 217.05,21.08 217.05,21.62 216.92,21.75 216.92,23.42 v1(217.12,23.63) 217.12,23.96 216.92,24.16 216.92,25.16 216.49,25.58 v1(216.49,26.55)
  BOTTOM w0.14: R1096.2 217.51,17.27 218.39,18.15 218.39,18.49 218.07,18.81 217.66,18.81 217.52,18.95 217.52,19.46 216.83,20.15 R1036.1 216.83,20.77
H_CPU_SVIDALRT#: length 12.7
  TOP w0.114: v1(154.87,127.29) 155.19,126.96 U3.BH31
  TOP w0.14: v1(161.84,133.49) 161.84,133.8 162.32,134.28 R35.1
  IN2 w0.089: v1(161.84,133.49) 161.84,133.09 159.81,131.05 159.12,131.05 155.88,127.82 155.43,127.82 154.9,127.29 v1(154.87,127.29)
H_CPU_SVIDDAT: length 20.3
  TOP w0.089: 164.51,131.61 164.01,131.61 163.71,131.91 R41.1 163.33,132.5 162.07,132.5
  TOP w0.114: U3.BH29 155.13,125.08 v1(155.19,125.03)
  TOP w0.14: 164.51,131.61 164.98,131.61 R42.2 ; 162.07,132.5 160.73,133.85 v1(159.51,133.85)
  IN2 w0.089: v1(159.51,133.85) 160.09,133.27 160.09,132.22 159.39,131.52 158.92,131.52 155.69,128.29 155.23,128.29 154.77,127.83 154.63,127.83 154.27,127.47 154.27,125.94 v1(155.19,125.03)
H_PM_DOWN: length 125.9
  TOP w0.102: v1(202.2,34.1) 202.34,33.97 U14.AE2
  TOP w0.14: R57.1 164.24,128.82 164.89,128.82 v1(165.47,128.25)
  IN2 w0.089: v1(165.47,128.25) 165.65,128.06 171.81,128.06 172.63,127.24 172.63,124.96 173.86,123.73 173.86,112.59 176.79,109.66 177.24,109.66 177.96,108.93 177.96,103.51 178.84,102.64 178.84,94.01 179.85,93 179.85,89.71 181.19,88.38 181.19,87.45 176.55,82.81 176.55,78.85 176.91,78.49 176.91,76.15 176.55,75.79 176.55,67.76 179.71,64.6 180.2,64.6 183.98,60.82 183.98,60.31 187.24,57.05 190.16,57.05 191.06,56.15 191.06,54.85 190.56,54.35 190.24,54.35 189.71,53.81 189.71,51.36 192.99,48.08 192.99,47.2 193.59,46.6 193.59,46.17 193.95,45.81 193.95,45.13 193.29,44.47 193.29,42.34 194.7,40.92 195.03,40.92 196.21,39.75 196.21,39.27 197.22,38.25 197.22,37.6 200.72,34.1 v1(202.2,34.1)
H_PM_DOWN_R: length 5.7
  TOP w0.114: U3.BP31 159.33,127.5 159.9,127.5 160,127.4 160.98,127.4
  TOP w0.14: R57.2 163.1,129.18 162.63,129.18 161.64,128.18 161.64,128.05 160.98,127.4
H_PRDY#: length 107.8
  TOP w0.079: 160.54,122.83 158.79,122.83 158.62,123 158.62,123.64 U3.BP27
  TOP w0.089: 163.72,123.31 163.21,123.31 163.17,123.27 160.98,123.27 160.54,122.83
  TOP w0.14: R234.2 191.44,40.64 191.74,40.95 v1(191.74,41.29) ; v1(165.63,122.85) 165.17,123.31 163.72,123.31
  IN2 w0.089: v1(165.63,122.85) 166.46,122.01 166.46,120.79 167.91,119.35 167.91,112.9 170.1,110.71 171.4,110.71 174.35,107.76 174.35,105.27 175.84,103.77 175.84,94.63 174.31,93.1 174.31,81.79 173.5,80.98 173.5,73.25 174.31,72.43 174.31,65.17 175.49,63.99 175.49,62.98 178.02,60.45 178.24,60.45 179.45,59.24 180.07,59.24 180.89,58.42 180.89,57.47 183.36,55 183.36,53.38 183,53.03 183,51.63 183.89,50.74 186.04,50.74 187.14,49.64 187.14,46.46 187.65,45.95 188.61,45.95 190.08,44.47 190.82,44.47 191.18,44.11 191.18,42.87 191.05,42.74 191.05,42.41 191.31,42.16 191.41,42.16 191.74,41.82 v1(191.74,41.29)
H_PRDY#_L: length 19.1
  TOP w0.102: U14.AM5 205.51,30.74 204.62,30.74 204.49,30.86 204.01,30.86 203.82,31.06 202.81,31.06 202.55,30.81 201.84,30.81 201.19,31.45
  TOP w0.14: R234.1 191.44,39.15 191.82,38.77 v1(191.86,38.77) 194.87,38.77 197.63,36.01 197.63,35.75 198.41,34.97 198.41,34.08 199.68,32.82 R345.2 199.98,32.67 201.19,31.46 201.19,31.45
H_PREQ#: length 111.5
  TOP w0.127: U3.BL30 156.88,126.31 v1(157.24,125.95)
  TOP w0.14: R233.2 192.4,41.05 192.21,41.24 192.21,41.91 191.59,42.54 v1(191.53,42.54) ; v1(168.07,121.05) 168.2,121.18 R76.2
  IN2 w0.089: v1(191.53,42.54) 191.38,42.69 191.38,44.31 189.05,46.65 189.05,48.3 188.26,49.09 187.95,49.09 187.67,49.37 187.67,49.72 186.22,51.18 184.07,51.18 183.43,51.82 183.43,52.85 183.8,53.21 183.8,55.17 181.32,57.65 181.32,58.6 180.25,59.67 179.63,59.67 178.72,60.58 178.72,61.37 174.75,65.34 174.75,72.61 173.93,73.43 173.93,80.8 174.75,81.62 174.75,90.87 175.52,91.64 175.52,93.69 176.28,94.45 176.28,106.45 169.26,113.47 169.26,119.85 v1(168.07,121.05)
  IN2 w0.102: v1(157.24,125.95) 157.62,126.33 161.29,126.33 162.09,127.12 163.17,127.12 164.29,126 164.29,125.2 164.79,124.71 165.05,124.71 168.07,121.69 v1(168.07,121.05)
H_PREQ#_L: length 16.5
  TOP w0.102: U14.AL2 204.06,31.26 202.72,31.26 202.54,31.08 201.88,31.08 201.39,31.56 201.39,31.65 201.32,31.72
  TOP w0.14: R233.1 192.9,39.15 194.41,39.15 194.59,39.33 v1(194.8,39.33) 195.04,39.33 195.42,38.95 195.42,38.62 197.94,36.1 197.94,35.88 198.66,35.16 198.66,34.38 201.32,31.72
H_PROCHOT#: length 281.2
  TOP w0.14: v1(68.41,40.45) 68.41,38.91 67.88,38.38 66.84,38.38 66.81,38.35 65.69,37.23 Q29.3 ; v1(181.36,172.67) 181.72,172.67 182.18,172.21 182.18,170.8 PR22.2 PR25.2 ; v1(169.11,124.4) 168.73,124.78 C60.2 168.12,125.02 168.12,125.02 R67.2 167.37,125.02 167,125.4 166.14,125.4 165.88,125.65 164.57,125.65 R68.1
  IN3 w0.089: v1(181.36,172.67) 181.28,172.59 174.83,172.59 174.21,171.97 174.21,169.76 173.72,169.28 173.72,160.39 176.53,157.58 176.53,152.42 174.01,149.9 174.01,146.84 172.76,145.59 172.76,137.89 170.53,135.66 170.53,131.14 169.8,130.4 169.8,129.62 168.85,128.68 168.85,124.65 v1(169.11,124.4) 169.8,123.71 169.8,114.04 168.97,113.21 168.97,112.09 169.46,111.6 170.07,111.6 172.45,109.22 172.45,94.47 171.48,93.5 171.48,92.68 173.01,91.15 173.01,89.09 172.1,88.18 172.1,86.08 170.61,84.58 170.61,81.4 171.48,80.53 171.48,67.02 174.82,63.67 174.82,62.98 175.42,62.39 175.42,61.05 v1(176.09,60.37)
  IN4 w0.086: v1(176.09,60.37) 175.56,60.37 174.74,61.2 174.29,61.2 173.65,61.84 172.9,61.84 163.12,71.61 116.89,71.61 114.08,68.81 110.35,68.81 110.08,69.09 102.66,69.09 98.95,65.38 98.12,65.38 97.66,64.93 95.52,62.79 95.3,62.79 94.39,61.87 92.71,61.87 92.07,61.23 92.07,59.3 v1(92.3,59.07) 92.42,59.07 92.86,59.5 93.38,59.5 93.82,59.06 93.82,58.46 92.91,57.55 92.2,57.55 91.38,56.73 91.38,54.89 89.41,52.91 87.18,52.91 85.21,50.95 85.21,49.39 82.91,47.08 82.91,44.55 81.99,43.64 81.99,42.4 80.61,41.01 74.09,41.01 73.34,40.27 68.59,40.27 v1(68.41,40.45)
  BOTTOM w0.14: v1(92.3,59.07) 92.3,58.82 92.83,58.28 PR484.2
H_PROCHOT#_CPU: length 6.7
  TOP w0.127: R68.2 161.41,125.37 160.93,125.85 160.01,125.85 U3.BR30
  TOP w0.14: EC1.2 165.06,126.15 164.86,125.95 164.09,125.95 R68.2
H_PROCHOT#_R: length 22.2
  TOP w0.14: v1(99.52,57.74) 99.14,57.74 99,57.6 PR194.1 99,57.45
  TOP w0.152: 99,57.45 99,57.12 99.26,56.86 PR197.1 99.51,56.86 99.71,56.65 99.71,55.97 99.18,55.44 99.18,55.03 98.52,54.38 98.41,54.38 98.38,54.35 97.86,54.35 97.83,54.38 PU23.10
  IN4 w0.086: v1(99.52,57.74) 100.09,57.17 100.09,54.45 97.84,52.2 94.43,52.2 v1(93.47,51.24)
  BOTTOM w0.14: v1(93.47,51.24) 93.5,51.24 93.53,51.21 94.09,51.21 PQ53.2 94.29,51.67 94.05,51.91 PR507.1 93.2,52.33 v1(92.83,52.7) 92.53,52.7 92.47,52.65 91.91,52.65 PQ52.2
H_TCK: length 113.9
  TOP w0.14: U3.BR28 159.93,125.09 162.25,125.09 162.6,124.73 165.47,124.73 R69.2 165.31,125.19 v1(164.97,125.19) ; v1(190.85,46.78) 190.42,46.35 190.42,45.15 190.91,44.66 192.28,44.66 192.91,44.03 192.91,43.34 193.56,42.69 193.56,42.18 194.25,41.49 195.14,41.49 196.7,39.93 198.23,39.93 198.64,39.52 R248.2
  IN2 w0.089: v1(190.85,46.78) 190.29,46.78 189.26,47.81 189.26,49.53 188.47,50.32 187.77,50.32 186.89,51.2 186.89,51.9 186.07,52.73 186.07,54.12 184.71,55.48 183.83,55.48 181.54,57.77 181.54,58.69 180.28,59.95 180.28,60.27 179.21,61.35 179.21,62.03 178.85,62.39 178,62.39 174.96,65.43 174.96,72.7 174.14,73.52 174.14,80.71 174.96,81.53 174.96,84.88 176.19,86.1 176.19,90.84 176.8,91.45 176.8,93.94 176.5,94.24 176.5,106.54 169.54,113.5 169.54,121.08 165.69,124.93 165.23,124.93 v1(164.97,125.19)
H_TDI: length 117.4
  TOP w0.14: U3.BL32 157.24,127.2 v1(157.24,126.64) ; v1(191.81,43.86) 192.27,43.4 192.27,43.22 193.03,42.47 193.03,41.96 194.05,40.94 194.91,40.94 196.64,39.2 R244.2 ; R73.2 168.3,123.48 169.11,122.68 v1(169.11,122.64)
  IN2 w0.089: v1(157.24,126.64) 161.28,126.64 161.99,127.35 163.26,127.35 164.68,125.93 165.3,125.93 166.38,124.86 167.23,124.86 169.11,122.98 v1(169.11,122.64) 169.97,121.77 169.97,116.41 172.18,114.21 172.18,111.47 176.71,106.94 176.71,94.64 177.01,94.34 177.01,90.78 176.45,90.22 176.45,85.76 175.18,84.49 175.18,81.44 174.36,80.62 174.36,73.61 175.18,72.79 175.18,65.52 178.09,62.61 178.94,62.61 179.43,62.12 179.43,61.44 180.5,60.36 180.5,60.04 181.75,58.78 181.75,57.86 183.92,55.69 184.8,55.69 186.29,54.21 186.29,52.84 187.11,52.02 187.11,51.29 187.86,50.54 188.59,50.54 189.48,49.65 189.48,47.9 189.76,47.62 190.87,47.62 191.26,47.24 191.26,46.55 191,46.3 190.8,46.3 190.54,46.04 190.54,45.48 191.81,44.21 v1(191.81,43.86)
H_TDO: length 99.3
  TOP w0.14: v1(188.33,46.75) 188.33,46.47 187.97,46.11 v1(187.97,45.95) 188.05,45.88 188.34,45.88 188.59,46.12 R188.2 ; U3.BT28 160.27,124.78 162.02,124.78 162.42,124.38 165.19,124.38 165.62,123.95 R72.2 165.62,123.55 v1(166.29,122.88)
  IN2 w0.089: v1(188.33,46.75) 188.33,47.13 187.46,48.01 187.46,49.63 186.13,50.96 183.98,50.96 183.22,51.73 183.22,52.94 183.58,53.3 183.58,55.08 181.1,57.56 181.1,58.51 180.16,59.46 179.54,59.46 178.33,60.67 178.11,60.67 175.71,63.07 175.71,64.08 174.53,65.25 174.53,72.52 173.71,73.34 173.71,80.89 174.53,81.71 174.53,90.96 175.31,91.73 175.31,93.78 176.06,94.54 176.06,103.86 174.57,105.36 174.57,107.85 171.49,110.93 171.31,110.93 170.19,110.93 168.32,112.79 168.32,119.75 167.56,120.51 167.56,121.89 166.57,122.88 v1(166.29,122.88)
H_TMS: length 112.2
  TOP w0.089: U3.BP28 159.25,124.39 161.95,124.39 162.22,124.12 163.26,124.12 R71.2 163.38,123.69 v1(162.91,123.69)
  TOP w0.14: R264.2 196.44,38.74 196.44,39.01 194.79,40.66 193.95,40.66 192.76,41.85 192.76,42.36 191.72,43.4 191.59,43.4 191.09,43.9 v1(190.77,43.9)
  IN2 w0.089: v1(162.91,123.69) 162.91,123.61 163.67,122.85 163.67,122.06 165.64,120.09 166.86,120.09 167.68,119.27 167.68,112.82 170.01,110.49 171.3,110.49 174.13,107.66 174.13,105.17 175.62,103.68 175.62,94.72 174.09,93.19 174.09,81.88 173.28,81.07 173.28,73.16 174.09,72.35 174.09,65.09 175.27,63.9 175.27,62.89 177.93,60.24 178.15,60.24 179.36,59.03 179.98,59.03 180.67,58.33 180.67,57.38 183.14,54.91 183.14,53.47 182.78,53.12 182.78,51.53 183.8,50.52 185.94,50.52 186.91,49.55 186.91,46.37 187.56,45.72 188.51,45.72 190.07,44.17 190.5,44.17 v1(190.77,43.9)
H_TRST#: length 120.9
  TOP w0.079: 161.51,126.59 159.2,126.59 U3.BP30
  TOP w0.089: 161.72,126.59 161.51,126.59
  TOP w0.14: R346.2 196.82,34.53 195.65,35.7 195.37,35.7 194.24,36.83 193.58,36.83 192.15,38.26 191.71,38.26 190.98,38.99 190.98,40.68 191.24,40.94 v1(191.24,41.75) ; 161.72,126.59 162.04,126.91 163.21,126.91 R65.2 163.2,126.41 v1(162.73,126.41)
  IN2 w0.089: v1(191.24,41.75) 190.7,42.29 190.7,42.68 189.78,43.59 189.78,44.15 189.27,44.66 189.27,44.66 188.42,45.51 187.45,45.51 186.66,46.3 186.66,49.5 185.85,50.3 183.71,50.3 182.57,51.44 182.57,53.21 182.92,53.56 182.92,54.82 180.46,57.29 180.46,58.24 179.89,58.81 179.27,58.81 178.06,60.02 177.84,60.02 175.06,62.8 175.06,63.81 173.87,65 173.87,72.26 173.06,73.07 173.06,81.16 173.87,81.97 173.87,93.28 175.4,94.81 175.4,103.59 173.92,105.08 173.92,107.57 171.21,110.28 169.92,110.28 167.47,112.73 167.47,119.18 166.77,119.87 165.55,119.87 163.45,121.97 163.45,122.76 163.16,123.05 162.83,123.05 162.32,123.56 162.32,126 v1(162.73,126.41)
H_TRST#_L: length 9.6
  TOP w0.102: R364.2 200.23,30.52 200.3,30.59 201.15,30.59 201.57,30.17 202.45,30.17 202.8,29.81 203.8,29.81 204,30.01 204.45,30.01 204.62,30.17 204.78,30.17 U14.AM4
  TOP w0.14: R346.1 197.51,31.48 v1(197.51,31.37) 197.72,31.16 199.09,31.16 R364.2
H_VCCST_PWRGD: length 3.9
  TOP w0.14: Q16.6 106.06,103.23 106.04,103.2 R107.2 105.59,103.2 104.78,102.39 R108.1 104.43,102.39 103.64,103.17 C92.1
HDMI_HPD: length 23.4
  TOP w0.14: CN1.19 68.46,166.19 69.72,166.19 RV1.1 C9.1 v1(69.27,164.9)
  IN1 w0.086: v1(69.27,164.9) 69.27,163.64 67.71,162.09 63.32,162.09 61.82,163.59 57.75,163.59 v1(56.28,162.12)
  BOTTOM w0.14: v1(56.28,162.12) 56.04,162.12 55.8,162.36 U34.21
HDMI_HPD_DC: length 3.7
  TOP w0.14: R20.2 47.14,161.49 47.47,161.81 47.79,161.81 ; 47.79,161.81 v1(47.82,161.81) ; 47.79,161.81 R15.1
  BOTTOM w0.14: U34.40 48.65,162.36 48.4,162.11 48.12,162.11 v1(47.82,161.81)
HDMI_HPD_PCH: length 373.9
  TOP w0.14: v1(16.86,103.29) 17.08,103.51 17.08,104.39 16.94,104.53 CG38.1 16.66,105.12 17.05,105.5 v1(18.05,105.5) 18.05,105.19 RG9.2 ; v1(48.41,160.32) 47.92,160.8 R20.1
  IN2 w0.089: v1(102.27,91.98) 102.27,92.84 102.15,92.96 102.15,96.73 103.14,97.73 103.14,99.33 104.34,100.53 104.34,129.55 97.73,136.16 97.73,142.89 94.91,145.71 92.45,145.71 91.21,146.96 91.21,148.99 90.42,149.77 90.42,151.2 89.07,152.54 89.07,155.13 87.7,156.51 87.17,156.51 84.83,158.84 81.06,158.84 78.85,161.05 77.98,161.05 77.7,160.77 76.21,160.77 75.86,161.13 74.51,161.13 73.98,161.66 72.41,161.66 71.03,160.29 69.65,160.29 67.94,158.58 65.35,158.58 64.77,159.17 64.48,159.17 63.23,160.41 61.72,160.41 61.17,160.96 57.49,160.96 57,160.47 48.56,160.47 v1(48.41,160.32) ; v1(98.72,82.52) 98.57,82.67 98.57,84.95 94.63,88.89 87.01,88.89 81.62,83.51 62.48,83.51 61.6,84.4 57.07,84.4 55.35,86.12 54.24,86.12 52.34,88.02 52.34,89.95 48.26,94.03 48.26,97.92 48.84,98.49 48.84,99.43 48.5,99.77 43.39,99.77 43.23,99.93 43.23,100.36 42.39,101.2 39.27,101.2 38.86,101.62 38.86,101.87 38.37,102.35 36.85,102.35 36.29,102.91 35.53,102.91 34.58,101.97 34.58,99.32 34.16,98.9 32.69,98.9 31.95,99.64 31.95,99.83 31.43,100.35 30.27,100.35 29.3,101.32 25.2,101.32 23.16,103.36 19.65,103.36 19.11,102.82 18.12,102.82 17.64,103.29 v1(16.86,103.29)
  IN3 w0.089: v1(102.27,91.98) 102.27,91.53 98.72,87.98 v1(98.72,82.52) 99.15,82.1 99.15,79.7 98.8,79.35 98.8,77.41 99.15,77.06 99.15,76.31 v1(98.86,76.02)
  IN4 w0.086: v1(201.21,53.64) 201.21,53.64 200.45,54.4 199.74,54.4 198.7,53.36 198.36,53.36 197.61,52.61 195.66,52.61 194.83,51.79 190.33,51.79 189.25,52.87 189.25,53.87 188.54,54.57 187.61,54.57 187.24,54.95 186.27,54.95 185.17,56.05 183.27,56.05 180.95,58.36 180.95,59.03 180.23,59.76 179.65,59.76 178.6,60.81 178.08,60.81 176.68,62.22 176.57,62.22 175.84,62.96 175.84,64.01 164.73,75.12 115.34,75.12 112.43,72.21 105.76,72.21 105.18,72.79 102.28,72.79 100.54,74.53 100.54,75 100.18,75.37 99.31,75.37 98.86,75.81 v1(98.86,76.02)
  BOTTOM w0.14: v1(201.21,53.64) 201.42,53.85 203.03,53.85 204.23,52.65 R783.2 203.85,51.36 203.85,50.46 203.58,50.19 Q70.6
HDMI_HPD_PCH_R: length 35.5
  TOP w0.102: U14.AP9 207.49,29.88 v1(207.77,30.16)
  IN2 w0.089: v1(207.77,30.16) 207.55,30.38 207.55,31.02 207.82,31.28 208.4,31.28 208.78,31.66 208.78,32.22 208.9,32.34 208.9,33.38 208.43,33.84 204.88,33.84 204.48,34.25 204.48,35.56 203.7,36.34 201.6,36.34 198.1,39.84 198.1,41.07 196.72,42.46 196.72,43.29 196.41,43.6 196.41,47.99 197.66,49.24 198.24,49.24 v1(198.9,49.9)
  BOTTOM w0.14: Q70.1 201.56,50.01 R798.1 199.74,49.06 v1(198.9,49.9)
HDMI_RST#: length 4.6
  BOTTOM w0.14: R657.2 48.35,158.22 C525.2 48.28,158.79 48.53,159.05 v1(49.39,159.05) 49.5,159.05 50.42,159.96 U34.35
HDMI_SCLK: length 90.6
  TOP w0.14: v1(52.7,167.34) 52.7,167.2 53.13,166.77 53.82,166.77 54.08,167.03 56.43,167.03 57.3,166.16 R10.2
  IN1 w0.086: v1(9.44,144.87) 9.79,144.52 10.73,144.52 12.14,145.94 17.4,145.94 19.42,147.96 19.42,154.51 19.73,154.81 21,154.81 21.79,155.61 23.35,155.61 24.28,156.53 25.56,156.53 25.79,156.76 27.58,156.76 29.22,158.41 30.74,158.41 32.43,160.1 34.62,160.1 35.28,160.77 43.56,160.77 44.76,161.96 45.61,161.96 47.52,163.88 48.42,163.88 51.48,166.93 51.48,167.52 51.79,167.83 52.48,167.83 52.7,167.61 v1(52.7,167.34)
  IN3 w0.089: v1(69.78,166.88) 69.31,166.41 58.11,166.41 57.39,167.14 54.41,167.14 53.84,167.71 53.06,167.71 v1(52.7,167.34)
  BOTTOM w0.14: v1(52.7,167.34) 52.7,167.18 52.42,166.89 U34.7 ; R675.2 9.44,144.73 v1(9.44,144.87) ; v1(69.78,166.88) 70.14,166.52 RV4.1 66.38,166.27 CN1.15
HDMI_SDATA: length 92.4
  TOP w0.14: R11.2 58.31,165.52 56.54,167.29 v1(53.37,167.29)
  IN1 w0.086: v1(10.1,144.92) 10.23,144.8 10.7,144.8 12.05,146.15 17.31,146.15 19.21,148.05 19.21,154.6 19.64,155.03 20.91,155.03 21.7,155.82 23.22,155.82 24.15,156.75 25.47,156.75 25.7,156.98 27.49,156.98 29.13,158.62 30.65,158.62 32.34,160.32 34.53,160.32 35.19,160.98 43.47,160.98 44.67,162.18 45.52,162.18 47.44,164.09 48.33,164.09 51.27,167.02 51.27,167.61 51.7,168.04 52.57,168.04 53.32,167.29 v1(53.37,167.29)
  IN3 w0.089: v1(53.37,167.29) 53.9,167.29 54.27,166.92 57.3,166.92 58.02,166.2 70.03,166.2 v1(70.69,166.86)
  BOTTOM w0.14: R674.2 9.69,143.94 9.55,144.08 9.55,144.32 10.1,144.87 v1(10.1,144.92) ; U34.8 52.82,166.81 53.3,167.29 v1(53.37,167.29) ; CN1.16 66.05,168.33 66.57,167.81 68.09,167.81 68.47,167.43 70.88,167.43 71.27,167.05 71.27,166.45 RV3.1 70.69,166.7 v1(70.69,166.86)
HDMI_SEL#_A1: length 2.6
  BOTTOM w0.14: U34.32 51.62,159.95 51.66,159.91 51.66,159.11 R659.2
HOLLD#_7: length 2.5
  TOP w0.14: UG2.7 48.59,80.32 v1(48.22,79.95) 48.11,79.83 RG72.2
HP-L1: length 39.2
  TOP w0.203: U17.46 35.46,28.36 v1(35.54,28.28)
  IN3 w0.254: v1(35.54,28.28) 35.66,28.16 36.26,28.16 36.8,27.63 36.8,24.67 35.16,23.03 31.06,23.03 30.68,23.41 28.03,23.41 26.61,24.82 26.61,25.33 26.07,25.87 22.55,25.87 21.27,24.6 19.48,24.6 17.87,22.99 17.87,20.76 13.79,16.68 13.79,15.79 12.59,14.6 v1(12.46,14.6)
  BOTTOM w0.254: v1(12.46,14.6) 12.37,14.5 CN17.2
HP-R1: length 37.2
  TOP w0.203: U17.45 35.18,27.96 35.48,27.65 v1(35.71,27.65)
  IN3 w0.254: v1(12.9,15.59) 13.36,16.05 13.36,17.17 13.79,17.6 13.79,17.76 17.11,21.08 17.11,23.3 19.16,25.36 20.96,25.36 22.23,26.64 26.38,26.64 27.37,25.65 27.37,25.14 28.34,24.17 30.99,24.17 31.37,23.79 34.84,23.79 36.04,24.98 36.04,27.32 v1(35.71,27.65)
  BOTTOM w0.254: v1(12.9,15.59) 12.5,15.18 12.38,15.18 12.2,15 CN17.3
HP_JD#_EC: length 111
  TOP w0.14: v1(9.24,15.97) 9.34,15.97 9.81,15.5 R565.2 ; v1(82.59,26.03) 82.67,26.03 83.66,27.02 U18.80
  IN1 w0.086: v1(53.77,14.22) 53.77,14.27 53.03,15 50.06,15 47.58,17.48 42.12,17.48 40.53,15.89 38.02,15.89 37.69,15.56 v1(37.69,14.62)
  IN3 w0.089: v1(9.24,15.97) 9.16,15.89 9.16,12.72 7.77,11.32 7.77,10.81 8.23,10.34 10.99,10.34 14.64,13.99 28.73,13.99 29.53,14.79 31.86,14.79 32.49,14.16 37.22,14.16 v1(37.69,14.62) ; v1(53.77,14.22) 54,13.98 57.04,13.98 57.34,13.68 62.14,13.68 62.86,14.4 66.36,14.4 67.64,13.12 79.18,13.12 80.54,14.48 80.7,14.48 v1(81.15,14.93)
  IN4 w0.086: v1(82.59,26.03) 82.32,25.76 81.88,25.76 81.59,25.47 81.15,25.47 80.04,24.36 80.04,23.4 78.53,21.89 77.46,21.89 76.85,21.28 76.85,17.9 77.82,16.93 80.31,16.93 81.15,16.09 v1(81.15,14.93)
  BOTTOM w0.14: CN17.4 11.1,15.5 10.66,15.94 9.26,15.94 v1(9.24,15.97)
HP_JD#_EC_CODEC: length 80.9
  TOP w0.14: v1(65.35,26.4) 65.61,26.65 R401.2 ; v1(8.36,11.05) 8.28,10.97 8.28,10.22 Q53.2 7.11,10.11 R623.1
  IN1 w0.086: v1(65.35,26.4) 64.88,25.92 63.7,25.92 63.3,25.53 63.3,22.78 61.33,20.82 61.33,19.96 61.99,19.3 62.71,19.3 63.19,19.78 63.83,19.78 v1(63.97,19.92)
  IN3 w0.089: v1(63.97,19.92) 63.84,19.92 62.36,18.44 62.36,14.74 61.89,14.28 58.68,14.28 58.31,14.65 58.31,14.91 57.94,15.28 57.42,15.28 56.44,16.26 49.44,16.26 47.52,18.18 42.08,18.18 40.86,19.4 38.27,19.4 37.99,19.12 25.61,19.12 24.32,17.83 19.54,17.83 18.49,16.78 17.54,16.78 15.39,14.63 14.44,14.63 11.65,11.84 9.71,11.84 8.92,11.05 v1(8.36,11.05)
HPD_2PL: length 6.2
  TOP w0.102: TP12.1 31.79,95.37 34.26,95.37 35.54,96.65 UG1.BG1
HPD_IFPD: length 13.1
  TOP w0.102: UG1.BH1 35.86,95.95 34.5,94.59 34.21,94.59
  TOP w0.14: 34.21,94.59 32.58,94.59 32.33,94.34 30.99,94.34 30.48,93.82 RG29.2 27.59,93.02 26.99,92.43 26.07,92.43 QG8.3
HPD_TBT: length 17.5
  TOP w0.102: UG1.BG4 39.05,96.65 38.7,96.3 37.58,96.3 37.56,96.27 35.65,96.27 34.33,94.96 32.89,94.96
  TOP w0.14: QG7.3 25.13,96.31 v1(25.92,95.52) 26.07,95.37 26.88,95.37 RG28.2 27.86,94.39 29.03,94.39 29.17,94.53 29.17,94.7 29.32,94.85 29.65,94.85 29.97,95.16 30.4,95.16 30.98,94.58 32.23,94.58 32.6,94.96 32.89,94.96
HRESET: length 50.4
  TOP w0.14: v1(244.56,36.22) 244.56,36.38 245.35,37.17 U13.44
  IN2 w0.089: v1(235.85,20.78) 236.61,20.78 237.41,21.59 237.41,24.65 237.97,25.21 237.97,27.77 237.74,28 237.74,29.94 236.8,30.88 236.8,32.05 236.49,32.35 236.49,33.77 236.72,34 238.19,34 239.11,34.92 239.11,35.45 239.99,36.33 240.57,36.33 241.02,35.88 242.74,35.88 243.1,36.24 244.55,36.24 v1(244.56,36.22)
  IN4 w0.086: v1(235.85,20.78) 235.31,20.78 234.93,21.16 223.4,21.16 223.31,21.25 222.47,21.25 222.01,20.79 219.29,20.79 218.74,20.24 217.28,20.24 216.44,21.09 v1(216.44,21.33)
  BOTTOM w0.102: R998.2 216.09,22.27 216.09,21.68 v1(216.44,21.33)
  BOTTOM w0.14: R854.1 245.88,37.5 v1(245.05,36.67) 245.01,36.67 v1(244.56,36.22)
HWPG: length 144.1
  TOP w0.14: R368.1 52.33,30.55 53.28,31.49 53.28,32.89 53.5,33.12 55.16,33.12 55.45,33.41 55.45,33.92 55.38,33.99 55.38,34.42 54.91,34.89 54.91,35.17 55.68,35.94 55.68,37.25 D37.2 D38.2 58.72,38.84 D33.2 59.97,38.84 D35.2 61.11,37.83 61.99,36.95 62.95,36.95 63.96,35.94 64.32,35.94 v1(64.38,35.88) ; U18.21 67.88,25.42 v1(67.38,25.92) ; R104.1 105.63,106.35 106.23,106.95 v1(107.57,106.95)
  IN3 w0.089: v1(85.21,53.51) 85.57,53.87 86.32,53.87 87.43,54.98 87.43,55.88 88.4,56.85 88.4,58.53 89.19,59.32 89.19,59.32 90,60.13 90.6,60.13 91.56,61.08 91.56,66.66 94.3,69.41 94.3,71.73 96.62,74.04 97.94,74.04 100.94,77.05 100.94,78.26 104.29,81.61 104.29,82.68 v1(103.78,83.2)
  IN4 w0.086: v1(64.38,35.88) 65.47,36.97 65.47,42.27 62.58,45.16 62.58,48 63.52,48.94 64.81,48.94 66.68,50.81 68.26,50.81 68.52,51.08 70.23,51.08 70.47,51.32 73.6,51.32 74.03,50.89 74.55,50.89 75.88,52.22 75.88,52.47 76.72,53.31 77.32,53.31 78.54,52.09 79.9,52.09 80.33,52.51 83.53,52.51 84.52,53.51 v1(85.21,53.51) ; v1(107.57,106.95) 108,106.51 108,105.58 107.49,105.06 107.49,97.35 106.1,95.96 106.1,93.65 104.23,91.78 104.23,89.28 104.59,88.92 104.59,86.88 104.23,86.52 104.23,83.65 v1(103.78,83.2)
  BOTTOM w0.14: v1(67.38,25.92) 67.38,26.12 66.74,26.76 D106.2 66.74,27.63 67.06,27.94 67.06,28.42 66.29,29.19 66.29,30.71 66.6,31.03 66.6,32.03 65.77,32.86 65.77,34.4 64.38,35.78 v1(64.38,35.88)
HWPG_1.8VS5: length 140.3
  TOP w0.14: D33.1 59.56,36.34 v1(59.01,35.78) ; PR416.2 172.99,19.96 172.57,19.55 PR415.1 171.93,19.55 171.47,20.01 v1(171.47,20.64)
  IN3 w0.089: v1(171.47,20.64) 170.95,20.12 165.75,20.12 165.08,19.45 160.4,19.45 159.16,20.68 151.75,20.68 149.15,23.28 144.09,23.28 143.73,22.93 133.62,22.93 131.11,20.42 118.47,20.42 116.83,22.05 116.83,22.66 115.04,24.46 111.86,24.46 111.36,24.95 103.38,24.95 101.95,23.52 101.95,23.33 100.12,21.51 100.12,19.72 98.94,18.54 97.81,18.54 97.2,19.15 95.76,19.15 94.16,20.74 91.72,20.74 91.08,20.1 88.19,20.1 87.29,21.01 86.43,21.01 85.6,21.84 84.2,21.84 84.12,21.91 83.53,21.91 82.93,22.51 82.63,22.51 82.03,23.11 80.11,23.11 79.12,22.11 76.8,22.11 76.04,22.88 75.06,22.88 74.75,22.56 74.41,22.56 73.92,23.06 73.92,23.37 73.32,23.97 73.32,24.69 72.62,25.4 72.62,27.47 69.78,30.3 69.78,30.96 69.12,31.62 67.75,31.62 67.3,31.17 66.63,31.17 66.52,31.07 65.67,31.07 65.55,31.2 63.61,31.2 62.89,30.48 62.24,30.48 61.72,31 59.93,31 v1(59.66,31.26)
  IN4 w0.086: v1(59.01,35.78) 59.01,35.58 59.57,35.02 59.57,31.36 v1(59.66,31.26)
HWPG_1VS5: length 128.4
  TOP w0.14: v1(61.06,35.1) 61.11,35.14 61.11,36 D35.1 ; PR386.2 164.94,25.85 v1(164.54,25.46) 164.43,25.35 PU29.1
  IN3 w0.089: v1(60.89,31.69) 60.95,31.69 61.53,32.26 62.15,32.26 62.23,32.34 63.18,32.34 63.75,31.78 64.48,31.78 65.01,32.31 66.39,32.31 66.66,32.04 67.34,32.04 67.54,32.24 69.33,32.24 70.37,31.2 70.37,30.54 73.97,26.94 73.97,25.68 74.42,25.23 76,25.23 77.54,23.69 82.27,23.69 82.77,23.19 84.05,23.19 84.83,22.42 87.15,22.42 88.3,21.27 89.55,21.27 89.6,21.33 94.4,21.33 96,19.73 99.06,19.73 99.54,20.21 99.54,21.96 100.16,22.59 100.16,24.35 102.57,26.76 115.42,26.76 116.99,25.19 118.69,25.19 118.99,25.49 121.88,25.49 125.22,22.15 130.71,22.15 133.37,24.81 141.4,24.81 141.77,24.44 143.03,24.44 143.39,24.79 147.95,24.79 148.64,25.49 153.22,25.49 153.28,25.42 154.13,25.42 154.7,25.99 164.01,25.99 v1(164.54,25.46)
  BOTTOM w0.14: v1(61.06,35.1) 61.27,35.31 61.57,35.31 62.59,34.29 62.59,33.18 62.16,32.75 61.95,32.75 v1(60.89,31.69)
HWPG_2.5V: length 192.3
  TOP w0.14: D38.1 58.58,37 v1(58.72,37) ; PR367.1 156.81,28.23 157.28,28.7 v1(157.28,28.85) ; PR149.2 PR150.1 93.73,75.01 v1(93.73,74.7)
  IN3 w0.089: v1(93.73,74.7) 93.36,74.33 93.36,69.84 90.61,67.09 90.61,62.7 89.5,61.59 89.5,61.02 87.46,58.98 87.46,57.22 86.5,56.26 86.5,55.37 85.93,54.8 82.34,54.8 82.09,55.06 81.48,55.06 81.2,54.77 76.22,54.77 76,54.56 73.55,54.56 72.27,53.28 70,53.28 69.64,53.64 66.82,53.64 66.62,53.43 59.88,53.43 59.63,53.18 v1(59.53,53.18) ; v1(58.9,33.03) 58.9,33.03 59.16,32.77 60.54,32.77 60.61,32.85 61.91,32.85 62.23,33.17 64.03,33.17 64.27,33.41 67.12,33.41 67.51,33.01 69.65,33.01 71.14,31.52 71.14,30.86 74.19,27.82 76.4,27.82 77.43,26.79 77.43,25.72 77.8,25.35 79.61,25.35 80.1,25.84 81.66,25.84 82.09,26.27 v1(82.09,26.57)
  IN4 w0.086: v1(59.53,53.18) 59,53.18 58.51,52.7 58.51,51.1 59.96,49.65 59.96,48.72 59.51,48.27 58.94,48.27 58.3,47.63 58.3,46.8 59.04,46.07 59.91,46.07 60.13,45.85 60.13,44 59.4,43.27 59.4,40.58 59.28,40.45 59.28,37.56 v1(58.72,37) 58.25,36.53 58.25,34.79 58.68,34.36 58.68,33.29 58.9,33.07 v1(58.9,33.03) ; v1(157.28,28.85) 156.41,27.97 148.68,27.97 148.06,28.6 112.25,28.6 110.43,26.78 102.08,26.78 101.04,27.82 98.77,27.82 97.27,26.33 95.45,26.33 94.92,26.86 93.78,26.86 93.7,26.77 92.41,26.77 91.89,27.3 89.6,27.3 88.31,26 85.95,26 84.78,24.83 84.78,23.98 84.37,23.57 82.71,23.57 82.39,23.89 82.39,24.96 83.2,25.77 83.2,26.29 82.86,26.64 82.19,26.64 82.12,26.57 v1(82.09,26.57)
HWPG_VDDR: length 97
  TOP w0.14: PR373.1 153.6,27.92 153.56,27.96 PR366.2 152.92,28.21 152.47,28.67 152.47,30.4 151.94,30.93 v1(151.94,30.99)
  IN1 w0.086: v1(86.38,28.7) 86.18,28.5 85.09,28.5 83.64,29.95 82.52,29.95 82.17,30.3 77.95,30.3 76.41,28.76 76.24,28.59 72.16,28.59 71.85,28.9 70.68,28.9 68.6,26.81 68.6,25.92 68.07,25.39 67.23,25.39 v1(66.62,26)
  IN4 w0.086: v1(151.94,30.99) 151.19,30.24 149.52,30.24 148.97,30.8 111.34,30.8 111.31,30.77 102.77,30.77 102.56,30.98 101.77,30.98 101.34,30.55 101.34,29.64 100.77,29.07 97,29.07 96.93,29.14 95.94,29.14 95.56,29.52 89.57,29.52 89.1,29.05 87.82,29.05 87.46,28.7 v1(86.38,28.7)
  BOTTOM w0.14: D106.1 66.74,25.87 v1(66.62,26)
I2C0_SCL: length 156.6
  TOP w0.102: U14.BC22 213.91,25.03 213.91,23.69 214.02,23.58 214.02,22.47 v1(213.63,22.09)
  TOP w0.14: v1(91.97,14.27) 91.59,14.27 R585.1 ; v1(199.29,21.26) 199.29,21.14 198.9,20.74 198.02,20.74 R451.1
  IN4 w0.086: v1(101.78,30.36) 103.61,28.54 109.7,28.54 111.52,30.35 148.78,30.35 149.34,29.8 151.61,29.8 152.28,30.47 165.55,30.47 165.93,30.85 175.06,30.85 180.61,36.4 184.73,36.4 187.89,33.24 187.89,33.09 188.81,32.17 188.96,32.17 189.39,31.73 189.39,31.73 190.5,30.62 190.5,27.94 193.6,24.84 193.6,23.36 194.05,22.91 196.68,22.91 197.81,21.78 198.93,21.78 199.29,21.42 v1(199.29,21.26) 199.41,21.15 199.41,21.11 199.76,20.76 200.93,20.76 201.78,19.91 208.92,19.91 211.58,22.57 212.57,22.57 213.05,22.09 v1(213.63,22.09)
  BOTTOM w0.14: v1(91.97,14.27) 92.03,14.27 94.81,17.05 98.86,17.05 99.09,17.3 99.09,18.13 99.08,18.31 99.08,18.59 v1(99.89,19.4) 99.89,21.46 101.82,23.39 101.82,26.36 101.47,26.71 101.47,29.1 101.34,29.24 101.34,29.92 v1(101.78,30.36)
I2C0_SDA: length 154.9
  TOP w0.102: v1(213.63,21.48) 214.22,22.07 214.22,23.8 U14.BF23
  TOP w0.14: R600.1 91.84,13.47 v1(91.84,13.48) ; v1(198.65,21.23) 198.48,21.4 198.19,21.4 197.39,22.21 R438.1
  IN4 w0.086: v1(213.63,21.48) 213.03,21.48 212.38,22.13 211.76,22.13 209.1,19.47 201.6,19.47 200.74,20.32 199.58,20.32 198.67,21.23 v1(198.65,21.23) 198.63,21.25 197.72,21.25 196.5,22.47 193.87,22.47 193.16,23.18 193.16,24.65 190.06,27.75 190.06,30.44 189.34,31.17 188.77,31.73 188.63,31.73 187.45,32.91 187.45,33.06 184.55,35.96 180.79,35.96 175.24,30.41 172.15,30.41 171.77,30.03 152.46,30.03 151.79,29.36 149.15,29.36 148.6,29.91 111.71,29.91 109.89,28.09 103.18,28.09 v1(101.84,29.43)
  BOTTOM w0.14: v1(91.84,13.48) 91.94,13.48 95.01,16.55 99.08,16.55 99.59,17.06 v1(99.59,18.08) 100.39,18.88 100.39,21.25 102.32,23.18 102.32,26.57 101.97,26.92 101.97,29.31 v1(101.84,29.43)
I2C1_SCL: length 53.5
  TOP w0.102: U14.BE21 213.3,23.99 213.3,23.42 213,23.12 213,21.25 212.36,20.62 212.31,20.62 v1(212.26,20.57) 211.98,20.28 EC6.2
  IN1 w0.086: v1(212.26,20.57) 212.26,20.44 213.12,19.57 220.49,19.57 221.3,18.76 221.3,16.92 220.52,16.14 220.52,14.19 221.24,13.47 223.89,13.47 225.04,14.62 228.28,14.62 228.82,14.09 234.11,14.09 234.75,13.44 237.13,13.44 237.96,14.28 241.44,14.28 242.83,15.67 242.83,16.73 243.86,17.76 243.86,19.79 245.04,20.97 v1(245.1,20.97)
  BOTTOM w0.14: v1(212.26,20.57) 212.24,20.54 R1057.1 ; v1(245.1,20.97) 245.26,20.97 245.61,21.33 245.61,21.74 R996.1
I2C1_SDA: length 50.1
  TOP w0.102: U14.BF21 213.53,23.36 213.2,23.03 213.2,21.13 212.92,20.85 v1(212.92,20.54) 212.92,19.96 R483.1
  IN1 w0.086: v1(245.1,21.66) 243.42,19.97 243.42,17.94 242.39,16.91 242.39,15.85 241.82,15.28 238.34,15.28 236.94,13.88 234.93,13.88 234.29,14.53 229,14.53 228.46,15.07 224.86,15.07 223.71,13.92 221.41,13.92 220.96,14.37 220.96,15.96 221.74,16.74 221.74,18.95 220.67,20.02 213.31,20.02 212.92,20.4 v1(212.92,20.54)
  BOTTOM w0.14: R997.1 245.1,22.02 v1(245.1,21.66)
I2C_EN_DP: length 4
  TOP w0.14: v1(91.23,149.86) 92.52,148.56 R25.2 R26.2
  BOTTOM w0.14: v1(91.23,149.86) 91.23,150.68 U39.17
I2C_EN_EDP: length 6
  TOP w0.14: R111.2 174.94,86.07 v1(174.42,86.07) 174.42,87.11 174.67,87.37 174.67,87.93 R112.2 175.28,88.89 v1(175.73,89.34)
  BOTTOM w0.14: v1(175.73,89.34) 175.73,89.52 175.93,89.72 U41.17
I2C_EN_TBT: length 2.7
  TOP w0.14: U10.17 v1(240.38,46.41)
  BOTTOM w0.14: R815.2 240.8,45.76 R817.2 240.81,45.98 v1(240.38,46.41)
I2C_SEL_PIN: length 3.1
  BOTTOM w0.14: R658.2 53.29,158.2 52.6,158.89 52.37,158.89 52.02,159.25 U34.31
I2C_TP_SCL_R: length 9.9
  TOP w0.14: v1(87.9,15.59) 88,15.68 D74.1 88.18,16.12 88.87,16.12 R558.2 88.36,15.42 88.36,15.24 Q48.1 87.56,15.02 87.47,14.94 R570.1
  BOTTOM w0.14: v1(87.9,15.59) 87.39,16.09 86.03,16.09 85.4,16.73 85.4,17.17 84.65,17.93 CN19.9
I2C_TP_SDA_R: length 12.2
  TOP w0.14: v1(88.69,16.63) 88.79,16.53 90.68,16.53 D73.1 90.83,15.96 90.56,15.69 R568.1 90.56,14.69 89.89,14.02 Q48.4 88.88,13.4 R599.2
  BOTTOM w0.14: v1(88.69,16.63) 88.65,16.59 86.24,16.59 85.9,16.93 85.9,17.38 85.15,18.13 CN19.8
I2CB_SCL_G: length 30.7
  TOP w0.102: UG1.BG8 41.48,97.02 41.42,97.02 41.42,97.03 v2(41.41,97.03)
  IN2 w0.089: v2(41.41,97.03) 41.42,97.03 41.42,96.96 42,96.37 42,93.13 40.55,91.67 39.51,91.67 39.05,91.22 39.05,90.91 38.32,90.18 34.53,90.18 v1(34.25,90.47)
  BOTTOM w0.14: v1(34.25,90.47) 34.27,90.49 34.27,92.79 33.55,93.51 33.55,94.1 32.27,95.38 30.74,95.38 29.74,96.38 29.74,98.84 29.94,99.04 29.94,99.94 29.5,100.38 28.88,100.38 28.33,100.94 26.46,100.94 RG138.2
I2CB_SDA_G: length 30.1
  TOP w0.102: v2(41.55,97.73) 41.55,97.65 UG1.BF8
  IN2 w0.089: v1(33.69,90.1) 33.81,89.99 38.4,89.99 39.24,90.83 39.24,91.14 39.58,91.48 40.63,91.48 42.21,93.06 42.21,96.55 41.91,96.85 41.91,97.37 v2(41.55,97.73)
  BOTTOM w0.14: RG140.2 28.37,100.1 29.38,100.1 29.66,99.83 29.66,99.15 29.46,98.95 29.46,96.27 30.63,95.1 32.16,95.1 33.27,93.99 33.27,93.29 33.99,92.56 33.99,90.92 33.69,90.62 v1(33.69,90.1)
I2CC_SCL_GFX: length 29
  TOP w0.102: UG1.BG9 42.87,96.33 v2(42.87,96.3)
  TOP w0.14: QG10.4 25.8,86.65 26.16,87.02 v1(26.16,87.21) 26.16,87.5 RG40.2
  IN1 w0.086: 27.78,88.29 27.78,87.14 27.32,86.68 26.54,86.68 26.16,87.05 v1(26.16,87.21) ; 43.85,93.5 44.21,93.87 44.21,96.28 43.83,96.66 43.23,96.66 v2(42.87,96.3)
  IN1 w0.089: 43.85,93.5 41.86,91.52 39.62,91.52 39.35,91.25 39.35,90.89 38.78,90.33 37.24,90.33 36.28,89.36 35.12,89.36 34.46,88.69 28.18,88.69 27.78,88.29
I2CC_SDA_GFX: length 29.2
  TOP w0.102: UG1.BH9 42.59,95.95 v2(42.89,95.65)
  TOP w0.14: QG10.1 27.13,85.35 27.22,85.26 v1(27.98,85.26) 28.16,85.26 28.67,85.77 28.67,86.78 28.16,87.29 v1(27.25,87.29) 26.97,87.29 26.83,87.43 26.83,87.87 26.84,87.87 RG39.2
  IN1 w0.086: v2(42.89,95.65) 42.96,95.65 42.96,95.66 43.35,95.27 43.86,95.27 44.01,95.11 44.01,93.94 43.66,93.58 ; 26.83,87.62 26.83,87.4 26.94,87.29 v1(27.25,87.29)
  IN1 w0.089: 43.66,93.58 41.79,91.71 39.54,91.71 39.16,91.33 39.16,90.97 38.7,90.52 37.16,90.52 36.2,89.55 35.04,89.55 34.38,88.88 28.1,88.88 26.83,87.62
I2S2_RXD: length 14.5
  TOP w0.14: U14.AW18 211.72,26.91 v1(211.38,26.91)
  IN1 w0.086: v1(211.38,26.91) 211.38,24.75 211.94,24.19 211.94,22.76 208.3,19.12 208.3,15.7 v1(208.31,15.69)
  BOTTOM w0.14: R1117.2 208.31,15.23 v1(208.31,15.69)
I2S2_SCLK: length 15.9
  TOP w0.14: U14.AV18 211.78,27.82 v1(211.5,27.54)
  IN1 w0.102: v1(211.5,27.54) 211.21,27.54 210.92,27.25 210.92,26.47 211.18,26.21 211.18,24.67 211.74,24.11 211.74,22.84 208.1,19.2 208.1,16.13 v1(207.66,15.69)
  BOTTOM w0.14: R1118.2 207.64,15.67 v1(207.66,15.69)
ICMNT: length 61.6
  TOP w0.14: v1(86.59,21.52) 86.75,21.52 87.13,21.9 C422.2 86.11,21.99 85.95,21.82 U18.67
  TOP w0.178: PR254.1 98.49,52.18 v1(98.75,52.44) 99.08,52.44 99.08,52.41 PC187.2
  IN3 w0.089: v1(98.75,52.44) 97.58,51.27 97.58,51 97.34,50.77 95.38,50.77 95.07,50.45 94.12,50.45 93.83,50.15 93.63,50.15 92.62,49.14 92.62,49.08 88.65,45.11 88.65,43.21 87.9,42.46 v1(87.47,42.46)
  BOTTOM w0.14: v1(87.47,42.46) 87.47,42.28 87.88,41.87 87.88,41.23 89.81,39.3 89.81,39.08 91.1,37.8 91.41,37.8 93.01,36.21 93.01,33.9 93.89,33.02 95.14,33.02 95.58,32.58 95.58,31.97 94.23,30.62 92.06,30.62 90.89,29.45 90.89,27.82 91.46,27.25 91.46,26.08 90,24.62 90,24.39 89.6,23.99 89.6,23.28 89.27,22.95 88.18,22.95 86.75,21.52 v1(86.59,21.52) ; v1(98.75,52.44) 98.75,53.03 100.17,54.45 100.17,56.23 98.82,57.57 97.61,57.57 97.44,57.4 97.2,57.4 97.08,57.51 96.88,57.51 96.62,57.78 PR488.2
IFPAB_RSET: length 1.2
  TOP w0.102: UG1.BD23 52.35,98.71 v2(52.68,98.39)
  BOTTOM w0.14: RG152.2 52.75,98.31 v2(52.68,98.39)
IFPB_I2C_SCL: length 299.5
  TOP w0.14: v1(96.13,77.16) 96.23,77.16 97,77.92 97,78.36 97.8,79.16 98.67,79.16 98.94,79.43 100.44,79.43 101.71,78.16 103.53,78.16 104.88,76.81 107.34,76.81 107.84,76.31 107.84,74.76 106.72,73.64 v1(106.72,73.12) ; R425.2 255.3,25.22 255.83,25.75 256.07,25.75 v1(256.2,25.62) ; RG54.2 27.56,84.21 27,83.65 QG14.3 27.44,83.11 28.1,83.78 28.54,83.78 28.75,83.57 28.75,81.3 28.54,81.09 26.66,81.09 26.28,80.71 26.28,80.46 25.52,79.7 v1(25.52,79.45)
  IN1 w0.086: v1(179.8,60.19) 179.8,61.71 180.66,62.57 182.7,62.57 186.87,66.73 190.07,66.73 193.22,63.58 204.96,63.58 206.91,61.63 211.82,61.63 212.25,61.2 214.68,61.2 214.88,61 216.02,61 216.12,60.9 218.73,60.9 219.15,60.49 224.05,60.49 225.95,58.59 225.95,57.54 229.57,53.93 235.08,53.93 237.38,51.63 237.38,51.17 240.38,48.17 240.38,48.02 240.9,47.5 240.9,45.6 242.86,43.64 242.86,42.93 242.22,42.3 242.22,38.02 243.04,37.2 243.04,36.34 242.66,35.96 242.66,33.72 243.63,32.76 243.63,31.84 246.59,28.89 254.3,28.89 255.82,27.37 255.82,26 v1(256.2,25.62)
  IN2 w0.089: v1(25.52,79.45) 26.04,78.93 29.07,78.93 29.56,78.44 33.37,78.44 33.72,78.78 38.83,78.78 39.31,79.27 40.92,79.27 41.41,79.75 42.8,79.75 43.24,79.3 47.04,79.3 47.4,79.66 49.89,79.66 50.55,79 52.43,79 52.92,79.5 54.33,79.5 54.96,78.86 88.13,78.86 89.48,77.51 92.46,77.51 92.86,77.11 96.08,77.11 v1(96.13,77.16)
  IN4 w0.086: v1(179.8,60.19) 178.79,61.2 178.79,61.27 176.99,63.07 176.99,63.53 176.63,63.89 176.63,64.18 164.97,75.84 112.67,75.84 112.26,75.43 109.13,75.43 107.01,73.3 106.9,73.3 v1(106.72,73.12)
  BOTTOM w0.14: v1(256.2,25.62) 256.23,25.62 257.12,24.73 257.12,24.3 v1(257.75,23.66) 257.75,22.99 R1005.2 256.63,21.86 255.95,21.86 255.71,21.62 255.71,20.8 255.49,20.57 R1013.1
IFPB_I2C_SDA: length 299.5
  TOP w0.14: v1(96.76,77.03) 97.39,77.66 97.39,78.19 97.96,78.76 98.83,78.76 99.11,79.04 100.27,79.04 101.54,77.77 103.37,77.77 104.72,76.42 107.18,76.42 107.45,76.15 107.45,74.92 106.07,73.54 v1(106.07,72.94) ; v1(24.51,79.02) 23.74,79.8 23.21,79.8 22.31,80.7 22.31,81.41 22.61,81.71 RG66.2 24.12,81.81 QG14.6
  IN1 w0.086: v1(178.68,61.99) 178.71,61.97 179.47,61.97 180.41,62.91 182.56,62.91 186.73,67.07 190.21,67.07 193.36,63.92 205.1,63.92 207.05,61.97 211.41,61.97 212.09,62.65 213.24,62.65 214.25,61.64 214.73,61.64 215.02,61.34 216.16,61.34 216.26,61.24 218.88,61.24 219.29,60.83 224.19,60.83 226.29,58.73 226.29,57.68 229.71,54.27 235.22,54.27 236.9,52.59 237.61,52.59 238.33,51.87 238.33,51.5 241.24,48.59 241.24,45.74 243.2,43.78 243.2,42.79 242.56,42.16 242.56,38.16 243.38,37.34 243.38,36.2 243,35.82 243,33.87 243.97,32.9 243.97,31.98 246.73,29.23 254.45,29.23 256.16,27.51 256.16,26.45 256.66,25.95 256.66,25.47 v1(256.13,24.93)
  IN2 w0.089: v1(24.51,79.02) 24.94,78.59 28.93,78.59 29.42,78.1 33.51,78.1 33.86,78.44 38.98,78.44 39.46,78.92 41.07,78.92 41.55,79.4 42.66,79.4 43.1,78.96 47.18,78.96 47.54,79.32 49.75,79.32 50.41,78.66 52.57,78.66 53.07,79.15 54.19,79.15 54.82,78.52 87.99,78.52 89.34,77.17 92.32,77.17 92.78,76.71 96.44,76.71 v1(96.76,77.03)
  IN4 w0.086: v1(106.07,72.94) 106.07,73.16 106.67,73.75 106.98,73.75 108.99,75.77 112.12,75.77 112.53,76.18 165.12,76.18 176.97,64.32 176.97,64.03 177.33,63.67 177.33,63.34 v1(178.68,61.99)
  BOTTOM w0.14: R1046.1 251.96,20.15 252.22,20.42 252.22,21.18 253.07,22.03 253.07,22.44 253.66,23.03 254.88,23.03 R986.2 255.41,22.54 R1001.2 255.69,22.52 256.18,23 256.77,23 256.91,23.14 256.91,23.92 256.72,24.11 256.72,24.57 256.36,24.93 v1(256.13,24.93)
IFPC_RSET: length 1.2
  TOP w0.102: v2(49.93,99.07) UG1.BD20
  BOTTOM w0.14: RG144.2 49.87,99.02 v2(49.93,99.07)
IFPEF_RSET: length 1.2
  TOP w0.102: v2(47.86,99.1) 48.15,98.81 UG1.BD17
  BOTTOM w0.14: RG148.2 48.25,98.7 v2(47.86,99.1)
IFPF_AUX+: length 12.9
  TOP w0.102: UG1.BM8 42.1,92.9 42.1,92.15 41.96,92.02 41.43,92.02 40.48,91.07 40.48,90.88 40.22,90.62 v1(40.21,90.62) 40.5,90.32 40.5,90.1 40.31,89.92 39.57,89.92 39.4,89.75 39.28,89.75 39.27,89.76 39.25,89.76 39.24,89.75
  TOP w0.14: 39.24,89.75 37.8,88.31 37.8,88.13 CG68.1 37.59,87.69 37.59,86.9 CG78.1
  BOTTOM w0.14: RG169.2 41.7,92.44 41.7,92.18 41.51,91.99 41.14,91.99 40.4,91.25 40.4,90.82 v1(40.21,90.62)
IFPF_AUX-: length 12.9
  TOP w0.102: 39.47,89.52 39.66,89.71 40.4,89.71 40.71,90.02 40.71,90.26 v1(41.06,90.62) 40.85,90.83 40.85,91.15 41.51,91.81 42.04,91.81 42.3,92.07 42.3,92.9 UG1.BM9
  TOP w0.14: 39.47,89.52 38.12,88.18 38.12,87.93 CG68.2 37.91,87.45 37.91,86.82 38.06,86.66 CG79.1
  BOTTOM w0.14: v1(41.06,90.62) 40.89,90.8 40.89,91.29 41.28,91.68 41.64,91.68 42.02,92.05 42.02,92.22 42.02,92.22 42.02,92.44 RG168.2
IFPF_L0+: length 9.4
  TOP w0.102: UG1.BL14 46.11,93.85 46.22,93.75 46.22,93.57 46.1,93.45 45.92,93.45 45.64,93.17 45.64,91.32 44.9,90.58 44.9,88.8 44.96,88.74 44.96,88.71
  TOP w0.14: CG75.1 47,86.91 46.77,86.91 46.63,87.05 46.63,87.73 46.3,88.05 45.46,88.05 44.96,88.55 44.96,88.71
IFPF_L0-: length 9.4
  TOP w0.102: 44.64,88.71 44.64,88.74 44.7,88.8 44.7,90.67 45.43,91.41 45.43,93.26 45.74,93.56 45.74,93.98 46.05,94.28 UG1.BK14
  TOP w0.14: 44.64,88.71 44.64,88.42 45.33,87.74 46.17,87.74 46.31,87.59 46.31,87.15 CG76.1
IFPF_L1+: length 8.8
  TOP w0.105: UG1.BK12 44.83,94.12 44.98,93.96 44.98,93.6 45.18,93.4 45.18,91.55 43.94,90.3 43.94,88.75 43.97,88.71
  TOP w0.14: 43.97,88.71 43.97,88.18 44.69,87.45 44.69,87.28 44.93,87.05 CG74.1
IFPF_L1-: length 8.8
  TOP w0.105: UG1.BL12 44.58,93.92 44.4,93.92 44.3,93.82 44.3,93.56 44.4,93.46 44.83,93.46 44.97,93.32 44.97,91.63 43.73,90.39 43.73,88.79 43.65,88.71
  TOP w0.14: CG73.1 44.23,87.05 44.37,87.19 44.37,87.32 43.65,88.04 43.65,88.71
IFPF_L2+: length 7.2
  TOP w0.102: UG1.BM12 44.4,92.9 44.4,92.62 44.57,92.45 44.57,91.62 42.94,90 42.94,88.8 43,88.74 43,88.71
  TOP w0.14: 43,88.71 43,88.02 42.74,87.76 42.74,87.38 CG72.1
IFPF_L2-: length 7.2
  TOP w0.102: UG1.BM11 44.2,92.9 44.2,92.54 44.37,92.37 44.37,91.71 42.74,90.08 42.74,88.8 42.68,88.74 42.68,88.71
  TOP w0.14: CG71.1 42.42,87.41 42.42,87.89 42.68,88.15 42.68,88.71
IFPF_L3+: length 9.3
  TOP w0.102: 41.84,88.71 41.84,88.74 41.78,88.8 41.78,89.73 43.63,91.59 43.63,93.41 43.73,93.51 43.99,93.51 44.09,93.61 44.09,93.74 43.98,93.85 UG1.BL11
  TOP w0.14: 41.84,88.71 41.84,88.24 41.38,87.78 40.82,87.78 40.56,87.52 40.56,87.2 40.7,87.06 41.01,87.06 CG70.1
IFPF_L3-: length 9.3
  TOP w0.102: UG1.BK11 43.95,94.28 43.61,93.94 43.61,93.72 43.43,93.54 43.43,91.67 41.58,89.82 41.58,88.8 41.52,88.74 41.52,88.71
  TOP w0.14: 41.52,88.71 41.52,88.37 41.24,88.1 40.69,88.1 40.24,87.65 40.24,87.31 CG69.1
ILIM_4PH_A: length 2.8
  TOP w0.203: v1(172.01,166.7) 172.23,166.7 172.42,166.51 PU2.7
  BOTTOM w0.203: v1(172.01,166.7) 171.25,166.7 PR447.2
ILIM_HI1: length 1.3
  TOP w0.14: U8.16 19.08,47.35 19.32,47.11 R181.1
ILIM_HI2: length 1.5
  TOP w0.254: U11.16 17.84,40.91 17.99,40.75 R229.1
ILIM_HI3: length 2.3
  TOP w0.14: U26.16 279.1,21.17 v1(278.98,21.3)
  BOTTOM w0.14: R1029.1 278.67,20.98 v1(278.98,21.3)
ILIM_LO1: length 1.2
  TOP w0.14: R180.1 18.56,47.22 18.58,47.24 U8.15
ILIM_LO2: length 1.3
  TOP w0.254: U11.15 17.34,41.08 17.36,41.06 R228.1
ILIM_LO3: length 2
  TOP w0.14: v1(279.9,21.07) 279.6,20.77 U26.15
  BOTTOM w0.14: v1(279.9,21.07) 279.66,20.84 R1030.2
IMVP_PWRGD: length 305
  TOP w0.14: Q6.2 106.64,131.34 110.05,134.75 v1(112.26,134.75)
  IN2 w0.089: v1(112.26,134.75) 112.63,134.39 113.98,134.39 114.39,134.79 114.7,135.1 123.49,135.1 126.65,138.26 133.22,138.26 133.84,138.88 138.76,138.88 139.44,138.2 140.81,138.2 141.29,137.72 157.47,137.72 158.98,136.2 160.52,136.2 160.93,135.79 167.05,135.79 169.23,137.97 169.23,142.49 172.52,145.78 172.52,147.59 174.22,149.28 174.22,154 177.03,156.81 v1(179.52,156.81) 179.52,157.95 179.12,158.35 179.12,167.89 176.4,170.6 176.4,171.35 v1(176.7,171.64) ; v1(200.15,59.42) 202.4,57.17 202.79,57.17 203.65,56.3 203.65,55.34 205.86,53.13 217.52,53.13 221.14,49.51 223.37,49.51 225.35,47.53 230,47.53 233.44,44.09 233.88,44.09 234.18,44.39 235.22,44.39 236.34,43.27 236.34,41.48 236.89,40.93 236.89,39.76 235.53,38.4 235.53,36.49 233.11,34.08 233.11,28.79 231.46,27.14 231.46,22.85 v1(232.3,22.01)
  IN3 w0.089: v1(200.15,59.42) 199.78,59.05 197.66,59.05 195.56,61.15 191.54,61.15 189.32,63.36 189.32,64.48 180.79,73.02 180.79,78.23 184.24,81.68 184.24,86.61 181.23,89.62 181.23,102.5 180.3,103.43 180.3,105.88 180.71,106.3 180.71,111.77 181.45,112.5 181.45,124.25 180.46,125.24 180.46,126.2 180.23,126.43 180.23,132.38 176.63,135.98 174.85,135.98 173.76,137.07 173.76,145.28 176.25,147.78 176.25,150.83 179.37,153.95 179.37,156.66 v1(179.52,156.81)
  BOTTOM w0.14: U42.2 232.78,22.49 v1(232.3,22.01) 232.05,22.27 230.37,22.27 229.84,21.73 R1019.2 ; PR429.2 PR436.2 177.31,172.36 176.7,171.75 v1(176.7,171.64)
INT_DP_AUXN: length 15.8
  TOP w0.102: 38.58,90.01 38.6,90.03 38.6,90.11 39.24,90.74 39.24,91.22 39.76,91.74 40.77,91.74 41.54,92.51 41.54,93.38 41.68,93.52 41.68,93.75 41.78,93.85 UG1.BL8
  TOP w0.14: QG12.4 35.97,81.94 35.76,82.15 35.76,84.18 RG53.2 35.71,84.62 35.71,84.78 36.68,85.75 36.68,88.11 38.58,90.01
INT_DP_AUXN_Q: length 181.6
  TOP w0.14: QG12.3 35.06,81.94 35.46,81.54 35.46,81.28 35.66,81.08 36.75,81.08 36.89,81.22 37.19,81.22 37.52,81.54 37.52,81.7 37.8,81.98 39.96,81.98 41.93,83.95 47.47,83.95 48.06,84.54 49.8,84.54 50.32,85.07 50.82,85.07 v1(50.99,84.89)
  IN4 w0.086: v1(76.22,163.24) 76.42,163.04 77,163.04 77.49,162.55 79.67,162.55 80.11,162.99 82.45,162.99 84.34,161.09 84.97,161.09 85.56,160.5 96.02,160.5 97.86,158.66 97.86,154.26 100.44,151.67 100.44,148.59 100.76,148.28 101.69,148.28 102.55,147.42 104.08,147.42 108.39,143.12 108.39,137.19 107,135.8 107,127.48 107.44,127.04 107.44,107.56 107,107.13 107,97.68 105.64,96.32 105.64,93.85 103.76,91.97 103.76,90.96 102.04,89.24 88.19,89.24 82.02,83.06 60.62,83.06 59.75,83.93 53.59,83.93 52.23,85.28 51.39,85.28 v1(50.99,84.89)
  BOTTOM w0.14: C512.2 79.59,160.62 79.59,161.57 79.27,161.89 78.17,161.89 Q57.3 77.38,161.75 77.38,162.17 76.54,163.01 76.45,163.01 v1(76.22,163.24)
INT_DP_AUXP: length 15.7
  TOP w0.102: 38.36,90.23 38.37,90.25 38.46,90.25 39.03,90.83 39.03,91.31 39.67,91.95 40.68,91.95 41.33,92.6 41.33,93.46 41.48,93.61 41.48,93.93 41.85,94.31 UG1.BK8
  TOP w0.14: 38.36,90.23 36.37,88.24 36.37,85.89 35.39,84.91 35.39,84.64 35.12,84.37 RG52.2 34.95,84.3 35.45,83.8 35.45,83.37 35.32,83.24 QG12.1
INT_DP_AUXP_Q: length 180.5
  TOP w0.14: v1(50.99,85.79) 50.99,85.58 50.8,85.38 50.19,85.38 49.66,84.86 47.93,84.86 47.34,84.27 41.8,84.27 39.83,82.3 38.61,82.3 37.79,83.13 37.59,83.13 37.47,83.24 QG12.6
  IN4 w0.086: v1(50.99,85.79) 51.32,85.47 52.31,85.47 53.66,84.12 59.83,84.12 60.69,83.25 81.94,83.25 88.11,89.42 101.96,89.42 103.57,91.04 103.57,92.05 105.45,93.92 105.45,96.39 106.81,97.76 106.81,107.2 107.25,107.64 107.25,126.96 106.81,127.4 106.81,135.88 108.2,137.26 108.2,143.04 104.01,147.23 102.47,147.23 101.62,148.09 100.68,148.09 100.26,148.52 100.26,151.6 97.67,154.18 97.67,158.59 95.94,160.32 85.48,160.32 84.89,160.9 84.27,160.9 82.37,162.8 80.19,162.8 79.75,162.36 77.41,162.36 76.93,162.85 76.32,162.85 76.22,162.75 76.22,162.63 v1(76.27,162.58)
  BOTTOM w0.14: v1(76.27,162.58) 76.06,162.58 75.92,162.44 75.92,160.69 76.13,160.48 76.13,160.11 76.67,159.57 77.02,159.57 Q60.3 77.97,158.89 78.58,159.49 79.09,159.49 79.55,159.04 C521.2
INT_EDP_AUXN: length 177.8
  TOP w0.102: UG1.BF11 43.95,97.35 43.64,97.04 43.64,97.01 v2(43.64,97.01)
  IN4 w0.086: v2(43.64,97.01) 43.64,97.17 43.81,97.33 44.01,97.33 44.44,96.9 44.44,94.16 44.72,93.89 44.72,88.6 47.56,85.77 47.56,83.44 49.43,81.57 50.51,81.57 51.86,80.22 52.45,80.22 52.75,80.52 56.07,80.52 56.81,79.79 83.62,79.79 89.66,85.82 93.57,85.82 95.15,84.23 95.15,83.84 96.57,82.42 96.57,79.51 97.07,79.01 97.91,79.01 98.14,79.24 98.14,79.57 98.39,79.82 v1(98.5,79.82)
  BOTTOM w0.14: RG156.2 43.8,96.87 43.64,97.02 43.64,97.01 v2(43.64,97.01) ; C639.1 171.91,115.39 171.27,115.39 170.31,114.43 170.31,110.59 170.03,110.31 170.03,107.97 169.68,107.62 169.68,97.06 167.05,94.43 167.05,93.5 154.88,81.34 106.33,81.34 104.15,79.15 101.12,79.15 100.92,79.35 99,79.35 98.87,79.22 98.33,79.22 98.19,79.36 98.19,79.51 v1(98.5,79.82)
INT_EDP_AUXP: length 177.9
  TOP w0.102: v2(43.63,97.7) 43.63,97.73 43.95,98.05 UG1.BE11
  IN4 w0.086: v2(43.63,97.7) 43.81,97.52 44.09,97.52 44.63,96.97 44.63,94.24 44.91,93.96 44.91,88.68 47.75,85.84 47.75,83.52 49.51,81.76 50.59,81.76 51.94,80.41 52.37,80.41 52.67,80.71 56.15,80.71 56.89,79.97 83.54,79.97 89.58,86.01 93.64,86.01 95.34,84.31 95.34,83.92 96.76,82.5 96.76,79.59 97.15,79.2 97.83,79.2 97.95,79.32 97.95,79.52 v1(97.65,79.82)
  BOTTOM w0.14: v2(43.63,97.7) 43.63,97.73 43.94,98.04 RG149.2 ; C640.1 171.91,115.07 171.4,115.07 170.63,114.3 170.63,110.45 170.35,110.18 170.35,107.84 170,107.48 170,96.93 167.36,94.29 167.36,93.37 155.01,81.02 106.46,81.02 104.28,78.83 100.99,78.83 100.79,79.04 99.13,79.04 99,78.91 98.2,78.91 97.87,79.23 97.87,79.6 v1(97.65,79.82)
INT_EDP_TXN0: length 160.3
  TOP w0.102: v1(48.57,90.17) 48.57,89.81 48.68,89.71 49.05,89.71 49.4,90.06 49.4,91.65 48.54,92.5 48.54,93.21 48.44,93.31 48.25,93.31 48.15,93.21 UG1.BM17
  IN4 w0.086: v1(48.57,90.17) 48.9,89.84 49.35,89.84 50.44,88.75 50.44,84.79 50.82,84.41 52.44,84.41 53.4,83.46 59.56,83.46 60.42,82.59 82.28,82.59 88.45,88.76 95.34,88.76 100.73,83.38 100.73,81.91 101.45,81.19 101.45,80.74 102.97,79.22 104.84,79.22 105.41,78.64 105.41,76.13 106.05,75.49 106.17,75.49 106.34,75.66 v1(106.34,75.77)
  BOTTOM w0.14: v1(106.34,75.77) 106.62,75.49 107.26,75.49 107.46,75.69 107.46,76.8 107.84,77.18 161.16,77.18 161.3,77.32 161.3,77.87 161.69,78.26 162.21,78.26 162.87,77.6 163.07,77.6 166.05,80.57 173.22,80.57 179.18,86.53 179.18,87.99 C681.1
INT_EDP_TXN0_R: length 2.1
  BOTTOM w0.14: C681.2 179.19,88.88 179.19,89.28 178.77,89.69 178.77,89.95 178.73,89.99 U41.10
INT_EDP_TXN1: length 160.6
  TOP w0.102: v1(47.38,89.86) 47.38,89.63 47.51,89.5 47.6,89.5 47.85,89.75 47.85,92.49 47.64,92.7 47.64,93.53 47.84,93.73 47.84,94.24 UG1.BK17
  IN4 w0.086: v1(47.38,89.86) 47.71,89.52 47.87,89.52 48.1,89.29 48.1,88.34 49.73,86.72 49.73,84.57 50.56,83.73 52.19,83.73 53.13,82.8 59.29,82.8 60.15,81.94 82.66,81.94 88.83,88.1 95.08,88.1 100.07,83.11 100.07,81.64 100.79,80.92 100.79,80.47 102.7,78.56 103.73,78.56 104.44,77.85 104.44,76.35 103.7,75.61 103.7,74.95 103.87,74.79 103.92,74.79 v1(104.29,75.15)
  BOTTOM w0.14: v1(104.29,75.15) 104.29,75.04 104.43,74.9 104.73,74.9 104.89,75.06 104.89,75.42 105.26,75.78 105.26,76.07 107.35,78.16 160.23,78.16 161.29,79.23 163.33,79.23 165.65,81.54 172.82,81.54 177.66,86.38 177.66,87.99 C683.1
