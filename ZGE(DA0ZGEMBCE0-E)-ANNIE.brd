# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 180.02,134.56 180.02,133.78 179.54,133.29 175.49,133.29 175.19,133.59 175.19,133.59 175.14,133.64 174.75,133.64 174.71,133.59 174.47,133.59 174.34,133.72 174.34,134.45 175.03,135.14 179.44,135.14
GND on BOTTOM (solid shape): 8.96,82.64 8.96,81.99 8.87,81.9 8.87,81.41 8.73,81.27 8.2,81.27 8.05,81.12 7.38,81.12 7.3,81.21 7.3,81.66 7.51,81.88 7.87,81.88 8.21,82.22 8.21,82.91 8.35,83.05 8.55,83.05
GND on BOTTOM (solid shape): 14.85,164.35 15.29,164.35 15.32,164.33 15.37,164.3 15.49,164.18 15.49,162.91 15.26,162.68 13.13,162.68 12.72,163.08 12.46,163.08 12.26,163.29 12.26,164 13.41,165.14 14.06,165.14
GND on BOTTOM (solid shape): 40.58,61.18 40.58,60.25 40.33,60.01 38.96,60.01 38.93,59.99 38.93,59.48 38.75,59.3 35.17,59.3 34.99,59.48 33.62,59.48 33.52,59.58 33.52,61.05 33.83,61.36 40.39,61.36
GND on BOTTOM (solid shape): 50.34,61.26 50.34,60.11 50.23,60.01 48.61,60.01 48.58,59.99 48.58,59.48 48.41,59.3 44.82,59.3 44.65,59.48 43.27,59.48 43.17,59.58 43.17,61.05 43.48,61.36 50.23,61.36
GND on BOTTOM (solid shape): 286.29,52.59 286.4,52.58 286.47,52.58 286.49,52.58 286.51,52.57 287.95,51.12 287.95,49.98 287.62,49.65 283.89,49.65 283.64,49.9 283.64,51.98 284.24,52.59 286.17,52.59
GND on BOTTOM (solid shape): 88.94,61.26 88.94,60.11 88.84,60.01 87.22,60.01 87.19,59.99 87.19,59.48 87.01,59.3 83.43,59.3 83.31,59.18 81.96,59.18 81.78,59.35 81.78,61.05 82.09,61.36 88.84,61.36
GND on BOTTOM (solid shape): 117.6,152.87 117.6,152.77 117.54,152.72 117.54,151.73 117.67,151.6 118.54,151.6 119.03,151.11 119.03,147.16 119.53,146.66 119.53,145.08 119.13,144.68 116.57,144.68 116.07,145.18 116.07,152.82 116.45,153.2 117.27,153.2
GND on BOTTOM (solid shape): 26.43,61.36 30.79,61.36 30.94,61.2 30.94,60.26 30.7,60.01 29.3,60.01 29.28,59.99 29.28,59.48 29.1,59.3 24.5,59.3 24.19,59.61 24.19,60.38 24.16,60.4 24.16,60.66 24.03,60.79 24.03,61.26 24.78,62.01 25.78,62.01
GND on BOTTOM (solid shape): 43.64,40.84 43.64,40.65 43.49,40.5 39.14,40.5 39.06,40.42 39.06,40.42 38.96,40.34 38.89,40.25 38.88,40.24 38.54,39.9 37.35,39.9 37.16,40.09 37.16,40.76 37.32,40.92 43.56,40.92
GND on BOTTOM (solid shape): 45.36,159.61 45.36,157.95 45.23,157.83 44.47,157.83 43.68,157.04 43.68,156.51 43.53,156.35 43.22,156.35 43.1,156.48 43.1,156.81 42.84,157.06 42.84,157.9 43.22,158.28 43.22,158.96 43.69,159.42 43.69,159.96 43.79,160.06 44.91,160.06
GND on BOTTOM (solid shape): 69.64,61.26 69.64,60.11 69.54,60.01 67.91,60.01 67.89,59.99 67.89,59.48 67.71,59.3 64.13,59.3 64.12,59.31 63.98,59.16 62.68,59.16 62.48,59.36 62.48,61.05 62.78,61.36 69.54,61.36
GND on BOTTOM (solid shape): 79.29,61.26 79.29,60.11 79.19,60.01 77.56,60.01 77.54,59.99 77.54,59.48 77.36,59.3 73.78,59.3 73.78,59.3 73.59,59.12 72.33,59.12 72.13,59.33 72.13,61.05 72.43,61.36 79.19,61.36
GND on BOTTOM (solid shape): 81.4,51.91 83.84,51.91 83.97,52.04 84,52.06 84.04,52.04 84.58,51.5 84.58,50.03 84.4,49.85 79.22,49.85 79.01,50.05 79.01,51.1 79.29,51.38 79.29,51.75 79.65,52.11 81.2,52.11
GND on BOTTOM (solid shape): 95.55,130.41 97.52,130.41 97.92,130.01 97.92,129.72 97.67,129.47 97.67,128.86 97.52,128.7 97.33,128.7 97.2,128.84 97.2,129.11 96.64,129.67 95.57,129.67 95.14,129.24 94.3,129.24 94.18,129.36 94.18,130.59 94.3,130.71 95.25,130.71
GND on BOTTOM (solid shape): 97.71,32.1 97.71,31.13 97.5,30.93 97.5,30.92 96.77,30.92 96.7,30.85 96.7,30.07 96.54,29.91 96.44,29.91 96.01,29.48 96.01,29.05 95.95,29 95.6,29 95.42,29.18 95.42,30.15 96.24,30.96 96.75,31.48 96.75,32.12 97.68,32.12
GND on BOTTOM (solid shape): 103.09,47.82 103.09,46.09 102.66,45.66 101.62,45.66 101.09,46.19 99.74,46.19 99.59,46.35 99.59,47.13 99.61,47.16 100.55,47.16 100.96,46.75 101.87,46.75 102.1,46.98 102.1,47.77 102.36,48.02 102.89,48.02
GND on BOTTOM (solid shape): 54.62,100.16 54.62,99.3 54.01,98.69 54.01,97.62 53.87,97.48 53.25,97.48 53.1,97.64 53.1,97.86 53.09,97.93 53.05,97.99 53.05,99.65 53.09,99.69 53.54,99.69 53.74,99.89 53.74,100.1 53.83,100.19 54.6,100.19
GND on BOTTOM (solid shape): 54.88,156.13 54.88,156.1 54.96,156.02 54.96,155.48 55.19,155.24 55.19,154.68 55.15,154.64 54.87,154.64 54.79,154.72 54.79,155.1 54.36,155.53 53.47,155.53 53.28,155.72 53.25,155.72 53.24,155.73 52.79,155.73 52.72,155.79 52.72,156.28 52.85,156.4 54.6,156.4
GND on BOTTOM (solid shape): 221.86,39.92 221.86,39.01 221.74,38.88 220.67,38.88 220.41,38.62 220.41,38.17 220.36,38.11 219.61,38.11 219.48,37.98 219.2,37.98 219.09,38.09 219.09,38.51 218.93,38.67 216.22,38.67 216.1,38.79 216.1,39.92 216.45,40.28 221.51,40.28
GND on BOTTOM (solid shape): 234.51,11.57 234.51,11.24 234.82,10.94 235.6,10.94 235.98,10.56 235.98,9.72 236.14,9.57 237.46,9.57 238.09,10.2 239.59,10.2 240.12,9.67 240.12,9.11 240.05,9.03 234.56,9.03 234.26,9.34 234.26,10.84 233.77,11.32 233.77,11.7 233.85,11.78 234.31,11.78
GND on BOTTOM (solid shape): 109.48,135.52 109.48,134.69 109.35,134.57 108.72,134.57 108.04,133.89 108.04,133.35 107.52,132.83 106.86,132.83 105.79,131.76 103.01,131.76 102.74,132.03 102.74,134.71 103.02,134.99 105.29,134.99 105.78,134.5 107.7,134.5 108.36,135.17 108.36,135.41 108.58,135.63 109.37,135.63
GND on BOTTOM (solid shape): 31.28,17 31.52,17 31.52,18.15 31.78,18.15 31.78,17 32.02,17 32.02,18.15 32.27,18.15 32.28,18.14 32.28,17 32.34,17 32.34,16.04 32.08,15.77 31.01,15.77 30.82,15.96 30.82,16.48 30.95,16.61 30.95,17 31.02,17 31.02,18.11 31.06,18.15 31.28,18.15
GND on BOTTOM (solid shape): 41.91,18.71 41.91,18.09 42.23,17.77 48.21,17.77 48.35,17.91 48.35,18.57 48.43,18.65 49.73,18.65 50.28,18.1 50.28,17.26 50.16,17.15 49.87,17.15 49.84,17.17 41.29,17.17 40.98,17.48 40.98,18.44 41.31,18.76 41.86,18.76
GND on BOTTOM (solid shape): 60.89,158.99 61.21,158.99 61.61,158.59 61.61,156.76 61.62,156.74 61.75,156.61 61.75,156.36 61.61,156.22 61.41,156.22 61.25,156.38 61.25,156.58 61.09,156.74 60.89,156.74 60.87,156.76 59.72,156.76 59.6,156.88 59.6,158.46 59.38,158.68 59.38,159.43 59.56,159.62 60.27,159.62
GND on BOTTOM (solid shape): 220.47,32.27 220.47,30.74 220.39,30.67 219.83,30.67 219.61,30.44 219.25,30.44 219.09,30.6 219.09,31.24 219.02,31.3 216.74,31.3 216.25,30.82 215.65,30.82 215.51,30.95 215.51,32.02 215.33,32.2 215.3,32.2 215.29,32.21 215.11,32.21 215.04,32.28 215.04,32.67 215.18,32.81 219.93,32.81
GND on BOTTOM (solid shape): 60.01,29.51 60.01,28.77 59.89,28.64 59.89,28.06 59.76,27.93 59.76,23.89 59.84,23.82 59.84,22.77 59.38,22.32 55.9,22.32 55.85,22.37 55.85,22.9 56.36,23.41 56.36,29.12 56.51,29.28 59.1,29.28 59.45,29.63 59.89,29.63
GND on BOTTOM (solid shape): 63.47,144.67 63.51,144.61 63.57,144.57 63.67,144.47 63.9,144.47 63.99,144.37 63.99,144.08 64,144.03 64,143.58 63.9,143.48 63.62,143.48 63.54,143.4 62.81,143.4 62.32,143.88 62.32,144.8 62.43,144.9 63.24,144.9
GND on BOTTOM (solid shape): 105.84,68.62 105.84,64.2 105.71,64.08 104.13,64.08 103.81,63.76 103.81,63.75 103.79,63.72 103.77,63.72 103.58,63.64 103.46,63.47 103.46,63.46 103.43,63.44 102.69,63.44 102.23,63.9 102.23,68.7 102.25,68.72 105.73,68.72
GND on BOTTOM (solid shape): 105.5,141.93 105.94,141.93 106.01,141.85 106.01,140.2 105.89,140.07 104.25,140.07 104.09,140.24 104.09,140.55 104.04,140.59 103.94,141.13 103.71,141.61 103.7,141.62 103.7,142.05 103.9,142.26 105.17,142.26
GND on BOTTOM (solid shape): 178.54,110.42 178.54,109.57 178.55,109.56 178.55,108.58 178.18,108.21 176.7,108.21 176.45,107.96 176.45,107.17 175.88,106.59 174.85,106.59 174.68,106.43 174.68,105.62 174.66,105.59 174.12,105.59 174.1,105.62 174.1,106.42 174.73,107.05 175.03,107.05 175.32,107.34 175.32,110.36 175.52,110.56 178.4,110.56
GND on BOTTOM (solid shape): 215.42,37.06 215.43,37.06 215.49,36.95 215.59,36.87 215.59,36.87 215.69,36.77 218.26,36.77 218.41,36.62 218.41,36.29 217.87,35.75 217.87,35.42 217.77,35.32 216.15,35.32 216.02,35.45 216.02,35.98 215.79,36.21 214.98,36.21 214.85,36.34 214.85,37.05 214.93,37.13 215.36,37.13
GND on BOTTOM (solid shape): 230.17,19.03 230.17,18.09 230.13,18.02 230.11,17.94 230.11,17.66 230.12,17.6 230.14,17.54 230.15,17.53 230.14,17.49 229.86,17.21 229.57,17.21 229.18,17.61 228.45,17.61 228.29,17.77 228.29,19.17 228.42,19.3 228.89,19.3 228.9,19.31 229.89,19.31
GND on BOTTOM (solid shape): 238.4,26.92 238.4,26.61 238.47,26.53 239.77,26.53 239.95,26.71 242.33,26.71 242.56,26.94 243.15,26.94 243.2,26.89 243.2,25.47 243.12,25.39 242.61,25.39 242.26,25.75 238.6,25.75 238.32,25.47 238.04,25.47 237.89,25.62 237.89,26.84 238.02,26.97 238.35,26.97
GND on BOTTOM (solid shape): 245.13,50.84 245.13,49.7 244.62,49.19 244.62,46.32 242.84,44.54 240.76,44.54 240.56,44.75 240.56,45.2 240.66,45.3 241.12,45.3 241.37,45.56 241.37,47.36 240.96,47.77 240.66,47.77 240.56,47.87 240.56,48.3 241.32,49.06 241.32,49.93 241.55,50.16 244.21,50.16 244.47,50.41 244.47,50.92 244.57,51.02 244.95,51.02
GND on BOTTOM (solid shape): 59.44,117.9 59.44,117.54 59.28,117.38 59.28,117.09 59.36,117.01 59.74,117.01 59.8,116.95 59.8,116.06 59.89,115.98 59.89,115.31 59.83,115.26 58.76,115.26 58.73,115.29 58.73,116.97 58.58,117.12 58.22,117.12 58.11,117.23 58.11,117.42 58.26,117.58 58.26,117.84 58.33,117.91 59.42,117.91
GND on BOTTOM (solid shape): 46.55,22.81 46.55,22.06 46.7,21.91 47.88,21.91 47.9,21.89 47.9,21.63 47.88,21.61 46.63,21.61 46.55,21.54 46.55,20.71 46.5,20.66 44.43,20.66 44.35,20.74 44.35,21.53 44.27,21.61 43.09,21.61 43.06,21.63 43.06,21.89 43.08,21.91 44.17,21.91 44.35,22.09 44.35,22.81 44.42,22.88 46.48,22.88
GND on BOTTOM (solid shape): 172.24,114.06 172.24,112.49 172.24,111.66 172.69,111.22 172.69,109.69 172.48,109.49 172.48,107.04 172.26,106.81 172.26,105.12 172.45,104.93 172.45,104.56 172.42,104.54 171.32,104.54 170.94,104.92 170.94,109.22 170.95,109.22 170.95,109.78 171.21,110.04 171.21,111.06 171.21,114.06 171.32,114.18 172.13,114.18
GND on BOTTOM (solid shape): 246.82,38.76 246.84,38.76 247.74,37.86 248.06,37.86 248.1,37.81 249.08,37.81 249.46,37.43 250.39,37.43 250.77,37.81 251.86,37.81 251.96,37.71 251.96,34.38 251.86,34.28 246.42,34.28 246.37,34.33 246.37,37.24 246.43,37.24 246.43,37.87 246.7,38.14 246.7,38.27 246.72,38.29 246.72,38.71 246.76,38.76
GND on BOTTOM (solid shape): 47.32,107.9 47.32,106.7 47.22,106.6 47.22,104.84 47.53,104.53 47.53,104.14 47.5,104.11 46.41,104.11 46.37,104.15 46.37,104.31 46.41,104.35 46.62,104.36 46.73,104.47 46.73,104.89 46.6,105.02 46.35,105.02 46.29,105.08 46.29,106.58 46.18,106.69 46.18,106.89 46.58,107.29 46.58,107.89 46.62,107.93 47.29,107.93
GND on BOTTOM (solid shape): 86.11,156.26 86.11,156.23 86.11,156.21 86.07,156.11 86.06,156 86.09,155.83 86.17,155.67 86.17,154.64 85.76,154.23 85.74,154.23 85.66,154.21 85.6,154.18 85.05,154.18 84.93,154.3 84.93,154.51 85.4,154.99 85.4,156.02 85.7,156.33 86.04,156.33
GND on BOTTOM (solid shape): 32.78,88.15 32.82,88.14 32.84,88.1 32.84,87.65 32.23,87.04 32.23,84.38 32.21,84.36 32.2,84.35 32.13,84.3 32.08,84.23 32.08,84.22 32.05,84.2 31.2,84.2 31.09,84.09 28.97,84.09 28.67,84.4 28.67,88.1 28.68,88.14 28.72,88.15
GND on BOTTOM (solid shape): 55.08,113.24 55.08,112.96 54.83,112.72 54.82,112.71 54.41,112.7 54.34,112.63 54.34,111.88 54.32,111.85 54.29,111.83 53.17,111.83 53.14,111.85 53.12,111.88 53.12,113.32 53.22,113.42 54.9,113.42
GND on BOTTOM (solid shape): 56.63,116.42 56.63,116.04 56.61,115.99 56.45,115.83 56.45,115.7 56.39,115.64 56.39,114.94 56.23,114.78 56.14,114.77 56.1,114.77 55.93,114.77 55.81,114.64 55.81,113.92 55.79,113.89 55.35,113.89 55.32,113.92 55.32,116.36 55.51,116.54 56.51,116.54
GND on BOTTOM (solid shape): 16.3,45.25 16.3,44.9 16.12,44.72 15.74,44.72 14.65,43.63 14.48,43.63 14.4,43.65 14.33,43.66 14.28,43.66 14.26,43.66 14.12,43.81 14.12,44.87 14.41,45.17 14.64,45.17 14.78,45.18 14.82,45.22 14.84,45.22 14.94,45.32 16.24,45.32
GND on BOTTOM (solid shape): 25.91,173.77 25.91,169.82 25.65,169.56 25.29,169.56 25.09,169.36 25.09,169 24.73,168.65 24.73,167.48 25.83,166.39 26.71,166.39 28.14,164.96 28.14,163 27.46,162.32 20.84,162.32 20.28,162.88 20.28,164.3 20.49,164.51 22.04,164.51 22.45,164.91 22.45,171.77 22.89,172.22 24.28,172.22 24.55,172.49 24.55,173.66 24.85,173.96 25.72,173.96
GND on BOTTOM (solid shape): 136.24,66.51 134.51,64.79 116.6,64.79 116.58,64.81 115.66,64.81 115.25,65.22 115.26,65.31 115.14,65.59 114.86,65.7 114.77,65.69 114.18,66.29 110.97,66.29 110.71,66.54 110.71,66.67 136.24,66.67
GND on BOTTOM (solid shape): 291.64,39.18 291.64,38.29 291.43,38.09 288.64,38.09 288.56,38.13 288.54,38.21 288.55,38.25 288.55,38.29 288.5,38.48 288.38,38.62 288.33,38.7 288.36,38.78 288.97,39.39 291.43,39.39
GND on BOTTOM (solid shape): 42.96,35.81 45.15,35.81 45.36,35.6 45.36,34.45 45.34,34.41 45.33,34.36 45.33,33.98 45.34,33.93 45.36,33.89 45.36,33.87 45.51,33.72 46.02,33.72 46.27,33.47 46.27,32.95 46.13,32.81 44.65,32.81 44.49,32.96 44.49,33.08 44.42,33.16 42.87,33.16 42.82,33.21 42.82,35.27 42.71,35.38 42.14,35.38 41.94,35.57 41.94,36.03 42.01,36.1 42.67,36.1
GND on BOTTOM (solid shape): 52.06,16.56 52.06,15.05 52.67,14.44 52.67,14.32 52.66,14.26 52.66,14.22 52.66,14.17 52.67,14.12 52.67,14.1 52.66,14.07 52.62,14.04 50.54,14.04 50.51,14.05 50.5,14.07 50.23,14.64 49.91,15.18 49.9,15.2 49.9,16.6 50.08,16.78 51.84,16.78
GND on BOTTOM (solid shape): 128.36,128.87 128.36,126.99 128.21,126.84 128.21,125.65 128.82,125.04 128.82,124.78 128.67,124.63 128.34,124.63 128.21,124.5 128.21,121.81 128.63,121.4 128.63,113.79 128.56,113.72 127.91,113.72 127.73,113.9 127.73,115.28 127.43,115.58 127.43,120.25 127.82,120.64 127.82,121.33 127.43,121.72 127.43,126.53 127.07,126.89 127.07,127.78 126.99,127.86 126.99,128.89 127.22,129.12 128.11,129.12
GND on BOTTOM (solid shape): 270.83,57.34 270.83,56.12 270.78,56.07 270.27,56.07 270.24,56.04 270.24,56.04 270.07,55.87 267.87,55.87 267.86,55.87 267.82,55.87 267.64,56.04 267.64,56.08 267.63,56.09 267.63,56.4 267.84,56.61 268.9,56.61 269.11,56.81 269.11,56.89 269.12,56.9 269.18,57.02 269.2,57.14 269.19,57.21 269.17,57.28 269.16,57.31 269.32,57.48 270.7,57.48
GND on BOTTOM (solid shape): 17.58,100.06 17.58,99.62 17.72,99.48 18.51,99.48 18.74,99.25 18.74,97.43 18.64,97.32 17.98,97.32 17.54,97.76 16.96,97.76 16.78,97.93 16.78,97.95 16.83,98.08 16.84,98.21 16.84,98.7 16.83,98.71 16.83,99.6 16.92,99.81 16.93,100.03 16.93,100.06 16.94,100.08 17.07,100.2 17.43,100.2
GND on BOTTOM (solid shape): 27.43,108.22 27.43,107.59 27.32,107.48 27.04,107.48 26.82,107.26 26.82,106.54 26.75,106.42 26.73,106.29 26.73,106.22 26.72,106.2 26.49,105.96 25.57,105.96 25.49,106.04 25.36,106.04 25.24,106.16 23.18,106.16 23.03,106.32 22.37,106.32 22.29,106.39 22.29,106.65 22.52,106.87 24.61,106.87 24.83,107.1 24.83,108.55 24.96,108.68 26.97,108.68
GND on BOTTOM (solid shape): 135.42,128.75 135.42,127.33 135.24,127.15 135.24,125.08 135.24,125.06 135.23,125.04 135.14,124.95 134.74,124.95 134.46,124.67 134.46,124.25 134.28,124.07 134.04,124.07 133.82,124.29 133.82,124.57 133.87,124.7 133.88,124.84 133.87,124.85 133.88,124.88 134.1,125.1 134.47,125.1 134.6,125.23 134.7,125.23 134.7,126.66 134.77,126.72 134.77,128.62 134.97,128.82 135.35,128.82
GND on BOTTOM (solid shape): 26.14,18.62 26.14,18.25 26.2,18.2 26.2,17.57 26.22,17.45 26.26,17.34 26.26,16.76 25.67,16.17 24.4,16.17 24.29,16.23 24.16,16.25 24.09,16.24 24.03,16.23 23.99,16.21 23.93,16.28 23.93,17.41 23.42,17.92 21.69,17.92 21.58,18.03 21.58,18.51 21.74,18.66 22.45,18.66 22.7,18.91 22.7,18.94 22.95,19.19 25.57,19.19
GND on BOTTOM (solid shape): 55.34,108.77 55.34,108.53 55.02,108.21 55.02,107.44 54.85,107.28 54.54,107.28 54.35,107.08 53.74,107.08 53.6,106.94 53.6,106.25 53.56,106.21 53.19,106.21 53.14,106.26 53.14,106.54 53.17,106.57 53.17,107.66 53.41,107.91 53.48,107.91 54.31,107.91 54.55,108.16 54.55,108.4 54.64,108.48 54.68,108.51 54.7,108.55 54.95,108.8 55.31,108.8
GND on BOTTOM (solid shape): 65.67,116.66 65.67,116.58 65.64,116.51 65.58,116.48 65.54,116.47 65.5,116.46 65.39,116.46 65.3,116.37 65.3,116.11 65.18,115.99 65.17,115.99 65.11,115.96 65.09,115.91 65.08,115.89 64.96,115.77 64.96,115.53 64.9,115.47 64.25,115.47 64.19,115.53 64.19,115.92 64.26,115.99 64.38,115.99 64.53,116.15 64.53,116.64 64.58,116.69 65.64,116.69
GND on BOTTOM (solid shape): 48.8,105.97 48.8,105.21 49.03,104.98 49.27,104.98 49.43,104.82 49.43,104.66 49.29,104.51 49.02,104.51 48.86,104.36 48.86,103.85 49.15,103.56 49.29,103.56 49.41,103.45 49.41,103.22 49.3,103.11 49.3,102.74 49.26,102.71 48.89,102.71 48.86,102.74 48.86,103.46 48.71,103.6 48.25,103.6 47.99,103.35 47.99,103.17 47.88,103.05 47.88,102.77 47.81,102.7 47.48,102.7 47.43,102.75 47.43,103.23 47.96,103.76 47.96,104.91 47.6,105.28 47.6,105.92 47.68,106 48.76,106
GND on BOTTOM (solid shape): 43.5,109.62 43.5,109.28 43.27,109.05 43.27,108.68 43.61,108.34 43.61,105.88 43.67,105.83 43.67,105.43 43.64,105.4 42.98,105.4 42.91,105.33 42.67,105.33 42.57,105.43 42.57,105.65 42.7,105.78 43.09,105.78 43.29,105.97 43.29,107.01 43.19,107.1 42.22,107.1 41.9,107.42 41.9,107.66 42.1,107.86 42.4,107.86 42.55,108.01 42.55,109.14 42.93,109.51 43,109.56 43.05,109.62 43.07,109.64 43.09,109.64 43.47,109.64
GND on BOTTOM (solid shape): 277.77,36.57 277.77,35.93 278.25,35.45 278.25,33.09 277.98,32.82 277.68,32.82 277.49,32.63 277.49,31.84 277.26,31.61 273.73,31.61 273.6,31.74 273.6,33.8 273.72,34.08 273.6,34.36 273.6,35.07 273.68,35.18 273.72,35.32 273.72,35.34 273.88,35.5 275.3,35.5 275.99,36.19 275.99,36.59 276.14,36.74 277.59,36.74
GND on BOTTOM (solid shape): 56.64,121.25 56.64,120.91 56.74,120.81 56.74,120.35 56.81,120.28 56.93,120.28 56.96,120.27 57.27,119.97 57.27,119.79 57.37,119.68 57.37,119.46 57.35,119.43 56.98,119.43 56.94,119.47 56.94,119.71 56.55,120.1 56.55,120.27 56.36,120.47 55.97,120.47 55.79,120.29 55.79,119.62 55.65,119.48 55.19,119.48 55.16,119.51 55.16,120.14 55.08,120.22 55.08,120.23 55.02,120.32 54.93,120.38 54.92,120.38 54.86,120.44 54.86,121.11 55.07,121.32 56.57,121.32
GND on BOTTOM (solid shape): 87.54,107.34 87.55,107.32 87.55,107.28 87.65,107.03 87.9,106.93 87.95,106.94 88,106.95 88.08,106.95 88.28,106.75 88.28,106.44 88.21,106.37 87.67,106.37 87.45,106.14 87.45,105.45 87.22,105.22 86.53,105.22 86.45,105.3 86.45,106.11 86.56,106.21 86.79,106.21 86.99,106.42 86.99,107.1 86.91,107.18 86.91,107.48 86.99,107.56 87.32,107.56
GND on BOTTOM (solid shape): 169.47,90.55 169.47,90.27 169.47,90.21 169.5,90.16 169.5,90.14 169.5,89.68 169.48,89.62 169.47,89.57 169.47,89.27 169.48,89.22 169.5,89.15 169.5,88.61 169.5,88.56 169.5,88.26 169.55,88.11 169.69,88.02 169.71,88.02 169.86,87.87 169.86,87.32 169.91,87.27 169.91,86.96 169.75,86.81 168.94,86.81 168.6,87.14 168.6,90.54 168.79,90.72 169.29,90.72
GND on BOTTOM (solid shape): 178.56,58.4 178.72,58.35 178.88,58.33 179.02,58.34 179.15,58.38 179.25,58.37 179.29,58.29 179.29,56.58 179.14,56.43 178.83,56.43 178.73,56.53 178.82,56.73 178.86,56.95 178.63,57.49 178.09,57.72 177.97,57.72 177.97,58.11 178.27,58.41 178.55,58.41
GND on BOTTOM (solid shape): 95.7,64.41 95.7,63.54 95.52,63.36 95.52,62.65 95.62,62.55 95.7,62.55 95.79,62.48 95.9,62.45 96.18,62.45 96.3,62.48 96.39,62.57 96.41,62.6 97.02,62.6 97.2,62.42 97.2,62.12 96.97,61.89 96.21,61.89 96.14,61.96 96.01,62.04 95.86,62.07 95.26,62.07 94.81,62.53 94.79,62.53 94.79,62.63 94.79,62.68 94.79,64.13 94.86,64.21 94.9,64.27 94.92,64.35 94.92,64.45 95.01,64.53 95.57,64.53
GND on BOTTOM (solid shape): 19.25,161.48 19.29,161.47 19.3,161.43 19.3,160.1 19.5,160.1 19.5,161.43 19.51,161.47 19.55,161.48 20.19,161.48 20.41,161.26 20.41,159.81 20.27,159.67 20.27,159.08 19.07,157.88 19.07,156.23 18.89,156.05 18.33,156.05 17.11,157.27 13.1,157.27 12.95,157.42 10.94,157.42 10.79,157.27 6.85,157.27 6.72,157.39 6.72,159.63 6.74,159.67 6.78,159.68 16.99,159.68 17.65,159.02 18.38,159.02 18.71,159.35 18.71,159.68 18.92,159.88 18.92,160.05 18.93,160.09 18.97,160.1 19,160.1 19,161.41 19.07,161.48
GND on BOTTOM (solid shape): 112.08,39.15 112.13,39.06 112.13,38.62 112.02,38.51 112.02,38.28 112,38.26 111.97,38.24 111.95,38.21 111.94,38.18 111.8,38.18 111.8,36.42 111.94,36.42 111.99,36.34 111.99,36.27 111.36,36.27 111.36,36.34 111.41,36.42 111.55,36.42 111.55,38.18 111.41,38.18 111.4,38.21 111.38,38.24 111.35,38.26 111.33,38.28 111.33,38.76 111.71,39.14 111.78,39.12 111.83,39.12 111.91,39.13 111.98,39.15
GND on BOTTOM (solid shape): 269.28,29.25 269.28,28.18 269.2,28.06 269.17,27.91 269.19,27.77 269.26,27.66 269.27,27.64 269.27,27.6 268.96,27.3 268.7,27.3 268.6,27.4 268.6,27.65 268.59,27.66 268.6,27.74 268.48,28.02 268.2,28.14 268.04,28.1 267.89,27.99 267.87,27.98 267.68,27.98 267.42,28.25 267.42,29.26 267.58,29.43 269.11,29.43
GND on BOTTOM (solid shape): 51.51,114.07 51.54,114.06 51.59,114 51.64,113.99 52.01,113.99 52.03,113.99 52.05,113.98 52.71,113.31 52.71,112.71 52.68,112.68 52.63,112.67 52.58,112.65 52.36,112.65 52.24,112.54 52.24,111.94 52.09,111.79 51.73,111.79 51.69,111.83 51.69,112.25 51.74,112.3 51.74,112.6 51.69,112.66 51.46,112.66 51.43,112.68 51.42,112.71 51.42,113.5 51.24,113.68 51.18,113.68 51.1,113.76 51.09,113.78 51.09,113.8 51.09,113.84 51.12,113.89 51.12,113.92 51.12,114.03 51.15,114.07
GND on BOTTOM (solid shape): 111.33,39.69 111.45,39.69 111.49,39.58 111.47,39.53 111.47,39.47 111.47,39.43 111.49,39.35 111.02,38.89 111.02,38.28 111,38.26 110.97,38.24 110.95,38.21 110.94,38.18 110.8,38.18 110.8,36.42 110.94,36.42 110.99,36.34 110.99,36.27 110.36,36.27 110.36,36.34 110.41,36.42 110.55,36.42 110.55,38.18 110.41,38.18 110.4,38.21 110.38,38.24 110.35,38.26 110.33,38.28 110.33,38.87 110.57,39.11 111.13,39.55
GND on BOTTOM (solid shape): 20.72,103.39 20.72,102.73 21.01,102.44 22.45,102.44 22.52,102.37 22.52,102.37 22.6,102.25 22.71,102.17 22.75,102.16 22.88,102.14 23.01,102.16 23.02,102.16 23.14,102.16 23.18,102.15 23.2,102.11 23.2,101.86 23.14,101.81 23.12,101.8 23.06,101.8 22.98,101.8 22.9,101.77 22.79,101.77 22.61,101.6 21.51,101.6 21.33,101.42 21.28,101.39 20.39,101.39 19.86,101.92 19.45,101.92 19.32,102.05 19.32,102.78 19.96,103.42 20.69,103.42
GND on BOTTOM (solid shape): 62.5,27.4 62.5,26.13 62.66,25.97 62.66,25.96 62.73,25.84 62.84,25.78 62.85,25.78 62.88,25.75 63.85,25.75 64.08,25.52 64.08,24.04 63.93,23.89 63.59,23.89 63.5,23.99 63.48,24.01 63.48,24.04 63.49,24.08 63.49,24.38 63.48,24.45 63.45,24.51 63.44,24.52 63.44,24.63 63.21,24.86 62.81,24.86 62.61,25.06 62.6,25.41 62.54,25.51 62.43,25.57 62.42,25.58 62.27,25.72 62.05,25.72 61.89,25.87 61.89,27.4 61.97,27.47 62.43,27.47
GND on BOTTOM (solid shape): 108.28,39.91 108.32,39.84 108.37,39.79 108.4,39.71 108.36,39.63 108.26,39.51 108.22,39.35 108.22,39.3 108.24,39.23 107.92,38.91 107.92,38.37 108.01,38.28 107.97,38.25 107.94,38.18 107.8,38.18 107.8,36.42 107.94,36.42 107.99,36.34 107.99,36.27 107.36,36.27 107.36,36.34 107.41,36.42 107.55,36.42 107.55,38.18 107.41,38.18 107.4,38.21 107.38,38.24 107.35,38.26 107.33,38.28 107.33,39.09 108.14,39.91
GND on BOTTOM (solid shape): 113.51,39.86 113.54,39.81 113.57,39.78 113.59,39.7 113.56,39.63 113.48,39.52 113.45,39.38 113.45,39.33 113.47,39.26 113.22,39 113.22,38.62 113.02,38.42 113.02,38.28 113,38.26 112.97,38.24 112.95,38.21 112.94,38.18 112.8,38.18 112.8,36.42 112.94,36.42 112.99,36.34 112.99,36.27 112.36,36.27 112.36,36.34 112.41,36.42 112.55,36.42 112.55,38.18 112.41,38.18 112.4,38.21 112.38,38.24 112.35,38.26 112.33,38.28 112.33,38.39 112.44,38.5 112.44,39.33 112.96,39.86
GND on BOTTOM (solid shape): 152.41,39.04 152.47,38.95 152.47,38.6 152.45,38.58 152.45,38.18 152.3,38.18 152.3,36.42 152.44,36.42 152.46,36.38 152.46,36.28 152.37,36.23 151.98,36.23 151.89,36.28 151.89,36.38 151.91,36.42 152.05,36.42 152.05,38.18 151.91,38.18 151.9,38.21 151.88,38.24 151.85,38.26 151.83,38.28 151.83,38.37 151.72,38.49 151.72,38.92 151.83,39.04 151.87,39.01 151.97,38.96 152.08,38.95 152.19,38.97 152.3,39.03
GND on BOTTOM (solid shape): 188.8,35.64 190.35,35.64 190.35,35.65 191.1,35.65 191.38,35.37 191.38,34.61 191.81,34.18 191.81,32.83 191.69,32.71 189.02,32.71 188.8,32.92 188.8,33.11 188.82,33.15 188.85,33.17 188.89,33.22 188.92,33.26 188.94,33.31 188.96,33.37 188.96,33.42 188.96,33.48 188.96,33.53 188.94,33.59 188.92,33.64 188.89,33.69 188.85,33.73 188.81,33.77 188.76,33.8 188.71,33.82 188.66,33.84 188.6,33.85 188.55,33.85 188.51,33.84 188.49,33.85 188.41,33.93 186.86,33.93 186.66,34.13 186.66,34.64 190.35,34.64 190.35,34.86 188.8,34.86 188.8,34.64 186.66,34.64 186.66,35.22 186.86,35.42 187.2,35.42 187.67,34.96 188.25,34.96 188.43,35.14 190.35,35.14 190.35,35.36 188.8,35.36 188.8,35.14 188.43,35.14 188.64,35.35 188.64,35.54 188.76,35.65 188.8,35.65
GND on BOTTOM (solid shape): 130.07,129.81 130.07,129.63 130.22,129.48 130.99,129.48 131.11,129.35 131.11,128.15 131.25,128.02 131.58,128.02 131.73,128.17 131.73,128.3 131.73,128.3 131.73,129.46 131.75,129.49 131.78,129.51 131.93,129.51 132.03,129.49 132.28,129.51 132.63,129.16 132.63,128.68 132.44,128.5 132.44,127.33 132.24,127.13 132.24,120.05 132.26,120.03 132.26,115.53 131.98,115.25 131.98,113.59 132.31,113.26 132.31,112.86 132.25,112.8 132.09,112.8 131.6,113.28 130.9,113.28 130.68,113.06 130.07,113.06 129.96,113.17 129.96,113.32 130.01,113.38 130.01,113.48 130.31,113.77 130.31,114.09 130.02,114.38 130.02,126.29 130,126.31 130,127.33 129.79,127.54 129.79,129.79 129.86,129.85 130.03,129.85
GND on BOTTOM (solid shape): 242.16,20.33 242.21,20.27 242.35,20.08 242.58,20 242.64,20.01 242.7,20.02 243.06,20.02 243.1,19.98 243.1,19.47 242.97,19.35 242.56,19.35 242.41,19.5 241.88,19.5 241.7,19.32 241.34,19.32 241.22,19.45 241.22,19.83 241.26,19.92 241.36,19.93 241.44,19.9 241.79,19.99 241.95,20.31 242.05,20.34 242.09,20.34
GND on BOTTOM (solid shape): 54.3,105.96 54.3,105.28 54.09,105.08 53.97,105.08 53.79,104.89 53.79,104.48 54.3,103.97 54.3,102.75 54.26,102.71 53.9,102.71 53.86,102.76 53.86,103.53 53.79,103.6 53.29,103.6 53.26,103.62 53.24,103.66 53.26,103.7 53.28,103.71 53.31,103.71 53.35,103.7 53.38,103.7 53.69,104 53.38,104.31 53.33,104.3 53.26,104.28 53.23,104.29 53.04,104.48 52.64,104.48 52.53,104.59 52.53,105.18 52.41,105.3 52.41,105.95 52.46,106 52.85,106 52.92,105.92 52.92,105.25 53.18,104.99 53.6,104.99 53.85,105.23 53.85,105.97 53.88,106 54.26,106
GND on BOTTOM (solid shape): 106.5,31.41 106.53,31.41 106.54,31.4 106.64,31.37 106.74,31.36 106.84,31.37 106.94,31.41 108.3,31.41 108.38,31.33 108.38,31.33 109.51,30.2 109.51,27.1 107.4,25 104.54,25 103.29,23.75 103.28,23.76 103.2,23.76 103.15,23.81 103,23.96 102.8,24.02 102.76,24.03 102.74,24.07 102.74,26.75 102.39,27.1 102.39,29.49 102.13,29.75 102.13,29.77 102.13,30.11 102.19,30.23 102.21,30.36 102.19,30.5 102.13,30.61 102.13,31.61 102.43,31.92 105.99,31.92
GND on BOTTOM (solid shape): 55.89,106.73 55.89,106.72 56.17,106.45 56.49,106.67 56.51,106.7 56.54,106.71 56.62,106.71 56.68,106.77 56.68,106.89 56.84,107.05 56.98,107.05 57.12,106.91 57.12,106.64 57.33,106.43 58.05,106.43 58.14,106.33 58.4,106.33 58.55,106.18 58.55,104.76 58.73,104.58 59.17,104.58 59.19,104.56 59.19,103.9 59.07,103.78 57.33,103.78 57.21,103.65 55.83,103.65 55.68,103.5 55.68,103.17 55.59,103.07 55.35,103.07 55.24,103.18 55.24,103.45 55.45,103.66 55.59,103.66 55.78,103.86 55.78,104.18 55.56,104.4 54.81,104.4 54.6,104.61 54.6,104.83 54.76,104.99 57.75,104.99 57.95,105.19 57.95,105.58 57.82,105.71 55.78,105.71 55.24,106.26 55.24,106.67 55.24,106.67 55.24,106.89 55.4,107.05 55.57,107.05
GND on BOTTOM (solid shape): 100.11,50.98 100.11,48.9 99.84,48.63 99.18,48.63 99,48.81 98.49,48.81 98.27,48.58 98.27,46.6 99.05,45.81 99.05,44.24 98.8,43.98 98.6,43.98 98.42,44.16 98.42,44.59 98.41,44.59 98.38,44.61 98.36,44.64 98.07,45.73 97.54,46.74 97.53,46.75 97.53,47.43 97.56,47.52 97.57,47.6 97.56,47.68 97.53,47.77 97.53,48.02 97.59,48.13 97.61,48.25 97.61,48.3 97.6,48.35 97.6,48.38 97.67,48.44 97.67,48.85 97.99,49.17 97.99,49.62 98.52,50.16 98.75,50.16 99.02,50.42 99.02,50.65 99.05,50.69 99.05,51.16 99.27,51.38 99.71,51.38
GND on BOTTOM (solid shape): 20.48,71.26 20.48,63.4 21.35,62.53 21.35,60.54 21.18,60.37 15.64,60.37 15.02,60.99 15.02,61.44 15,61.45 15,61.51 14.76,61.75 14.76,61.95 14.39,62.32 14.03,62.32 13.99,62.37 13.99,63.67 14,63.68 14.02,63.74 14.03,63.81 14.03,64.11 14.03,64.14 14.02,64.17 14.05,64.27 14.14,64.3 14.18,64.29 14.22,64.29 14.5,64.41 14.61,64.68 14.56,64.88 14.43,65.02 14.43,65.18 13.86,65.74 13.86,65.83 13.73,65.95 13.73,69 13.99,69.26 15.64,69.26 15.89,69 15.89,68.34 18.03,66.21 18.94,66.21 19.29,66.56 19.29,71.45 19.51,71.67 20.07,71.67
GND on BOTTOM (solid shape): 38.58,107 38.58,106.67 38.69,106.55 38.73,106.51 38.77,106.48 38.93,106.32 40.56,106.32 41.17,105.71 42.19,105.71 42.25,105.7 42.3,105.69 42.32,105.69 42.34,105.68 42.39,105.63 42.39,105.1 42.35,105.02 42.28,105 42.26,105 41.96,105 41.81,104.94 41.76,104.8 41.76,104.52 41.81,104.37 41.96,104.31 42.26,104.31 42.32,104.32 42.38,104.35 42.39,104.36 42.48,104.36 42.67,104.18 45.18,104.18 45.23,104.13 45.23,103.04 45.13,102.94 44.72,102.94 44.47,103.19 42.72,103.19 42.16,103.75 41.47,103.75 40.96,104.26 37.15,104.26 37,104.41 37,106.16 38.02,107.18 38.4,107.18
GND on BOTTOM (solid shape): 108.82,39.78 108.91,39.8 108.98,39.73 109.02,39.65 109.08,39.58 109.08,38.91 108.95,38.77 108.95,38.18 108.8,38.18 108.8,36.42 108.94,36.42 108.99,36.34 108.99,36.27 108.36,36.27 108.36,36.34 108.41,36.42 108.55,36.42 108.55,38.18 108.41,38.18 108.4,38.21 108.38,38.24 108.35,38.26 108.33,38.28 108.33,38.39 108.23,38.49 108.23,38.78 108.45,39.01 108.53,38.99 108.58,38.99 108.83,39.1 108.93,39.35 108.9,39.49 108.81,39.62 108.77,39.7 108.81,39.77
GND on BOTTOM (solid shape): 287.44,46.61 287.45,46.58 287.43,46.52 287.43,46.47 287.55,46.19 287.83,46.08 287.87,46.08 287.93,46.09 287.96,46.09 288.46,45.58 288.46,45.2 288.41,45.15 288.14,45.15 288.12,45.15 288.11,45.16 287.98,45.29 287.93,45.33 287.88,45.37 287.86,45.39 287.86,45.41 287.86,45.44 287.82,45.53 287.73,45.57 287.4,45.57 287.31,45.53 287.27,45.44 287.27,45.41 287.27,45.39 287.25,45.37 287.2,45.33 287.16,45.29 287.06,45.19 287.04,45.18 287.02,45.18 283.76,45.18 283.64,45.19 283.53,45.21 283.23,45.51 283.23,46.35 283.41,46.52 286.86,46.52 287.04,46.7 287.34,46.7
GND on BOTTOM (solid shape): 152.41,40.32 152.47,40.23 152.47,39.66 152.41,39.57 152.3,39.58 152.19,39.64 152.08,39.66 151.85,39.58 151.73,39.38 151.72,39.36 151.41,39.05 151.41,38.36 151.5,38.27 151.44,38.18 151.3,38.18 151.3,36.42 151.44,36.42 151.46,36.38 151.46,36.28 151.37,36.23 150.98,36.23 150.89,36.28 150.89,36.38 150.91,36.42 151.05,36.42 151.05,38.18 150.91,38.18 150.9,38.21 150.88,38.24 150.85,38.26 150.83,38.28 150.83,39.11 151.98,40.26 152.05,40.24 152.1,40.24 152.21,40.26 152.31,40.31
GND on BOTTOM (solid shape): 148.22,41.04 148.31,40.98 148.3,40.88 148.24,40.77 148.22,40.66 148.33,40.41 148.58,40.3 148.72,40.33 148.84,40.42 148.95,40.44 149.02,40.35 149.02,39.89 148.32,39.2 148.32,38.67 148.52,38.48 148.52,38.28 148.5,38.26 148.47,38.24 148.45,38.21 148.44,38.18 148.3,38.18 148.3,36.42 148.44,36.42 148.46,36.38 148.46,36.28 148.37,36.23 147.98,36.23 147.89,36.28 147.89,36.38 147.91,36.42 148.05,36.42 148.05,38.18 147.91,38.18 147.9,38.21 147.88,38.24 147.85,38.26 147.83,38.28 147.83,38.33 147.69,38.46 147.69,38.82 147.77,38.9 147.77,40.9 147.91,41.04
GND on BOTTOM (solid shape): 157.6,40.32 157.65,40.23 157.65,39.69 157.6,39.6 157.49,39.61 157.39,39.66 157.28,39.68 157.03,39.57 156.93,39.32 156.93,39.28 156.95,39.2 156.52,38.78 156.52,38.28 156.5,38.26 156.47,38.24 156.45,38.21 156.44,38.18 156.3,38.18 156.3,36.42 156.44,36.42 156.46,36.38 156.46,36.28 156.37,36.23 155.98,36.23 155.89,36.28 155.89,36.38 155.91,36.42 156.05,36.42 156.05,38.18 155.91,38.18 155.9,38.21 155.88,38.24 155.85,38.26 155.83,38.28 155.83,38.65 156.23,39.05 156.28,39.19 157.02,40.13 157.15,40.26 157.23,40.24 157.27,40.24 157.39,40.26 157.49,40.31
GND on BOTTOM (solid shape): 77.74,169.27 77.59,169.16 77.47,169.03 77.34,167.97 78.25,167.39 82.07,167.39 82.26,167.2 82.26,166.5 82.14,166.38 80.87,166.38 79.49,164.99 79.09,164.99 79,164.9 76.49,164.9 73.49,167.9 71.23,167.9 71.12,168.01 70.94,168.01 70.88,168.07 70.37,168.12 69.89,168.32 69.5,168.32 69.36,168.45 69.36,169.15 69.55,169.33 70.24,169.33 70.52,169.14 70.86,169.08 71.52,169.6 71.31,170.4 71.31,178.29 77.74,178.29
GND on BOTTOM (solid shape): 134.71,112.63 134.71,112.55 135.94,112.55 136.02,112.47 136.03,112.45 136.03,112.4 136.03,112.37 136.03,111.97 135.98,111.92 135.9,111.89 135.82,111.93 135.27,112.03 135.19,111.47 135.21,111.4 135.18,111.33 135.1,111.25 135.01,111.22 134.94,111.27 134.68,111.44 134.38,111.38 134.27,111.37 134.22,111.46 134.22,111.51 134.08,111.64 134.07,111.66 134.07,111.68 134.04,111.88 133.9,112.05 133.9,112.07 133.9,112.82 133.98,112.9 134.45,112.9
GND on BOTTOM (solid shape): outline of 92 points within 282.47,35.91 285.69,39.49
GND on BOTTOM (solid shape): outline of 103 points within 93.06,66.84 96.36,71.06
GND on BOTTOM (solid shape): 208.81,26.98 208.95,26.98 210.06,26.98 210.1,26.98 210.41,26.98 211.13,26.27 211.13,25.37 210.31,24.55 209.72,24.55 209.57,24.71 209.57,24.93 209.8,25.16 209.92,25.16 209.94,25.16 210.07,25.07 210.21,25.04 210.57,25.39 210.21,25.75 210.15,25.75 210.11,25.8 210.18,25.91 210.2,25.99 210.2,26.29 210.14,26.44 210,26.5 209.72,26.5 209.58,26.44 209.52,26.29 209.52,26.09 209.25,25.82 209.25,25.78 209.24,25.77 209.24,25.29 209.04,25.09 208.78,25.09 208.71,25.16 208.71,25.59 208.61,25.69 208.61,26.01 208.65,26.1 208.67,26.21 208.65,26.3 208.61,26.39 208.61,26.41 208.61,26.45 208.6,26.47 208.3,26.77 208.3,27.06 208.38,27.14 208.65,27.14
GND on BOTTOM (solid shape): 174.44,169.56 174.8,169.21 178.58,169.21 178.73,169.36 179.44,169.36 179.83,168.98 179.83,168.45 179.8,168.44 179.72,168.39 179.69,168.3 179.69,167.92 179.71,167.87 179.74,167.82 179.76,167.76 179.74,167.69 179.71,167.65 179.69,167.59 179.69,167.21 179.71,167.15 179.75,167.1 179.77,167.04 179.76,166.98 179.73,166.93 179.72,166.88 179.72,166.5 179.73,166.45 179.76,166.4 179.79,166.34 179.76,166.27 179.73,166.23 179.72,166.17 179.72,165.79 179.73,165.73 179.76,165.69 179.79,165.62 179.76,165.56 179.73,165.51 179.72,165.46 179.72,165.08 179.73,165.02 179.76,164.98 179.79,164.91 179.76,164.85 179.73,164.8 179.72,164.75 179.72,164.35 179.44,164.35 179.29,164.51 179.29,164.57 179.25,164.67 179.15,164.71 178.77,164.71 178.71,164.7 178.66,164.66 178.64,164.63 176.27,164.63 176.27,164.61 176.05,164.39 175.44,164.39 175.15,164.68 174.64,164.68 174.57,164.76 174.57,168.19 174.01,168.75 174.01,169.56 174.06,169.61 174.44,169.61
GND on BOTTOM (solid shape): 263.54,35.04 263.54,34 263.7,33.85 264.69,33.85 265.07,33.47 265.07,33.39 265.06,33.37 265.05,33.35 264.93,33.06 265.05,32.77 265.06,32.76 265.07,32.74 265.07,32.33 265.24,32.16 265.27,32.11 265.32,32.07 265.45,31.94 265.45,31.72 265.19,31.46 265.19,31.14 265.18,31.11 265.14,31.09 264.75,30.7 265.14,30.31 265.3,30.34 265.45,30.44 265.47,30.45 265.52,30.45 265.54,30.44 265.55,30.43 265.69,30.32 265.86,30.28 266.1,30.37 266.24,30.59 266.24,30.61 266.44,30.8 266.87,30.8 266.97,30.7 266.97,30.14 266.67,29.84 264.97,29.84 264.38,30.42 264.38,30.98 264.2,31.16 260.75,31.16 259.84,32.07 259.84,34.19 259.86,34.25 259.87,34.31 259.87,34.61 259.86,34.67 259.84,34.73 259.84,35.14 260.01,35.32 263.26,35.32
GND on BOTTOM (solid shape): outline of 103 points within 57.59,119.42 64.7,123.78
GND on BOTTOM (solid shape): outline of 123 points within 50.4,116.42 55.05,119.28
GND on BOTTOM (solid shape): outline of 93 points within 136.06,112.13 142.24,130.83
GND on BOTTOM (solid shape): 278.2,8.52 280.69,7.49 281.72,5 281.72,2.45 282.15,2.03 284.67,2.03 285.07,2.43 285.07,4.06 285.8,4.78 287.82,4.78 288.18,4.46 288.65,4.34 297.69,4.34 297.69,2 297.26,0.94 296.2,0.51 281.2,0.51 280.85,0.65 280.71,1 280.71,5 279.97,6.77 278.2,7.51 195.12,7.51 195.75,7.87 196.06,8.52
GND on BOTTOM (solid shape): 189.71,54.75 189.79,54.74 189.87,54.75 189.95,54.78 190.27,54.78 190.36,54.75 190.44,54.74 190.52,54.75 190.61,54.78 191.71,54.78 191.81,54.68 191.81,53.56 191.75,53.49 191.73,53.49 191.65,53.49 191.56,53.48 191.47,53.46 191.43,53.46 191.38,53.4 191.33,53.36 191.23,53.25 191.23,53.21 191.21,53.12 191.2,53.05 191.21,52.97 191.23,52.89 191.23,52.44 191.21,52.36 191.2,52.29 191.2,52.24 191.21,52.19 191.2,52.16 191.1,52.06 190.65,52.06 190.44,52.26 190.42,52.26 190.37,52.28 190.35,52.31 190.35,52.36 189.84,52.36 189.71,52.43 189.57,52.45 188.76,52.45 188.67,52.5 188.67,52.61 188.7,52.68 188.73,52.69 188.75,52.69 188.78,52.68 188.8,52.64 190.35,52.64 190.35,52.86 188.75,52.86 188.72,52.89 188.72,52.91 188.68,53.03 188.6,53.14 188.57,53.21 188.6,53.28 188.71,53.43 188.74,53.61 188.62,53.91 188.3,54.07 188.28,54.11 188.28,54.55 188.51,54.78 189.63,54.78
GND on BOTTOM (solid shape): outline of 135 points within 14.68,47.16 19.11,54.46
GND on BOTTOM (solid shape): outline of 110 points within 188.16,27.2 191.74,31.06
GND on BOTTOM (solid shape): outline of 132 points within 74.97,25.67 82.29,27.75
GND on BOTTOM (solid shape): outline of 152 points within 122.64,113.72 125.45,123.78
GND on BOTTOM (solid shape): outline of 217 points within 62.04,96.51 73.51,108.79
GND on BOTTOM (solid shape): outline of 149 points within 44.32,100.75 63.67,103.51
GND on BOTTOM (solid shape): outline of 81 points within 105.28,36.47 109.31,44.57
GND on BOTTOM (solid shape): outline of 96 points within 197.19,14.4 299.18,67.79
GND on BOTTOM (solid shape): outline of 156 points within 257.09,52.93 264.85,57.6
GND on BOTTOM (solid shape): outline of 317 points within 28.62,154.32 41.5,159.99
GND on BOTTOM (solid shape): outline of 549 points within 93.45,65.66 194.45,178.29
GND on BOTTOM (solid shape): outline of 512 points within 44.04,108.72 54.33,121.91
GND on BOTTOM (solid shape): outline of 294 points within 0.51,7.51 194.19,178.29
GND on BOTTOM (solid shape): outline of 697 points within 143.11,112.44 156.52,132.1
GND on BOTTOM (solid shape): outline of 842 points within 149.22,18.55 173.35,27.53
GND on BOTTOM (solid shape): outline of 710 points within 258.36,45.28 272.48,54.65
GND on BOTTOM (solid shape): outline of 1551 points within 103.04,9.08 176.85,29.33
GND on BOTTOM (solid shape): outline of 5745 points within 104.91,31.18 129.38,60.96
GND on BOTTOM (solid shape): outline of 7018 points within 136.5,26.83 174.67,69.06
GND on SGND (solid shape): outline of 13735 points within 0.51,0.51 299.18,178.29
GND on IN1 (solid shape): 258.16,40.63 258.16,39.08 256.89,37.81 256.13,37.81 255.59,38.35 255.59,40.66 255.72,40.78 258.01,40.78
GND on IN1 (solid shape): 260.11,28.11 260.11,27.25 259.51,26.64 257.19,26.64 256.56,27.27 256.56,28.31 256.81,28.57 259.66,28.57
GND on IN1 (solid shape): 32.84,88.18 32.84,87.65 32.23,87.04 32.23,84.3 32.21,84.27 32.18,84.25 28.81,84.25 28.67,84.4 28.67,88.18 28.85,88.36 32.66,88.36
GND on IN1 (solid shape): 233.62,27.35 234.41,27.35 234.42,27.34 234.42,24.33 234.63,24.13 234.64,24.09 234.63,24.06 234.4,23.84 234.04,23.84 234.03,23.83 232.25,23.83 232.13,23.96 232.13,27.26 232.25,27.39 233.59,27.39
GND on IN1 (solid shape): 201.54,46.7 201.54,44.36 201.5,44.32 198.72,44.32 198.69,44.33 198.67,44.37 198.67,45.95 198.55,46.07 198.21,46.07 198.06,46.22 198.06,46.98 198.08,47.01 198.11,47.03 201.22,47.03
GND on IN1 (solid shape): 249.15,50.26 249.15,47.95 249.1,47.87 248.99,47.87 248.91,47.9 248.82,47.91 248.47,47.55 248.82,47.2 248.91,47.21 248.99,47.24 249.1,47.24 249.15,47.15 249.15,45.01 248.9,44.77 247.59,44.77 247.3,45.05 247.3,50.31 247.59,50.6 248.81,50.6
GND on IN1 (solid shape): 77.74,169.27 77.59,169.16 77.47,169.03 77.34,167.97 78.25,167.39 82.33,167.39 82.39,167.33 82.39,166.38 82.22,166.21 81.5,166.21 80.45,165.15 79.28,165.15 78.89,164.77 78.59,164.77 77.57,165.78 77.49,165.78 77.18,166.09 73.41,166.09 72.83,166.68 72.61,167.21 72.07,167.43 71.98,167.42 71.89,167.41 71.22,167.41 70.98,167.56 70.69,167.62 70.46,167.58 70.25,167.48 70.21,167.51 70.16,167.54 69.66,168.04 69.66,168.15 69.5,168.32 69.5,169.06 69.77,169.33 70.24,169.33 70.58,169.11 70.99,169.11 71.54,169.66 71.31,170.4 71.31,178.29 77.74,178.29
GND on IN1 (solid shape): 278.2,8.52 280.1,7.97 281.4,6.49 283.3,4.58 286.78,4.58 286.75,4.65 286.73,4.72 287.87,4.72 287.93,4.65 288,4.58 288.3,4.4 288.65,4.34 297.69,4.34 297.69,2 297.26,0.94 296.2,0.51 281.2,0.51 280.85,0.65 280.71,1 280.71,5 279.97,6.77 278.2,7.51 195.12,7.51 195.75,7.87 196.06,8.52
GND on IN1 (solid shape): 269.26,41.49 269.26,40.43 268.65,39.82 265.86,39.82 265.37,40.3 265.37,41.54 265.39,41.57 265.67,41.69 265.77,41.94 265.66,42.19 265.41,42.3 265.27,42.27 265.12,42.18 265.08,42.19 265.04,42.23 264.92,42.23 264.91,42.24 264.74,42.28 264.57,42.24 264.56,42.23 264.26,42.23 264.24,42.24 264.11,42.32 263.98,42.34 263.84,42.32 263.71,42.24 263.69,42.23 263.49,42.23 263.48,42.24 263.35,42.32 263.21,42.34 263.08,42.32 262.95,42.24 262.93,42.23 262.67,42.23 262.65,42.24 262.63,42.25 262.37,42.36 262.12,42.25 262.1,42.24 262.08,42.23 262.01,42.23 261.98,42.25 261.86,42.33 261.72,42.36 261.58,42.33 261.45,42.24 261.43,42.23 261.1,42.23 261.08,42.23 261.07,42.25 260.82,42.34 260.58,42.25 260.56,42.23 260.54,42.23 260.45,42.23 260.44,42.23 260.42,42.25 260.18,42.34 259.93,42.25 259.91,42.23 259.9,42.23 259.58,42.23 259.38,42.43 259.38,43.96 259.66,44.24 266.52,44.24
GND on IN1 (solid shape): 271.6,48.76 271.6,47.01 271.23,46.64 271.22,46.64 270.82,46.33 270.46,45.96 270.44,45.94 270.42,45.94 269.55,45.94 269.45,46.01 269.48,46.12 269.58,46.24 269.61,46.4 269.57,46.56 269.45,46.69 269.41,46.78 269.45,46.86 269.57,46.99 269.61,47.16 269.26,47.52 268.9,47.16 268.95,46.99 269.06,46.86 269.11,46.78 269.06,46.69 268.94,46.56 268.9,46.4 268.94,46.24 269.03,46.12 269.06,46.01 268.97,45.94 268.52,45.94 268.14,46.32 268.14,48.61 268.37,48.84 268.95,48.84 269.04,48.78 269.04,48.68 268.99,48.58 268.98,48.48 269.33,48.12 269.69,48.48 269.66,48.62 269.58,48.74 269.55,48.81 269.57,48.88 269.64,48.99 269.67,49.12 269.7,49.18 269.77,49.21 271.14,49.21
GND on IN1 (solid shape): outline of 184 points within 227.44,47.9 232.35,50.29
GND on IN1 (solid shape): outline of 154 points within 0.51,7.51 194.57,178.29
GND on IN1 (solid shape): outline of 526 points within 285.39,37.15 294.28,47.49
GND on IN1 (solid shape): outline of 938 points within 92.32,14.11 299.18,178.29
GND on SGND1 (solid shape): outline of 10551 points within 0.51,0.51 299.18,178.29
GND on IN2 (solid shape): 258.16,40.63 258.16,39.08 256.89,37.81 256.13,37.81 255.59,38.35 255.59,40.66 255.72,40.78 258.01,40.78
GND on IN2 (solid shape): 260.11,28.11 260.11,27.25 259.51,26.64 257.19,26.64 256.56,27.27 256.56,28.31 256.81,28.57 259.66,28.57
GND on IN2 (solid shape): 234.66,27.19 234.66,24.1 234.4,23.84 234.04,23.84 234.03,23.83 232.25,23.83 232.13,23.96 232.13,27.26 232.25,27.39 234.47,27.39
GND on IN2 (solid shape): 32.64,88.35 32.67,88.35 32.84,88.18 32.84,87.65 32.23,87.04 32.23,84.17 32.15,84.09 28.97,84.09 28.67,84.4 28.67,88.18 28.85,88.36 32.63,88.36
GND on IN2 (solid shape): 201.54,46.7 201.54,44.36 201.29,44.11 198.75,44.11 198.67,44.19 198.67,45.93 198.48,46.12 198.19,46.12 198.19,47.25 198.4,47.46 199.26,47.46 199.26,47.46 200.78,47.46
GND on IN2 (solid shape): 77.74,169.27 77.59,169.16 77.47,169.03 77.34,167.97 78.25,167.39 82.2,167.39 82.31,167.28 82.31,166.4 82.29,166.38 81.58,166.38 80.19,164.99 79.09,164.99 78.85,164.75 77.95,164.75 77.62,165.08 74.7,165.08 72.22,167.55 70.32,167.55 69.62,168.26 69.62,169.24 69.72,169.33 70.24,169.33 70.58,169.11 70.99,169.11 71.54,169.66 71.31,170.4 71.31,178.29 77.74,178.29
GND on IN2 (solid shape): 196.82,8.42 202.41,8.42 202.49,8.35 207.12,8.35 207.17,8.4 234.31,8.4 234.43,8.52 241.02,8.52 241.17,8.37 245.62,8.37 245.67,8.32 251.9,8.32 251.93,8.35 251.96,8.35 269.45,8.35 269.5,8.3 271.46,8.3 271.69,8.52 278.2,8.52 280.69,7.49 281.72,5 282.28,4.44 288.21,4.44 288.42,4.37 288.65,4.34 297.69,4.34 297.69,2 297.26,0.94 296.2,0.51 281.2,0.51 280.85,0.65 280.71,1 280.71,5 279.97,6.77 278.2,7.51 195.12,7.51 195.75,7.87 196.06,8.52 196.72,8.52
GND on IN2 (solid shape): outline of 170 points within 0.51,7.51 194.57,178.29
GND on IN2 (solid shape): outline of 863 points within 92.65,14.34 299.18,178.29
GND on SVCC (solid shape): 14.23,171.52 14.35,171.46 14.47,171.44 14.6,171.46 14.71,171.52 15.43,171.52 15.9,171.04 15.9,171 15.89,170.96 16.01,170.67 16.3,170.55 16.34,170.55 16.39,170.56 16.53,170.42 16.49,170.32 16.48,170.22 16.49,170.12 16.53,170.03 16.53,168.63 16.42,168.49 16.38,168.32 16.42,168.14 16.53,168 16.53,167.28 15.43,166.18 12.29,166.18 11.45,167.03 11.45,171.11 11.51,171.09 11.58,171.09 11.83,171.19 11.93,171.44 11.93,171.48 11.92,171.52
GND on SVCC (solid shape): outline of 277 points within 9.67,94.8 100.35,157.01
GND on SVCC (solid shape): outline of 1165 points within 87.94,34.84 179.09,112.31
GND on SVCC (solid shape): outline of 1472 points within 23.39,136.44 182.37,176.77
GND on SVCC (solid shape): outline of 2658 points within 63.01,2.03 297.66,60.47
GND on SVCC1 (solid shape): 153.53,25.7 153.66,25.53 153.86,25.47 154.06,25.53 154.19,25.7 162.62,25.7 162.83,25.48 162.83,25.44 162.94,25.19 163.19,25.09 163.23,25.09 171.44,16.88 171.44,16.22 169.12,13.91 152.16,13.91 151.97,13.87 151.81,13.76 150.3,12.26 131.93,12.26 128.67,15.52 128.67,16.98 129.77,18.08 138.96,18.08 139.15,18.11 139.32,18.22 146.79,25.7
GND on SVCC1 (solid shape): 14.23,171.52 14.35,171.46 14.47,171.44 14.6,171.46 14.71,171.52 15.43,171.52 15.9,171.04 15.9,171 15.89,170.96 16.01,170.67 16.3,170.55 16.34,170.55 16.39,170.56 16.53,170.42 16.49,170.32 16.48,170.22 16.49,170.12 16.53,170.03 16.53,168.63 16.42,168.49 16.38,168.32 16.42,168.14 16.53,168 16.53,167.28 15.43,166.18 12.29,166.18 11.45,167.03 11.45,171.11 11.51,171.09 11.58,171.09 11.83,171.19 11.93,171.44 11.93,171.48 11.92,171.52
GND on SVCC1 (solid shape): outline of 5271 points within 23.39,2.03 297.66,176.77
GND on IN3 (solid shape): 258.16,40.63 258.16,39.08 256.89,37.81 256.13,37.81 255.59,38.35 255.59,40.66 255.72,40.78 258.01,40.78
GND on IN3 (solid shape): 260.11,28.11 260.11,27.25 259.51,26.64 257.19,26.64 256.56,27.27 256.56,28.31 256.81,28.57 259.66,28.57
GND on IN3 (solid shape): 32.84,88.18 32.84,87.65 32.23,87.04 32.23,84.17 32.15,84.09 28.97,84.09 28.67,84.4 28.67,88.18 28.85,88.36 32.66,88.36
GND on IN3 (solid shape): 234.66,27.19 234.66,24.1 234.4,23.84 234.04,23.84 234.03,23.83 232.25,23.83 232.13,23.96 232.13,27.26 232.25,27.39 234.47,27.39
GND on IN3 (solid shape): 201.54,46.7 201.54,44.36 201.29,44.11 198.75,44.11 198.67,44.19 198.67,45.95 198.54,46.08 198.24,46.08 198.06,46.26 198.06,47.31 198.21,47.46 200.78,47.46
GND on IN3 (solid shape): 269.08,41.49 269.08,40.45 269.05,40.42 265.45,40.42 265.4,40.48 265.4,41.47 265.54,41.61 265.55,41.61 265.66,41.69 265.74,41.81 265.74,41.81 266.21,42.28 268.29,42.28
GND on IN3 (solid shape): 77.74,169.27 77.59,169.16 77.47,169.03 77.34,167.97 78.25,167.39 82.22,167.39 82.34,167.28 82.34,166.51 82.2,166.38 81.42,166.38 80.03,164.99 79.09,164.99 78.88,164.78 74.91,164.78 72.8,166.9 72.61,167.2 72.3,167.39 72.03,167.66 70.22,167.66 69.56,168.32 68.19,168.32 68.04,168.47 68.04,169.15 68.22,169.33 70.24,169.33 70.58,169.11 70.99,169.11 71.54,169.66 71.31,170.4 71.31,178.29 77.74,178.29
GND on IN3 (solid shape): 197.86,8.3 244.67,8.3 244.89,8.52 278.2,8.52 280.3,7.83 281.57,6.02 282.09,5.5 282.43,5.5 283.26,4.67 286.55,4.67 286.56,4.66 287.91,4.66 288.25,4.43 288.65,4.34 297.69,4.34 297.69,2 297.26,0.94 296.2,0.51 281.2,0.51 280.85,0.65 280.71,1 280.71,5 279.97,6.77 278.2,7.51 195.12,7.51 195.75,7.87 196.06,8.52 197.64,8.52
GND on IN3 (solid shape): outline of 167 points within 0.51,7.51 194.57,178.29
GND on IN3 (solid shape): outline of 927 points within 92.17,13.78 299.18,178.29
GND on SGND2 (solid shape): outline of 10583 points within 0.51,0.51 299.18,178.29
GND on IN4 (solid shape): 234.66,27.19 234.66,24.1 234.4,23.84 234.04,23.84 234.03,23.83 232.25,23.83 232.13,23.96 232.13,27.26 232.25,27.39 234.47,27.39
GND on IN4 (solid shape): 260.11,28.11 260.11,27.25 259.51,26.64 258.83,26.64 258.77,26.69 257.14,26.69 256.56,27.27 256.56,28.31 256.81,28.57 259.66,28.57
GND on IN4 (solid shape): 269.16,41.8 269.16,40.43 268.83,40.1 266.17,40.1 265.81,40.46 265.66,40.46 265.62,40.47 265.61,40.51 265.61,41.54 265.71,41.64 265.79,41.74 265.83,41.86 265.83,41.88 266.21,42.26 268.7,42.26
GND on IN4 (solid shape): 258.14,40.65 258.14,39.21 258.16,39.19 258.16,39.08 257.06,37.98 255.96,37.98 255.95,37.99 255.91,38.09 255.84,38.18 255.66,38.37 255.61,38.4 255.6,38.42 255.59,38.44 255.59,40.66 255.72,40.78 258.01,40.78
GND on IN4 (solid shape): 31.26,88.08 32.78,88.08 32.82,88.07 32.84,88.03 32.84,87.85 32.02,87.04 32.02,84.21 31.96,84.11 31.85,84.13 31.82,84.17 28.9,84.17 28.67,84.39 28.67,85.15 28.67,88.18 28.85,88.36 30.98,88.36
GND on IN4 (solid shape): 200.45,47.15 200.47,47.15 200.48,47.14 201.54,46.08 201.54,44.95 201.52,44.9 201.47,44.9 201.14,44.92 200.94,44.67 200.92,44.64 200.89,44.63 198.72,44.63 198.69,44.64 198.67,44.68 198.67,45.91 198.51,46.07 198.24,46.07 198.06,46.25 198.06,47.1 198.08,47.14 198.11,47.15
GND on IN4 (solid shape): outline of 113 points within 268.24,45.51 271.6,49.42
GND on IN4 (solid shape): 212.85,8.37 223.72,8.37 223.87,8.52 278.2,8.52 280.69,7.49 281.72,5 281.72,4.75 282.7,3.78 285.9,3.78 286.68,4.56 288.02,4.56 288.32,4.4 288.65,4.34 297.69,4.34 297.69,2 297.26,0.94 296.2,0.51 281.2,0.51 280.85,0.65 280.71,1 280.71,5 279.97,6.77 278.2,7.51 195.12,7.51 195.75,7.87 196.06,8.52 212.7,8.52
GND on IN4 (solid shape): 77.74,169.27 77.59,169.16 77.47,169.03 77.34,167.97 78.25,167.39 82.15,167.39 82.37,167.17 82.37,166.59 82.24,166.46 80.63,166.46 80.55,166.38 80.37,166.38 79.93,165.94 79.93,165.77 79.8,165.63 79.8,165.27 79.51,164.98 79.08,164.98 78.87,164.77 74.76,164.77 72.83,166.7 72.6,167.22 72.07,167.43 71.86,167.4 71.67,167.31 71.3,167.31 71.03,167.54 70.69,167.62 70.46,167.58 70.25,167.48 70.03,167.6 69.78,167.64 69.73,167.64 69.68,167.64 69.36,167.96 68.55,167.96 68.19,168.32 68.19,169.21 68.32,169.33 70.24,169.33 70.58,169.11 70.99,169.11 71.54,169.66 71.31,170.4 71.31,178.29 77.74,178.29
GND on IN4 (solid shape): outline of 163 points within 0.51,7.51 194.57,178.29
GND on IN4 (solid shape): outline of 656 points within 285.11,37.15 294.4,47.39
GND on IN4 (solid shape): outline of 987 points within 92.5,14.24 299.18,178.29
