# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on SGND3 (solid shape): outline of 12516 points within 0.51,0.51 299.18,178.29
VCC0P9_CIO on BOTTOM (solid shape): 261.95,53.21 261.95,53.08 261.94,53.05 261.77,52.91 261.72,52.72 261.72,52.55 261.97,52.29 261.97,51.13 261.92,51.07 261.52,51.07 261.45,51.09 261.39,51.1 261.33,51.09 261.31,51.09 261.29,51.11 261.23,51.17 261.22,51.18 261.22,51.2 261.22,51.55 261.2,51.57 261.2,51.59 261.2,52.99 261.47,53.26 261.9,53.26
VCC0P9_DP on TOP (solid shape): 260.34,52.13 260.34,52.07 260.54,51.86 260.62,51.79 260.63,51.79 260.69,51.72 260.86,51.72 261.03,51.89 261.12,51.89 261.16,51.81 261.23,51.75 261.23,51.66 261.1,51.53 261.1,51.33 261.17,51.26 261.2,51.22 261.23,51.19 261.23,51.05 260.49,50.31 260.34,50.31 259.98,50.67 259.98,51.01 259.99,51.02 259.99,51.16 259.91,51.28 259.88,51.29 259.88,51.53 259.96,51.61 259.97,51.63 260,51.75 259.97,51.86 259.96,51.89 259.88,51.96 259.88,52.14 260.03,52.29 260.18,52.29
VCC0P9_DP on TOP (solid shape): 264.11,53.75 264.12,53.73 264.12,53.72 264.14,53.61 264.22,53.5 264.23,53.48 264.23,53.31 264.22,53.29 264.21,53.27 263.51,52.57 263.51,52.53 263.51,52.52 263.47,52.43 263.48,52.33 263.49,52.3 263.51,52.26 263.51,52.19 263.73,51.98 263.74,51.96 263.77,51.88 263.83,51.8 263.84,51.79 263.85,51.77 263.85,51.69 263.77,51.61 263.77,51.52 263.75,51.4 263.77,51.3 263.77,51.28 263.81,51.22 263.85,51.18 263.87,51.16 263.87,51.14 263.87,51.05 263.76,50.94 263.74,50.93 263.72,50.92 263.67,50.92 263.64,50.93 263.63,50.95 263.54,51.05 263.42,51.1 263.41,51.11 263.18,51.33 263.18,51.53 263.18,51.53 263.18,51.57 263.19,51.59 263.2,51.6 263.25,51.75 263.2,51.89 263.19,51.91 263.18,51.92 263.18,52.22 263.19,52.24 263.2,52.25 263.25,52.4 263.2,52.54 263.18,52.55 263.18,52.57 263.13,52.62 263.13,52.78 262.7,53.21 262.7,53.87 262.89,54.06 262.91,54.07 262.93,54.07 263.79,54.07
VCC0P9_DP on BOTTOM (solid shape): 264.27,53.91 264.27,53.27 264.18,53.17 263.75,53.17 263.61,53.03 263.61,51.27 263.5,51.16 263.21,51.16 263.13,51.24 263.13,52.6 263.06,52.67 263.06,53.93 263.08,53.95 264.24,53.95
VCC0P9_DP on BOTTOM (solid shape): 261.01,52.71 261.01,52.44 260.93,52.37 260.9,52.36 260.83,52.39 260.77,52.39 260.61,52.35 260.48,52.23 260.48,52.23 260.43,52.18 260.43,52.05 260.43,51.86 260.64,51.64 260.93,51.64 261.06,51.51 261.07,51.5 261.08,51.48 261.08,50.89 261.05,50.82 261.04,50.79 261,50.78 259.91,50.78 259.88,50.79 259.86,50.82 259.85,50.87 259.84,50.91 259.84,50.94 259.86,50.96 260.01,51.16 260.07,51.41 260.04,51.58 259.96,51.74 259.95,51.77 259.96,51.79 260.02,51.94 260.04,52.09 259.96,52.38 259.74,52.6 259.74,52.63 259.74,52.71 259.81,52.79 260.93,52.79
VCC0P9_DP on IN2 (solid shape): outline of 946 points within 257.63,48.23 264.43,54.52
VCC0P9_LVR on BOTTOM (solid shape): outline of 87 points within 264.43,47.82 268.35,52.34
VCC0P9_PCIE on TOP (solid shape): 263.08,50.62 263.1,50.62 263.19,50.52 263.19,50.5 263.19,50.37 263.19,50.35 263.11,50.24 263.08,50.14 263.08,50.11 263.07,50.08 263.1,49.96 263.19,49.84 263.19,49.82 263.19,49.73 263.18,49.69 263.17,49.68 263.1,49.59 263.08,49.48 263.14,49.29 263.3,49.19 263.32,49.19 264.25,48.25 264.25,48.08 264.25,48.05 264.23,48.03 264.17,47.99 264.14,47.93 264.13,47.92 263.86,47.64 263.61,47.64 263.21,48.04 263.14,48.04 263.04,48.06 262.94,48.04 262.93,48.04 262.85,48.04 262.44,47.62 262.29,47.62 261.81,48.11 261.81,48.29 261.81,48.29 261.89,48.34 261.93,48.41 261.94,48.42 262.02,48.5 262.05,48.51 262.06,48.51 262.25,48.6 262.34,48.79 262.34,48.8 262.35,48.83 262.46,48.94 262.47,48.95 262.57,49.03 262.6,49.15 262.58,49.24 262.5,49.34 262.49,49.36 262.49,49.58 262.5,49.6 262.58,49.7 262.6,49.8 262.58,49.88 262.53,49.95 262.51,49.97 262.5,49.99 262.49,50.01 262.49,50.16 262.94,50.61 262.96,50.62 262.98,50.62
VCC0P9_PCIE on BOTTOM (solid shape): 262.99,50.16 262.99,48.6 263.15,48.44 264.11,48.44 264.23,48.32 264.23,48.03 264.13,47.92 263.96,47.92 263.86,47.82 263.86,47.4 263.82,47.36 263.57,47.36 263.35,47.59 262.22,47.59 262.15,47.66 262.15,48.31 262.34,48.5 262.34,48.62 262.34,48.64 262.38,48.72 262.39,48.81 262.29,49.05 262.05,49.15 261.99,49.14 261.97,49.15 261.85,49.27 261.85,49.51 261.88,49.54 262.33,49.54 262.44,49.66 262.44,50.12 262.64,50.31 262.84,50.31
VCC0P9_SVR on TOP (solid shape): 279.95,58.51 279.95,56.53 279.8,56.38 275.76,56.38 275.46,56.07 275.46,55.62 275.33,55.49 273.83,55.49 273.73,55.59 273.73,57.73 274.16,58.16 275.79,58.16 276.4,58.77 279.7,58.77
VCC0P9_SVR on BOTTOM (solid shape): 266.89,50.84 266.89,50.6 267.18,50.32 267.18,49.91 267.08,49.82 265.82,49.82 265.66,49.66 265.66,49.62 265.64,49.54 265.63,49.47 265.64,49.4 265.66,49.32 265.66,49 265.64,48.93 265.62,48.87 265.6,48.85 265.45,48.85 265.4,48.9 265.4,50.84 265.54,50.98 266.75,50.98
VCC0P9_SVR on IN1 (solid shape): outline of 1321 points within 262.37,48.89 281.29,58.79
VCC0P9_SVR_IND on TOP (solid shape): 273.25,57.75 273.25,55.57 273.04,55.36 272.1,55.36 270.8,56.66 267.74,56.66 267.31,56.24 267.31,55.59 267.25,55.52 267.23,55.51 267.21,55.51 267.13,55.51 267,55.64 267,55.78 266.85,55.92 266.72,55.92 266.62,56.03 266.62,56.97 267.08,57.43 267.14,57.46 267.18,57.49 267.37,57.69 268.1,57.69 268.19,57.66 268.28,57.65 268.37,57.66 268.46,57.69 270.32,57.69 270.6,57.96 272.31,57.96 272.38,58.03 272.97,58.03
VCC0P9_USB on BOTTOM (solid shape): 261.32,49.7 261.51,49.7 261.65,49.56 261.65,49.05 261.64,49.03 261.63,49.01 261.31,48.69 260.68,48.69 260.64,48.73 260.64,49.12 260.83,49.3 260.83,49.81 260.86,49.85 261.17,49.85
VCC3V3_FLASH on TOP (solid shape): 253.64,44.7 253.64,42.54 253.46,42.36 252.9,42.36 252.75,42.51 252.75,44.7 252.85,44.8 253.54,44.8
VCC3V3_FLASH on TOP (solid shape): 249.84,32.02 249.88,32.01 249.89,31.97 249.89,31.26 249.9,31.26 249.93,31.23 249.93,31.16 249.85,31.08 249.85,31 249.85,30.99 249.8,30.79 249.85,30.6 249.85,29.35 249.73,29.23 248.84,29.23 248.79,29.28 248.79,30.34 248.81,30.36 248.83,30.37 249.05,30.51 249.13,30.77 249.14,30.8 249.46,31.12 249.53,31.12 249.59,31.16 249.63,31.22 249.66,31.25 249.66,31.26 249.69,31.26 249.69,32.02 249.7,32.02
VCC3V3_FLASH on BOTTOM (solid shape): 250.98,53.46 251.08,53.4 251.19,53.37 251.21,53.37 251.25,53.33 251.25,52.01 250.72,51.48 250.46,51.48 250.37,51.38 250.35,51.38 250.27,51.32 250.22,51.24 250.21,51.23 249.65,50.67 248.48,50.67 248.32,50.83 248.32,51.26 248.45,51.4 249.47,51.4 249.51,51.44 249.52,51.44 249.64,51.51 249.7,51.62 249.71,51.64 250.41,52.34 250.42,52.34 250.56,52.49 250.61,52.68 250.58,52.82 250.49,52.96 250.49,52.98 250.49,53.28 250.67,53.46
VCC3V3_FLASH on BOTTOM (solid shape): outline of 277 points within 240.4,29.25 249.83,38.82
VCCPHVLDO_1P8 on TOP (solid shape): 212.38,33.89 212.4,33.89 212.42,33.88 212.69,33.76 212.95,33.88 212.97,33.89 212.99,33.89 213.26,33.89 213.38,33.77 213.38,33.26 213.33,33.21 212.93,33.21 212.8,33.08 212.59,33.08 212.47,33.21 212.19,33.21 212.06,33.08 211.71,33.08 211.57,33.22 211.57,33.6 211.77,33.81 211.79,33.82 211.81,33.82 211.95,33.83 212.08,33.89
VCCPHVLDO_1P8 on BOTTOM (solid shape): 212.92,33.77 212.92,33.19 212.77,33.04 211.65,33.04 211.37,32.75 210.73,32.75 210.68,32.8 210.68,33.2 211.27,33.79 211.27,34.23 211.45,34.41 212.29,34.41
1P35V_LGATE on TOP (solid shape): 153.93,23.4 153.95,23.41 153.98,23.41 154.01,23.4 154.85,23.4 154.88,23.36 154.88,23.23 154.81,23.16 154.22,23.16 154.07,23 154.07,22.47 153.84,22.25 153.58,22.25 153.5,22.33 153.46,22.33 153.27,22.52 153.27,22.74
1P35V_PHASE on TOP (solid shape): 154.41,15.46 154.41,15.02 153.23,13.84 153.23,13.56 152.94,13.27 148.53,13.27 146.73,11.47 146.73,9.62 146.49,9.38 142.49,9.38 142.18,9.68 142.18,11.84 142.5,12.16 143.97,12.16 147.52,15.71 154.15,15.71
1P35V_PHASE on TOP (solid shape): 155.35,22.92 155.39,22.91 155.4,22.87 155.4,22.24 155.14,21.98 154.36,21.98 153.75,21.37 153.36,21.37 153.27,21.47 153.27,21.88 153.5,22.11 153.9,22.11 154.33,22.54 154.74,22.54 155.03,22.82 155.03,22.84 155.11,22.92
1P35V_UGATE on TOP (solid shape): 155.8,22.89 155.8,21.94 154.94,21.09 154.15,21.09 154.09,21.14 154.09,21.5 154.33,21.74 155.28,21.74 155.41,21.86 155.42,21.86 155.51,21.91 155.54,22 155.55,22 155.6,22 155.6,22.86 155.67,22.93 155.75,22.93
8068LX1_1.8V on TOP (solid shape): 12.14,86.24 12.14,82.9 11.93,82.69 11.04,82.69 10.6,83.13 8.53,83.13 8.43,83.23 8.43,84.46 8.52,84.71 8.43,84.97 8.43,86.68 8.65,86.91 11.47,86.91
8068LX_1.8V on TOP (solid shape): 171.98,21.68 173.4,21.68 173.5,21.58 173.5,21.57 173.5,20.84 173.38,20.72 172.04,20.72 171.71,21.05 170.63,21.05 170.35,20.77 170.35,20.41 170.22,20.29 167.23,20.29 166.72,20.79 166.72,22.32 167.02,22.62 171.04,22.62
8816ALGATE1 on TOP (solid shape): 27.19,173.57 27.19,172.63 26.89,172.33 24.5,172.33 24.4,172.43 24.4,173.42 24.94,173.96 26.81,173.96
8816ALGATE1 on TOP (solid shape): 17.23,170.46 17.23,170.01 16.6,169.38 15.86,169.38 15.83,169.41 15.83,169.43 14.82,169.43 14.78,169.44 14.77,169.48 14.77,169.58 14.78,169.62 14.82,169.63 15.83,169.63 15.83,169.64 15.86,169.66 15.89,169.66 16.81,170.59 17.09,170.59
8816ALGATE2 on TOP (solid shape): 17.16,168.6 17.3,168.6 17.9,168 17.9,167.78 17.79,167.67 17.16,167.67 17.06,167.58 16.91,167.58 16.69,167.8 16.67,167.8 16.6,167.86 16.6,167.89 16.3,168.19 16.3,168.49 16.16,168.64 14.84,168.64 14.8,168.67 14.8,168.8 14.82,168.82 16.17,168.82 16.2,168.85 16.91,168.85
8816APHASE1 on TOP (solid shape): 16.66,172.1 16.66,170.65 15.83,169.83 14.8,169.83 14.77,169.84 14.75,169.88 14.75,170.12 15.36,170.73 15.36,170.81 15.38,170.83 15.38,172.51 15.59,172.71 16.04,172.71
8816APHASE1 on TOP (solid shape): 35.45,173.68 35.45,172.63 36.59,171.49 36.59,167.5 36.12,167.03 31.22,167.03 29.2,165.01 29.2,164 28.24,163.03 25.57,163.03 25.39,163.21 25.39,166.26 25.62,166.49 26.69,166.49 27.32,167.12 27.32,168.37 27.07,168.62 25.57,168.62 25.49,168.7 25.49,171.77 25.65,171.92 27.16,171.92 27.47,172.23 27.47,173.38 28.02,173.93 35.2,173.93
8816APHASE2 on TOP (solid shape): 16,168.24 16,167.83 16.17,167.66 16.63,167.66 16.78,167.5 16.78,167.12 16.73,167.07 16.69,167 16.63,166.95 16.2,166.95 15.11,168.04 14.85,168.04 14.85,168.04 14.77,168.13 14.77,168.37 14.82,168.43 15.81,168.43
8816APHASE2 on TOP (solid shape): outline of 151 points within 6.95,147.01 16.25,156.84
8816AUGATE2 on TOP (solid shape): 14.19,168.08 14.22,168.06 14.24,168.03 14.24,167.03 14.25,167.03 14.28,167.02 14.35,166.92 14.43,166.89 14.45,166.89 14.46,166.88 15.03,166.88 15.21,166.69 15.21,166.25 15.06,166.09 14.67,166.09 13.99,166.77 13.99,167 14.02,167.03 14.03,167.03 14.03,168.03 14.05,168.06 14.08,168.08
9619_SW1 on TOP (solid shape): 90.37,66.29 90.37,62.6 89.53,61.76 82.8,61.76 82.67,61.89 82.67,66.84 82.8,66.97 89.68,66.97
9619_SW2 on TOP (solid shape): 80.26,66.56 80.26,61.87 80.16,61.76 73.15,61.76 73.02,61.89 73.02,66.84 73.15,66.97 79.85,66.97
9619_SW3 on TOP (solid shape): 70.61,66.56 70.61,61.87 70.5,61.76 63.49,61.76 63.37,61.89 63.37,66.84 63.49,66.97 70.2,66.97
9619_SW4 on TOP (solid shape): 60.95,66.56 60.95,61.87 60.85,61.76 53.84,61.76 53.71,61.89 53.71,66.84 53.84,66.97 60.55,66.97
9619_SW5 on TOP (solid shape): 51.3,66.56 51.3,61.87 51.2,61.76 44.19,61.76 44.06,61.89 44.06,66.84 44.19,66.97 50.89,66.97
9619_SW6 on TOP (solid shape): 41.65,66.56 41.65,61.87 41.55,61.76 34.54,61.76 34.41,61.89 34.41,66.84 34.54,66.97 41.24,66.97
9619_SW7 on TOP (solid shape): 32,66.56 32,61.87 31.9,61.76 25.7,61.76 24.76,62.7 24.76,66.84 24.89,66.97 31.59,66.97
9619_SW8 on TOP (solid shape): 22.7,66.21 22.7,62.22 22.24,61.76 16.22,61.76 15.72,62.27 15.72,66.31 16.38,66.97 21.94,66.97
24780_LX on TOP (solid shape): 78.23,48.12 78.23,47.4 78.46,47.16 81.91,47.16 82.49,46.57 82.49,44.56 82.64,44.56 82.65,44.58 83.09,44.58 83.22,44.44 83.22,44.2 83.11,44.1 83.05,43.96 82.22,43.96 81.98,43.73 80.28,43.73 80.16,43.86 80.16,44.49 80.03,44.62 75.51,44.62 75.2,44.92 75.2,47.9 75.69,48.38 77.97,48.38
51225_DH1 on TOP (solid shape): 122.8,22.35 123.19,22.35 123.37,22.17 123.37,21.24 123.14,21.01 122.81,21.01 122.55,21.28 122.55,22 122.2,22.35 121.57,22.35 121.54,22.37 121.52,22.4 121.52,22.51 121.54,22.54 121.57,22.56 122.31,22.56 122.31,22.56 122.59,22.56
51225_DH2 on TOP (solid shape): 117.29,17.87 117.55,17.87 117.69,17.73 117.69,16.4 117.54,16.25 116.88,16.25 116.75,16.39 116.75,17.74 116.88,17.87 117.28,17.87
51225_DH2 on TOP (solid shape): 119.26,22.56 119.29,22.54 119.31,22.51 119.31,22.36 118.5,21.56 118.15,21.56 118,21.71 118,22.04 118.51,22.56
51225_DL2 on TOP (solid shape): 118.38,11.33 118.38,10.72 118.31,10.65 116.94,10.65 116.89,10.7 116.89,11.34 116.95,11.41 118.3,11.41
51225_DL2 on TOP (solid shape): 119.66,22.15 119.7,22.14 119.72,22.1 119.72,21.42 119.7,21.38 119.66,21.37 119.51,21.37 119.06,20.92 119.03,20.92 118.82,20.71 118,20.71 117.83,20.88 117.83,21.16 118.08,21.41 118.6,21.41 119.35,22.15
51225_SW1 on TOP (solid shape): 137.6,14.51 137.6,11.12 138.74,9.98 138.74,9.49 138.61,9.35 131.71,9.35 131.65,9.41 131.65,11.28 130.65,12.28 125.16,12.28 125.15,12.28 125.11,12.28 124.96,12.43 124.96,14.9 125.05,14.99 137.12,14.99
51225_SW1 on TOP (solid shape): 123.45,23.58 123.96,23.58 124.11,23.42 124.11,22.97 124.05,22.9 122.97,22.9 122.71,23.16 121.57,23.16 121.54,23.17 121.52,23.21 121.52,23.31 121.54,23.34 121.57,23.36 122.31,23.36 122.31,23.36 122.64,23.36 122.92,23.65 123.37,23.65
51225_SW2 on TOP (solid shape): 117.33,14.41 117.33,11.78 117.31,11.75 117.28,11.73 113.08,11.73 112.61,11.26 112.61,10.29 111.49,9.17 104.03,9.17 103.68,9.52 103.68,12.96 105.15,14.43 117.32,14.43
51225_SW2 on TOP (solid shape): 117.17,23.36 118.52,23.36 118.52,23.36 119.26,23.36 119.3,23.34 119.31,23.31 119.31,23.16 119.31,23.16 118.24,23.16 117.89,22.81 117.74,22.81 117.65,22.72 116.72,22.72 116.57,22.87 116.57,23.33 116.66,23.42 117.11,23.42
51225_VIN on TOP (solid shape): 120.11,22.17 120.11,21.12 120.03,21.05 120.03,20.31 120.34,20.01 120.34,19.63 120.29,19.57 119.4,19.57 119.14,19.32 118.33,19.32 118.15,19.5 118.15,20.11 118.43,20.39 119.02,20.39 119.91,21.28 119.91,21.36 119.91,21.36 119.91,22.14 119.93,22.18 119.96,22.19 120.08,22.19
61087SW on TOP (solid shape): 234.8,60.47 234.82,60.46 234.83,60.45 235.45,59.83 235.45,58.23 235.44,58.2 235.4,58.18 234.6,58.18 234.6,57.96 235.4,57.96 235.44,57.94 235.45,57.91 235.45,57.73 235.44,57.7 235.4,57.68 234.6,57.68 234.57,57.65 227.32,57.65 226.94,58.03 226.94,60.32 227.08,60.45 227.09,60.46 227.11,60.47
+SPI_VCC on IN2 (solid shape): outline of 804 points within 236.01,19.82 243.58,33.87
+TPVDD on TOP (solid shape): 86.71,15.43 86.71,14.85 86.84,14.72 86.84,14.71 86.91,14.61 87.01,14.56 87.11,14.52 87.22,14.51 87.65,14.51 87.73,14.59 88.14,14.59 88.29,14.62 88.42,14.7 89.24,14.7 89.26,14.67 89.76,14.67 89.79,14.66 89.81,14.62 89.81,14.42 89.78,14.39 89.76,14.38 89.73,14.38 89.61,14.43 89.49,14.45 89.42,14.44 89.35,14.42 89.26,14.38 89.19,14.32 89.16,14.29 88.49,14.29 88.46,14.31 88.45,14.31 88.31,14.41 88.14,14.45 87.98,14.41 87.84,14.32 87.74,14.2 87.46,13.92 87.45,13.92 87.28,13.82 87.18,13.66 87.18,13.64 87.06,13.53 85.95,13.53 85.86,13.62 85.86,13.85 86.07,14.06 86.1,14.06 86.2,14.1 86.24,14.2 86.24,14.58 86.24,14.62 86.21,14.68 85.8,15.09 85.8,15.63 85.87,15.7 86.44,15.7
+TPVDD on TOP (solid shape): outline of 211 points within 91.08,14.65 98.15,20.51
+TPVDD on BOTTOM (solid shape): outline of 198 points within 86.91,16.54 92.64,19.75
+USBPWR on TOP (solid shape): outline of 204 points within 12.44,39.51 17.27,49.13
+USBPWR on BOTTOM (solid shape): 13.89,43.22 13.89,42.51 13.96,42.44 13.96,42.43 14.11,42.24 14.33,42.17 14.48,42.2 14.61,42.29 14.61,42.29 14.65,42.31 14.83,42.31 15.26,41.88 15.26,40.6 14.98,40.32 12.39,40.32 11.98,40.73 11.98,43.25 12.08,43.35 13.76,43.35
+USBPWR on IN4 (solid shape): 17.47,48 17.47,44.9 16.43,43.86 16.42,43.83 16.41,43.81 16.25,43.51 16.41,43.22 16.42,43.2 16.43,43.18 16.43,43.11 16.42,43.09 16.41,43.07 16.3,42.82 16.41,42.56 16.42,42.54 16.43,42.52 16.43,41.34 16.18,41.1 16.1,41.07 16.02,41.12 15.89,41.25 15.72,41.29 15.46,41.19 15.36,40.94 15.41,40.76 15.53,40.63 15.58,40.55 15.55,40.47 15.51,40.42 14.26,40.42 14.12,40.57 14.12,42.12 14.16,42.2 14.24,42.22 14.29,42.21 14.33,42.21 14.58,42.32 14.69,42.57 14.65,42.72 14.56,42.84 14.53,42.92 14.56,42.99 14.65,43.11 14.68,43.26 14.67,43.35 14.65,43.43 14.64,43.5 14.69,43.56 14.85,43.69 14.9,43.88 14.8,44.13 14.55,44.24 14.41,44.21 14.29,44.13 14.18,44.11 14.12,44.2 14.12,46.08 14.16,46.16 14.25,46.17 14.32,46.15 14.4,46.14 14.65,46.25 14.75,46.5 14.69,46.69 14.54,46.82 14.49,46.88 14.49,46.95 14.5,47 14.52,47.04 14.52,47.07 14.52,47.11 14.52,47.18 14.87,47.53 15.93,47.53 16.31,47.91 16.31,48.16 16.6,48.45 17.01,48.45
+USBPWR3 on TOP (solid shape): 288.14,6.35 287.04,5.25 284.19,5.25 283.81,5.63 283.81,6.21 283.97,6.37 284.07,6.37 284.3,6.6 285.08,6.6 285.22,6.73 286.77,6.73 287.28,7.24 287.28,7.26 287.34,7.32 287.34,8.83 287.5,8.98 288.14,8.98
+USBPWR3 on TOP (solid shape): 284.07,19.96 284.07,17.09 283.94,16.96 283.94,16.04 284.09,15.89 285.08,15.89 285.34,15.64 285.34,14.22 285.07,13.95 282.89,13.95 282.03,14.8 282.03,15.69 281.73,15.99 281.73,17.03 281.94,17.24 282.27,17.24 282.29,17.25 282.33,17.25 282.42,17.21 282.52,17.2 282.8,17.31 282.91,17.59 282.9,17.69 282.86,17.78 282.85,17.8 282.86,17.83 282.9,17.87 282.9,18.01 282.93,18.08 282.96,18.14 283,18.19 283.06,18.21 283.11,18.21 283.5,18.6 283.11,19 283.06,18.99 283.02,18.99 282.98,18.99 282.96,19.02 282.8,19.27 282.52,19.37 282.4,19.35 282.29,19.3 282.28,19.3 282.21,19.3 282.16,19.25 281.45,19.25 281.3,19.22 281.16,19.14 280.92,19.14 280.87,19.19 280.87,19.57 280.89,19.61 280.89,19.65 280.89,19.78 281.58,20.46 283.56,20.46
+USBPWR3 on BOTTOM (solid shape): 288.14,6.35 287.04,5.25 285.21,5.25 284.96,5.5 284.96,6.47 285.22,6.73 286.77,6.73 287.28,7.24 287.28,7.26 287.34,7.32 287.34,8.47 287.44,8.57 287.44,8.93 287.5,8.98 288.14,8.98
+USBPWR3 on IN1 (solid shape): 288.14,6.35 287.04,5.25 285.21,5.25 284.96,5.5 284.96,6.47 285.22,6.73 286.77,6.73 287.28,7.24 287.28,7.26 287.34,7.32 287.34,8.83 287.5,8.98 288.14,8.98
+USBPWR3 on IN2 (solid shape): outline of 1008 points within 279.7,4.96 288.14,20.34
+USBPWR3 on IN3 (solid shape): outline of 965 points within 279.77,4.96 288.13,20.34
+USBPWR3 on IN4 (solid shape): outline of 953 points within 279.83,4.41 288.14,20.34
+VREFCA_CHB_DIMM on TOP (solid shape): 181.5,50.74 181.49,50.71 181.46,50.61 181.45,50.51 181.45,50.1 181.27,49.92 180.42,49.92 180.09,49.59 180.09,48.98 179.67,48.98 179.67,50.79 179.77,50.89 181.35,50.89
+WL_VDD on TOP (solid shape): 50.19,52.34 50.19,52.07 49.97,51.86 49.97,49.68 49.83,49.54 48.53,49.54 48.3,49.77 48.3,51.93 48.41,52.04 49.34,52.04 49.7,52.41 50.12,52.41
+WL_VDD on TOP (solid shape): 54.81,45.95 54.81,44.98 54.62,44.79 54.14,44.79 53.96,44.98 53.96,45.58 53.79,45.74 53.31,45.74 53.15,45.59 53.15,45.54 53.14,45.5 53.14,45.47 53.14,44.94 53.14,44.91 53.15,44.88 53.15,44.71 53.15,44.71 53.15,44.45 52.78,44.08 52.78,43.98 52.76,43.96 52.76,43.59 52.55,43.38 51.93,43.38 51.52,43.79 51.52,44.85 51.57,44.94 51.67,44.94 51.75,44.92 51.83,44.91 52.1,45.02 52.22,45.29 52.22,45.31 52.44,45.52 52.44,45.7 52.74,46 52.73,46.04 52.72,46.08 52.72,46.1 52.73,46.12 52.76,46.16 52.78,46.22 53.08,46.52 54.24,46.52
+WL_VDD on TOP (solid shape): outline of 82 points within 48.79,30.85 53.1,39.01
+WL_VDD on BOTTOM (solid shape): 49.31,51.23 50.64,51.23 50.73,51.14 50.73,50.91 50.71,50.88 50.68,50.86 49.1,50.86 49.1,50.64 50.68,50.64 50.71,50.63 50.73,50.59 50.73,50.44 50.66,50.36 49.1,50.36 49.1,50.36 49.07,50.33 49.06,50.33 48.97,50.24 48.96,50.14 48.96,49.95 48.88,49.86 48.57,49.86 48.31,50.12 48.31,51.26 48.52,51.47 49.06,51.47
+WL_VDD on BOTTOM (solid shape): 48.94,33.64 49.1,33.64 49.1,33.64 50.65,33.64 50.65,33.64 51.07,33.64 51.48,33.24 51.48,32.73 51.43,32.66 51.38,32.59 51.33,32.52 51.28,32.44 51.25,32.36 51.22,32.28 51.2,32.19 51.18,32.11 51.18,32.02 51.18,31.93 51.19,31.84 51.21,31.76 51.24,31.67 51.27,31.59 51.31,31.51 51.36,31.44 51.4,31.38 51.39,31.36 51.38,31.34 50.9,30.86 49.43,30.86 49.23,31.06 49.23,31.54 49.08,31.69 48.02,31.69 47.97,31.74 47.97,33.14 50.65,33.14 50.65,33.36 49.1,33.36 49.1,33.14 47.97,33.14 47.97,33.66 48.03,33.72 48.86,33.72
+WL_VDD on IN3 (solid shape): outline of 100 points within 50.56,38.52 53.74,45.7
+WL_VDD on IN4 (solid shape): outline of 512 points within 47.52,44.11 53.61,51.35
ADOGND on TOP (solid shape): 29.15,22.79 29.15,22.22 29.15,22.22 29.15,21.15 28.8,20.79 25.38,20.79 25.24,20.99 25.01,21.06 24.93,21.05 24.85,21.03 24.83,21.07 24.83,21.71 24.48,22.06 23.84,22.06 23.74,22.17 23.74,22.25 23.76,22.32 23.76,22.4 23.76,22.62 23.95,22.8 25.05,22.8 25.46,23.21 28.73,23.21
ADOGND on BOTTOM (solid shape): outline of 715 points within 15.31,19.82 42.48,30.39
ADOGND on SGND (solid shape): outline of 173 points within 10.52,13.63 42.73,32.17
ADOGND on IN1 (solid shape): 25.24,31.87 25.26,31.84 25.29,31.83 25.34,31.75 25.31,31.67 25.27,31.63 25.09,31.13 25.37,30.66 25.38,30.63 25.39,30.6 25.38,30.42 25.46,30.25 25.49,30.17 25.44,30.1 25.3,29.76 25.54,29.47 25.6,29.4 25.58,29.3 25.46,29.04 25.57,28.79 25.61,28.71 25.57,28.64 25.56,28.11 26.09,28.15 26.11,28.17 26.14,28.17 26.16,28.17 26.18,28.16 26.21,28.11 26.21,28.07 25.51,27.37 25.49,27.36 25.47,27.35 21.98,27.35 21.96,27.37 21.95,27.38 21.63,27.58 21.32,27.38 21.31,27.37 21.29,27.35 21.2,27.35 21.11,27.42 21.13,27.53 22.93,29.33 22.99,29.41 23.01,29.51 23.01,31.81 23.37,32.17 24.93,32.17
ADOGND on IN1 (solid shape): outline of 231 points within 13.06,19.19 19.67,26.62
ADOGND on IN1 (solid shape): outline of 96 points within 10.52,13.63 14.59,18.67
ADOGND on IN1 (solid shape): outline of 925 points within 18.18,20.08 42.73,30.39
ADOGND on SGND1 (solid shape): outline of 173 points within 10.52,13.63 42.73,32.17
ADOGND on IN2 (solid shape): outline of 1211 points within 10.52,16.26 42.73,32.17
ADOGND on SVCC (solid shape): outline of 173 points within 10.52,13.63 42.73,32.17
ADOGND on SVCC1 (solid shape): outline of 173 points within 10.52,13.63 42.73,32.17
ADOGND on IN3 (solid shape): outline of 1484 points within 10.52,15.83 42.73,32.17
ADOGND on SGND2 (solid shape): outline of 173 points within 10.52,13.63 42.73,32.17
ADOGND on IN4 (solid shape): outline of 183 points within 25.36,20.49 42.73,28.76
ADOGND on IN4 (solid shape): outline of 1450 points within 10.52,13.63 38.02,32.17
ADOGND on SGND3 (solid shape): outline of 173 points within 10.52,13.63 42.73,32.17
BAT-V on TOP (solid shape): 72.52,51.31 72.52,49.75 71.13,48.35 69.62,48.35 69.39,48.13 67.14,48.13 67.09,48.18 67.01,48.2 66.63,48.2 66.61,48.22 63.85,48.22 62.82,49.25 62.19,49.25 61.23,50.21 61.23,51.3 61.49,51.55 72.28,51.55
BAT-V on BOTTOM (solid shape): 70.88,51.35 70.88,50.53 71.67,49.75 71.79,49.75 72.05,49.49 72.05,49.27 71.82,49.04 69.1,49.04 69.09,49.03 63.24,49.03 62.12,50.15 61.63,50.15 61.42,50.36 61.42,51.29 61.61,51.48 70.76,51.48
BAT-V on IN1 (solid shape): outline of 159 points within 61.46,46.24 72.56,51.83
C_SPKL+ on TOP (solid shape): 27.67,17.32 27.67,15.35 27.58,15.26 27.2,15.26 27,15.35 26.79,15.39 26.41,15.39 26.41,17.34 26.53,17.47 27.52,17.47
C_SPKL+ on BOTTOM (solid shape): 53.32,20.53 53.53,20.53 53.56,20.51 53.58,20.48 53.58,16.76 53.45,16.64 52.7,16.64 52.37,16.97 52.37,20.33 52.62,20.58 53.27,20.58
C_SPKL+ on IN2 (solid shape): 29.74,17.95 29.74,17.25 29.08,16.6 28.34,16.6 27.74,16 27.74,15.39 27.62,15.27 26.77,15.27 26.4,15.65 26.4,17.01 27.62,18.22 29.47,18.22
C_SPKL+ on IN2 (solid shape): 53.59,17.3 53.59,16.68 52.84,15.93 52.58,15.93 52.54,15.89 51.25,15.89 51.07,16.07 51.07,16.74 51.24,16.91 52.14,16.91 52.27,17.03 52.27,17.11 52.7,17.55 53.34,17.55
C_SPKL- on TOP (solid shape): 22.6,15.05 22.6,14.24 22.47,14.11 21.99,14.11 21.84,14.27 21.84,14.7 21.66,14.88 20.82,14.88 20.57,14.62 20.57,14.16 20.44,14.04 19.5,14.04 19.27,14.27 19.27,14.47 19.42,14.62 19.93,14.62 20.24,14.93 20.24,15.38 20.47,15.61 22.04,15.61
C_SPKL- on BOTTOM (solid shape): 54.72,20.57 54.73,20.56 54.82,20.47 54.82,16.86 55.27,16.42 55.75,16.42 55.97,16.2 55.97,15.54 55.47,15.03 54.32,15.03 53.96,15.39 53.96,20.35 53.97,20.38 54.01,20.4 54.11,20.38 54.2,20.38 54.46,20.43 54.69,20.58
C_SPKL- on IN3 (solid shape): 21.89,15.05 21.89,14.52 21.53,14.16 19.48,14.16 19.25,14.39 19.25,14.54 19.25,14.54 19.25,14.98 19.37,15.1 19.4,15.1 19.65,15.36 21.58,15.36
C_SPKL- on IN3 (solid shape): 55.85,15.66 55.85,14.8 55.58,14.53 54.23,14.53 54.16,14.61 53.86,14.76 53.49,14.71 53.46,14.72 53.44,14.74 53.44,15.64 53.5,15.71 55.8,15.71
CCD_PWR on TOP (solid shape): 178.8,134.4 178.88,134.4 178.95,134.4 179.03,134.42 179.05,134.42 179.14,134.33 179.14,133.49 178.86,133.21 177.2,133.21 177.19,133.22 176.95,133.26 176.71,133.22 176.7,133.21 175.48,133.21 175.36,133.1 175.18,133.1 175.04,132.96 175.03,132.96 174.95,132.93 174.88,132.88 174.59,132.88 174.44,133.04 174.44,133.75 174.57,133.87 175.08,133.87 175.28,134.08 177.69,134.08 178.05,134.43 178.71,134.43
CCD_PWR on BOTTOM (solid shape): 174.09,130.78 174.09,130.01 174.19,129.92 175.39,129.92 175.45,129.86 175.45,129.64 175.37,129.56 174.09,129.56 173.58,130.06 173.58,130.76 173.71,130.88 173.99,130.88
CORE_PLLVDD on BOTTOM (solid shape): 44.42,99.03 44.42,98.75 43.88,98.21 43.48,98.21 43.4,98.29 43.4,99.28 43.48,99.36 44.09,99.36
CORE_PLLVDD on BOTTOM (solid shape): 24.91,101.29 25.39,101.29 25.47,101.21 25.47,100.12 25.37,100.02 25.19,100.02 24.63,100.58 23.06,100.58 22.7,100.93 22.7,101.54 22.83,101.67 24.53,101.67
CORE_PLLVDD on BOTTOM (solid shape): 46.34,98.75 46.4,98.75 46.45,98.75 46.51,98.77 47.06,98.77 47.08,98.77 47.18,98.69 47.29,98.66 47.35,98.62 47.37,98.54 47.37,98.5 47.38,98.45 47.39,98.39 47.39,98.19 47.22,98.02 47.2,98.01 47.18,98.01 47.14,98.01 47.11,98.01 47.02,98 46.94,97.96 45.99,97.96 45.94,98.01 45.94,98.18 45.98,98.26 46,98.35 45.99,98.44 45.95,98.52 45.94,98.53 45.94,98.64 46.07,98.77 46.28,98.77
CORE_PLLVDD on BOTTOM (solid shape): 51.71,98.59 51.71,98.21 51.41,97.92 51.39,97.91 51.2,97.81 51.12,97.61 51.14,97.51 51.19,97.42 51.2,97.41 51.2,97.32 51.19,97.29 51.05,97.17 51,97.01 50.97,96.95 50.9,96.92 50.79,96.92 50.72,96.99 50.72,97.39 50.73,97.42 50.74,97.42 50.85,97.54 50.89,97.69 50.88,97.78 50.84,97.86 50.82,97.94 50.88,98.01 50.96,98.08 50.99,98.19 50.99,98.44 51.28,98.72 51.58,98.72
CORE_PLLVDD on BOTTOM (solid shape): 49.52,98.54 49.52,98.02 49.47,97.93 49.36,97.94 49.27,97.99 49.17,98.01 48.95,97.92 48.86,97.7 48.9,97.55 49.01,97.44 49.06,97.36 49.02,97.28 48.94,97.17 48.91,97.04 49,96.83 49.22,96.74 49.3,96.75 49.37,96.78 49.47,96.78 49.52,96.69 49.52,96.66 49.47,96.57 49.37,96.57 49.3,96.6 49.22,96.61 49,96.52 48.91,96.31 48.93,96.22 48.97,96.14 48.97,96.03 48.88,95.98 48.1,95.98 48.02,96.06 48.01,96.09 48.02,96.11 48.05,96.18 48.06,96.25 48.04,96.36 47.97,96.46 47.97,96.71 48.55,97.28 48.55,97.44 48.55,97.46 48.59,97.54 48.61,97.61 48.61,97.89 48.59,97.96 48.54,98.04 48.53,98.06 48.53,98.21 48.54,98.23 48.59,98.31 48.61,98.39 48.61,98.46 48.81,98.67 49.4,98.67
CORE_PLLVDD on IN4 (solid shape): outline of 2701 points within 22.7,98.16 65.46,122.04
DCPRTC on TOP (solid shape): 226.34,23.74 226.34,23.65 226.59,23.4 226.59,22.56 227.19,21.97 227.63,21.97 227.65,21.96 227.67,21.95 228.65,20.97 228.65,18.83 228.57,18.75 228.14,18.75 228.06,18.83 228.06,20.67 227.4,21.33 226.98,21.33 226.22,22.09 226.22,23.28 226.21,23.3 226.06,23.45 226.06,23.46 225.93,23.59 225.93,23.69 226.03,23.79 226.29,23.79
DDR_VTT on TOP (solid shape): 98.52,61.13 98.52,60.21 98.18,59.87 97.68,59.87 97.56,59.99 97.56,60.45 97.3,60.71 97.3,60.9 97.43,61.03 97.73,61.03 98.01,61.31 98.34,61.31
DDR_VTT on TOP (solid shape): 157.93,21.98 158.02,21.98 158.3,21.7 159.34,21.7 159.46,21.59 159.46,21.18 159.4,21.12 157.81,21.12 156.8,22.13 156.8,22.81 156.86,22.88 157.04,22.88
DDR_VTT on TOP (solid shape): 103.25,38.87 103.25,37.38 102.54,36.66 102.54,36.11 101.54,35.12 101.54,34.58 101.19,34.22 101.19,30.14 100.84,29.8 99.4,29.8 99.18,30.01 99.18,33.27 99.1,33.34 99.1,34.56 99.43,34.89 99.43,35.14 99.89,35.6 99.89,36.25 100.12,36.48 100.62,36.48 100.98,36.85 100.98,39.16 101.77,39.95 102.18,39.95
DDR_VTT on BOTTOM (solid shape): outline of 133 points within 95.78,59.7 99.05,64.53
DDR_VTT on BOTTOM (solid shape): outline of 220 points within 96.26,23.18 101.4,31.06
DDR_VTT on IN1 (solid shape): 159.56,22.98 159.56,22.67 159.38,22.5 158.34,22.5 158.18,22.34 158.18,21.78 157.96,21.56 157.6,21.56 157.35,21.81 157.35,22.7 157.93,23.28 159.25,23.28
DDR_VTT on IN3 (solid shape): outline of 179 points within 120.9,20.89 125.49,25.24
DDR_VTT on IN3 (solid shape): outline of 451 points within 148.15,21.45 159.84,25.24
DDR_VTT on IN3 (solid shape): outline of 527 points within 101.21,38.68 107.44,48.72
DP_USB_MUX_0V9 on TOP (solid shape): 269.87,12.74 269.87,11.4 269.74,11.27 268.57,11.27 268.45,11.4 268.45,12.64 268.67,12.87 269.74,12.87
DP_USB_MUX_0V9 on TOP (solid shape): 275.61,25.49 275.61,22.75 275.28,22.42 273.83,22.42 273.45,22.8 273.45,25.44 273.64,25.63 273.65,25.64 273.72,25.68 273.79,25.73 273.8,25.74 273.82,25.75 275.35,25.75
DP_USB_MUX_0V9 on BOTTOM (solid shape): 275.61,24.58 275.61,22.53 275.35,22.28 274.79,22.28 274.78,22.28 274.16,22.5 273.51,22.6 273.49,22.61 273.45,22.65 273.45,24.6 273.63,24.78 275.41,24.78
DP_USB_MUX_0V9 on IN3 (solid shape): outline of 1173 points within 268.45,11.07 279.65,24.45
DP_USB_MUX_0V9 on IN4 (solid shape): outline of 586 points within 263.8,18.99 275.86,28.43
DP_USB_MUX_AVDD09 on TOP (solid shape): 268.17,15.54 268.98,15.54 269.04,15.47 269.04,15.12 269.67,14.49 269.67,13.28 269.64,13.25 268.78,13.25 268.65,13.38 268.65,14.39 267.81,15.23 267.13,15.23 266.65,15.71 266.65,15.81 266.64,15.82 266.64,16.11 266.67,16.14 267.56,16.14
DP_USB_MUX_VDDIO on BOTTOM (solid shape): outline of 414 points within 258.59,15.59 269.06,21.4
DP_USB_MUX_VIN on TOP (solid shape): 269.82,25.52 269.82,22.42 268.89,21.49 268.53,21.49 268.14,21.1 267.64,21.1 267.64,21.14 266.64,21.14 266.62,21.16 266.62,21.31 266.64,21.34 267.67,21.34 268.37,22.04 268.37,23.94 269.13,24.71 269.13,25.52 269.23,25.62 269.72,25.62
DP_USB_MUX_VIN on BOTTOM (solid shape): 269.92,25.59 269.92,22.7 269.74,22.52 268.5,22.52 268.37,22.65 268.37,23.94 269.13,24.71 269.13,25.57 269.23,25.67 269.84,25.67
DP_USB_MUX_VX on TOP (solid shape): 272.81,25.59 272.81,22.7 272.51,22.39 271.7,22.39 269.78,20.48 269.35,20.48 269.18,20.64 269.12,20.64 269.04,20.67 268.95,20.68 268.94,20.68 267.69,20.68 267.65,20.69 267.64,20.73 267.64,20.74 266.67,20.74 266.63,20.75 266.62,20.79 266.62,20.9 266.66,20.94 267.64,20.94 267.64,20.95 268.22,20.95 268.55,21.28 268.98,21.28 271.49,23.79 271.49,25.57 271.7,25.77 272.64,25.77
DP_USB_MXU_DCDC_GND on TOP (solid shape): 271.29,25.52 271.29,23.82 270.45,22.98 270.1,22.98 270.02,23.05 270.02,25.54 270.15,25.67 271.14,25.67
DP_USB_MXU_DCDC_GND on BOTTOM (solid shape): 272.94,25.44 272.94,22.66 272.93,22.63 272.89,22.61 270.8,21.87 269.45,20.12 269.43,20.09 269.4,20.08 268.78,20.08 268.52,20.34 266.67,20.34 266.62,20.39 266.62,21.3 266.64,21.33 267.71,21.33 268.6,22.22 269.87,22.22 270.22,22.57 270.22,25.62 270.43,25.82 272.56,25.82
DP_USB_MXU_DCDC_GND on SGND (solid shape): 272.94,25.46 272.94,22.5 272.71,22.27 271.93,22.27 271.83,22.25 271.75,22.19 269.64,20.08 269.11,20.08 268.98,20.05 268.89,19.97 268.56,20.3 268.53,20.32 268.5,20.32 266.63,20.32 266.6,20.35 266.6,21.32 266.63,21.34 267.66,21.34 267.69,21.35 267.72,21.37 268.05,21.69 268.07,21.72 268.08,21.76 268.08,21.8 268.2,21.89 268.24,22.04 268.24,23.81 269.06,24.63 269.11,24.71 269.13,24.81 269.13,25.59 269.36,25.82 272.58,25.82
DP_USB_MXU_DCDC_GND on SGND3 (solid shape): 272.94,25.46 272.94,22.5 272.71,22.27 271.93,22.27 271.83,22.25 271.75,22.19 269.64,20.08 269.11,20.08 268.98,20.05 268.89,19.97 268.56,20.3 268.53,20.32 268.5,20.32 266.63,20.32 266.6,20.35 266.6,21.32 266.63,21.34 267.66,21.34 267.69,21.35 267.72,21.37 268.05,21.69 268.07,21.72 268.08,21.76 268.08,21.8 268.2,21.89 268.24,22.04 268.24,23.81 269.06,24.63 269.11,24.71 269.13,24.81 269.13,25.59 269.36,25.82 272.58,25.82
F_SPKL+ on TOP (solid shape): 49.62,23.18 50.51,23.18 50.69,23.01 50.69,22.97 50.69,22.96 50.63,22.8 50.61,22.64 50.63,22.45 50.71,22.28 50.71,22.27 50.71,21.98 50.73,21.81 50.79,21.65 50.79,21.63 50.63,21.47 49.43,21.47 49.33,21.38 49.02,21.38 48.53,21.86 48.53,23.26 48.61,23.33 49.47,23.33
F_SPKL+ on BOTTOM (solid shape): 56.08,20.44 56.08,17.06 56.08,17.06 56.08,17.01 55.87,16.8 55.43,16.8 55.2,17.02 55.2,20.4 55.29,20.49 56.03,20.49
F_SPKL+ on IN4 (solid shape): 56.2,18.91 56.2,17.31 55.97,17.09 55.01,17.09 54.7,17.39 54.7,18.81 54.83,18.94 56.18,18.94
F_SPKL+ on IN4 (solid shape): 50.77,21.89 50.77,21.58 50.62,21.43 50.62,20.74 50.31,20.44 49.93,20.44 49.59,20.78 49.59,21.82 49.8,22.04 50.62,22.04
F_SPKL- on TOP (solid shape): 50.41,24.76 50.41,24.27 50.62,24.07 50.62,23.84 50.46,23.69 48.69,23.69 48.49,23.88 48.49,24.69 48.69,24.88 50.29,24.88
F_SPKL- on BOTTOM (solid shape): 57.41,20.34 57.41,17.26 57.18,17.03 56.65,17.03 56.46,17.22 56.46,20.24 56.66,20.44 57.31,20.44
F_SPKL- on IN1 (solid shape): 57.08,19.03 57.08,17.02 56.86,16.81 56.48,16.81 56.27,17.02 56.27,18.19 55.95,18.51 55.26,18.51 55.04,18.74 55.04,19.35 55.29,19.6 56.51,19.6
F_SPKL- on IN1 (solid shape): 50.67,24.04 50.67,23.98 50.66,23.96 50.65,23.95 50.48,23.71 50.46,23.41 50.46,23.39 50.44,23.36 49.47,22.39 49.24,22.39 48.76,22.88 48.76,23.47 49.57,24.29 50.42,24.29
F_SPKR+ on TOP (solid shape): 50.74,29.05 50.74,28.77 50.62,28.64 50.31,28.64 50.11,28.44 50.11,28.29 49.96,28.13 49.65,28.13 49.38,28.41 48.92,28.41 48.72,28.61 47.09,28.61 46.72,28.24 46.72,28.06 46.5,27.84 45.97,27.84 45.88,27.93 45.88,28.77 46.06,28.95 46.5,28.95 46.89,29.33 50.46,29.33
F_SPKR+ on BOTTOM (solid shape): 58.62,20.23 58.62,17.22 58.62,17.22 58.54,17.14 58.04,17.14 57.67,17.51 57.67,20.31 57.77,20.41 58.44,20.41
F_SPKR+ on IN3 (solid shape): 49.96,28.51 49.96,27.93 49.95,27.9 49.91,27.88 47.95,27.88 47.75,28.08 47.75,28.69 47.83,28.78 49.7,28.78
F_SPKR+ on IN3 (solid shape): 58.83,19.49 58.85,19.41 58.87,19.35 58.87,17.44 58.57,17.14 58.31,17.14 58.3,17.15 58.2,17.15 58.05,17.3 58.05,19.71 58.26,19.93 58.39,19.93
F_SPKR- on TOP (solid shape): 49.61,27.93 50.06,27.93 50.12,27.99 50.43,27.99 50.54,27.88 50.54,27.35 50.13,26.94 50.13,26.92 49.07,26.92 48.49,27.49 48.49,28.15 48.64,28.29 49.24,28.29
F_SPKR- on BOTTOM (solid shape): 59.91,20.41 59.91,18.84 60.09,18.66 60.09,17.72 59.89,17.52 59.89,17.44 59.57,17.12 59.35,17.12 59.07,17.4 59.07,20.34 59.2,20.46 59.86,20.46
F_SPKR- on IN3 (solid shape): 60.59,18.93 60.59,17.5 60.14,17.06 59.56,17.06 59.3,17.31 59.3,19.57 59.51,19.78 59.73,19.78
F_SPKR- on IN3 (solid shape): 49.96,27.16 49.96,27.06 50.06,26.96 50.06,26.43 49.85,26.23 49.83,26.23 49.55,25.95 49.55,25.04 49.24,24.73 48.66,24.73 48.56,24.83 48.56,26.71 49.24,27.4 49.73,27.4
FBA_PLL_AVDD on TOP (solid shape): 29.36,108.42 29.36,104.82 29.33,104.79 29.32,104.78 29.2,104.74 29.1,104.66 29.04,104.63 28.97,104.65 28.61,104.71 28.36,104.45 28.34,104.42 28.31,104.41 27.25,104.41 26.99,104.66 26.99,104.69 26.87,104.81 26.87,106.47 26.99,106.59 26.99,108.04 27.55,108.6 29.18,108.6
FBA_PLL_AVDD on IN2 (solid shape): outline of 1353 points within 26.89,105.07 65.58,121.78
FBVDDQ_MEM on TOP (solid shape): outline of 1591 points within 42.72,103.82 66.64,122.95
FBVDDQ_MEM on TOP (solid shape): outline of 3224 points within 85.41,98.25 102.53,134.94
FBVDDQ_MEM on TOP (solid shape): outline of 10928 points within 7.38,104.94 85.74,168.04
FBVDDQ_MEM on BOTTOM (solid shape): outline of 384 points within 49.52,147.16 52.91,150.67
FBVDDQ_MEM on BOTTOM (solid shape): outline of 153 points within 25.08,150.92 28.63,157.29
FBVDDQ_MEM on BOTTOM (solid shape): outline of 60041 points within 7.46,97.2 102.53,158
FBVDDQ_MEM on IN1 (solid shape): outline of 1898 points within 43.1,103.78 66.59,123.46
FBVDDQ_MEM on IN2 (solid shape): outline of 1198 points within 43.02,103.83 67.18,123.45
FBVDDQ_MEM on SVCC1 (solid shape): outline of 943 points within 9.67,94.74 100.73,167.43
FBVDDQ_MEM on IN3 (solid shape): outline of 86178 points within 8.21,96.99 101.06,167.66
FBVDDQ_MEM on IN4 (solid shape): outline of 1376 points within 42.93,105.46 66.93,122.98
G5719LX2.5V on TOP (solid shape): 99.59,72.61 99.59,71.8 99.15,71.37 97.48,71.37 97.15,71.03 97.15,70.76 97.05,70.65 96.18,70.65 96.06,70.78 96.06,71.92 96.82,72.69 99.51,72.69
GLS_LED_EN_R on TOP (solid shape): 7.79,60.93 7.79,60.21 7.83,60.18 7.83,60.09 7.87,59.99 7.97,59.95 8.97,59.95 9.05,59.97 9.1,60.02 9.1,60.03 9.15,60.07 9.18,60.09 9.21,60.08 9.31,60.04 9.42,60.02 9.55,60.05 9.67,60.11 10.31,60.11 10.36,60.06 10.36,59.48 10.25,59.38 9.16,59.38 9.13,59.39 9.06,59.49 8.97,59.52 7.4,59.52 7.15,59.76 7.13,59.79 7.13,60.81 7.3,60.98 7.73,60.98
GLS_LED_PWR on TOP (solid shape): 16.66,163.95 16.66,162.73 16.35,162.42 15.94,162.42 15.75,162.61 15.75,163.07 15.75,163.07 15.75,163.76 15.88,163.88 15.88,164.06 15.97,164.15 16.45,164.15
GLS_LED_PWR on TOP (solid shape): 9.15,54.36 9.15,53.84 9.09,53.78 8.84,53.78 8.78,53.78 8.18,53.78 8.03,53.75 7.9,53.67 7.84,53.61 7.76,53.48 7.73,53.34 7.73,53.32 7.62,53.21 6.79,53.21 6.7,53.3 6.7,53.97 6.8,54.07 7.5,54.07 7.56,54.13 7.56,54.21 7.97,54.62 8.89,54.62
GLS_LED_PWR on BOTTOM (solid shape): 16.73,163.59 16.73,160.09 16.63,159.99 15.94,159.99 15.83,160.1 16.5,160.1 16.5,161.4 16.3,161.4 16.3,160.1 15.83,160.1 15.77,160.16 15.77,161.15 15.73,161.19 15.73,161.24 15.67,161.3 15.67,163.55 15.91,163.8 16.52,163.8
LANVCC on BOTTOM (solid shape): 18.97,46.63 18.97,45.91 18.9,45.84 18.86,45.84 18.84,45.85 18.73,45.92 18.6,45.94 18.33,45.83 18.18,45.49 18.11,45.46 14.86,45.46 14.72,45.32 14.66,45.32 14.62,45.31 14.04,45.31 13.71,45.63 12.21,45.63 12.11,45.74 12.11,46.3 12.19,46.37 13.94,46.37 14.22,46.09 14.52,46.09 14.58,46.15 14.65,46.19 14.7,46.25 14.72,46.26 14.74,46.27 16.41,46.27 16.79,46.65 17.75,46.65 17.85,46.64 17.95,46.65 18.21,46.65 18.33,46.78 18.81,46.78
LCDVCC on TOP (solid shape): 181.65,111.4 181.65,109 181.48,108.83 181.17,108.83 180.97,109.03 180.97,110.93 180.98,110.98 180.98,111.02 180.98,111.32 180.99,111.36 181,111.37 181.1,111.47 181.58,111.47
LCDVCC on TOP (solid shape): 180.53,103.09 181.08,103.09 181.15,103.07 181.22,103.07 181.29,103.07 181.36,103.09 181.39,103.09 181.42,103.12 181.98,103.12 182.27,102.84 182.27,102.33 181.89,101.96 180.78,101.96 180.39,102.14 180,101.96 179.59,101.96 179.47,102.07 179.47,102.81 179.47,102.81 179.47,103.03 179.57,103.12 180.5,103.12
LCDVCC on BOTTOM (solid shape): 173.32,113.91 175.41,113.91 175.48,113.83 175.48,111.01 175.11,110.65 175.11,107.33 174.97,107.19 174.64,107.19 173.81,106.35 173.81,105.64 173.75,105.59 172.52,105.59 172.4,105.71 172.4,106.7 172.87,107.17 172.87,111.29 172.38,111.78 172.38,114.06 172.5,114.18 173.06,114.18
MIC_VCC on BOTTOM (solid shape): 173.43,130.35 173.43,129.92 173.95,129.39 175.4,129.39 175.45,129.34 175.45,129.15 175.36,129.05 173.57,129.05 172.77,129.86 172.77,130.4 172.95,130.59 173.18,130.59
NVVDD on TOP (solid shape): outline of 171 points within 15.18,71.92 91,82.85
NVVDD on TOP (solid shape): outline of 7660 points within 45.17,92.97 75.53,120.62
NVVDD on BOTTOM (solid shape): 18.4,77.29 19.81,77.51 19.81,77.51 22.24,77.51 24.02,75.73 27.56,75.73 27.77,75.52 29.6,75.52 29.81,75.73 31.9,75.73 33.55,77.38 33.96,77.38 34.11,77.24 34.79,77.24 34.91,77.24 34.96,77.29 34.98,77.29 35.04,77.3 35.09,77.35 35.1,77.36 35.14,77.38 35.19,77.38 35.23,77.36 35.24,77.35 35.29,77.3 35.36,77.29 36.04,77.29 36.13,77.29 36.14,77.3 36.19,77.3 36.37,77.34 36.51,77.46 37.75,77.46 37.89,77.34 38.07,77.3 38.25,77.34 38.39,77.46 39.48,77.46 39.6,77.39 39.73,77.37 39.86,77.38 39.97,77.44 40.02,77.38 44.6,77.38 44.71,77.28 45.47,77.28 45.81,76.93 49.29,76.93 49.61,77.24 49.73,77.24 49.87,77.38 56.68,77.38 56.8,77.26 87.03,77.26 88.84,75.45 89.68,75.45 90.19,74.94 90.19,72.3 89.81,71.92 88.74,71.92 88.73,71.96 88.56,72.17 88.31,72.25 88.05,72.17 87.89,71.96 87.88,71.92 16.1,71.92 15.77,72.25 15.77,77.26 16.02,77.51 16.97,77.51
NVVDD on BOTTOM (solid shape): outline of 5431 points within 43.81,93.33 75.68,120.84
NVVDD on IN1 (solid shape): outline of 8022 points within 44.54,96.13 71.93,120.29
NVVDD on IN2 (solid shape): outline of 9582 points within 45.48,91.82 75.55,120.34
NVVDD on SVCC (solid shape): outline of 1642 points within 15.51,70.4 94,120.46
NVVDD on SVCC1 (solid shape): outline of 1547 points within 15.51,70.65 94,120.31
NVVDD on IN3 (solid shape): outline of 28261 points within 15.82,71.54 89.84,120.23
NVVDD on IN4 (solid shape): outline of 9345 points within 45.48,93.63 75.72,120.33
PEX_PLL_HVDD on BOTTOM (solid shape): 58.82,101.05 58.82,100.78 58.75,100.71 58.75,100.44 58.74,100.44 58.74,99.56 58.7,99.52 57.81,99.52 57.42,99.91 57.39,99.91 57.39,99.93 56.82,99.93 56.76,99.99 56.76,100.47 56.87,100.58 57.32,100.58 57.54,100.8 57.54,100.95 57.69,101.09 58.78,101.09
PPC_CC1_6 on TOP (solid shape): 248.12,20.53 249.09,20.53 249.13,20.52 249.14,20.48 249.14,20.23 249.14,20.11 248.15,19.12 247.39,19.12 247.08,18.81 247.08,18.13 246.87,17.91 246.84,17.89 246.82,17.86 246.63,17.67 246.63,17.52 246.42,17.31 245.92,17.31 245.76,17.47 245.76,18 246.12,18.36 246.26,18.36 246.26,19.97 246.4,20.11 247.49,20.11 247.95,20.57 248.09,20.57
PPC_CC2_4 on TOP (solid shape): 246.74,23.31 246.75,23.29 246.82,23.12 246.97,23 247.02,22.95 247.02,22.88 247.01,22.82 247.01,22.76 247.06,22.55 247.22,22.41 247.23,22.41 247.95,21.68 247.97,21.68 247.99,21.67 248,21.66 248.03,21.62 248.08,21.6 248.09,21.59 248.12,21.56 248.12,21.53 249.09,21.53 249.13,21.52 249.14,21.48 249.14,21.28 249.13,21.25 249.09,21.23 248.12,21.23 248.09,21.2 247.44,21.2 247.24,21.4 246.73,21.4 246.3,21.83 246.3,22.57 246.25,22.62 246.25,23.23 246.35,23.33 246.72,23.33
PPC_DVDD_IO on TOP (solid shape): 253.94,27.09 253.94,26.85 253.64,26.56 253.64,24.24 253.23,23.83 253.23,23.43 253.01,23.21 251.87,23.21 251.83,23.22 251.81,23.26 251.81,24.25 251.94,24.38 252.47,24.38 252.75,24.65 252.75,27.17 252.88,27.3 253.74,27.3
PPC_DVDD_IO on BOTTOM (solid shape): 253.46,27.85 253.79,27.85 254.02,27.63 254.02,26.79 253.82,26.58 252.93,26.58 252.64,26.87 252.63,26.89 252.63,26.92 252.63,26.95 252.64,26.99 252.52,27.27 252.24,27.39 252.06,27.34 251.9,27.2 251.88,27.19 251.63,27.19 251.48,27.35 251.48,27.93 251.57,28.02 251.59,28.03 251.64,28.02 251.68,28.02 251.76,28.03 251.85,28.06 253.26,28.06
PPC_DVDD_IO_C on TOP (solid shape): 251.63,25.75 251.63,24.91 251.15,24.43 251.15,24.26 251.12,24.23 251.12,23.26 251.1,23.22 251.07,23.21 250.88,23.21 250.85,23.22 250.83,23.26 250.83,24.97 250.87,25.01 250.87,25.54 250.95,25.67 250.98,25.81 251,25.82 251.55,25.82
PPC_DVDD_IO_C on BOTTOM (solid shape): 251.17,25.18 251.2,25.18 251.48,25.18 251.52,25.18 251.54,25.17 251.66,25.06 251.66,24.83 252.04,24.45 252.49,24.45 252.88,24.83 253.33,24.83 253.43,24.73 253.43,24.07 253.25,23.89 252.45,23.89 252.45,23.9 251.67,23.9 251.67,23.87 251.05,23.87 250.84,24.07 250.84,25.06 250.97,25.19 251.14,25.19
PPC_VCCD_C on TOP (solid shape): 250.21,25.72 250.21,25.71 250.31,25.54 250.48,25.45 250.49,25.44 250.69,25.24 250.69,24.3 250.68,24.26 250.66,24.24 250.63,24.23 250.62,24.23 250.62,23.26 250.6,23.22 250.57,23.21 250.37,23.21 250.33,23.22 250.31,23.26 250.31,24.23 250.28,24.26 250.28,24.38 250.13,24.53 249.92,24.53 249.68,24.77 249.68,25.26 249.5,25.44 249.5,25.72 249.6,25.82 250.11,25.82
PPC_VCCD_C on BOTTOM (solid shape): 251.07,26.68 251.15,26.67 251.23,26.68 251.32,26.71 251.86,26.71 251.96,26.61 252.14,26.61 252.24,26.6 252.34,26.61 252.67,26.61 253.43,25.85 253.43,25.31 253.28,25.16 252.95,25.16 252.85,25.26 252.85,25.57 252.39,26.03 251.48,26.03 251.3,26.2 251.27,26.2 251.25,26.22 250.59,26.22 250.54,26.21 250.46,26.2 250.44,26.19 250.26,26.04 250.2,25.82 250.29,25.56 250.53,25.43 250.55,25.43 250.62,25.37 250.62,24.81 250.44,24.63 250.08,24.63 249.73,24.98 249.73,26.07 250.37,26.71 250.98,26.71
PPC_VCON_5V on TOP (solid shape): 247.39,21.07 247.41,21.05 248.12,21.05 248.12,21.03 249.08,21.03 249.11,21.02 249.13,20.98 249.13,20.78 249.11,20.74 249.08,20.73 248.12,20.73 248.12,20.72 247.85,20.72 247.49,20.36 246.45,20.36 246.27,20.54 246.27,20.95 246.35,21.02 246.35,21.02 246.45,21.09 246.52,21.19 246.52,21.2 246.58,21.25 247.21,21.25
PPC_VCON_5V on BOTTOM (solid shape): 248.43,21.25 248.43,20.95 248.3,20.82 247.54,20.82 246.8,20.08 246.09,20.08 246.02,20.16 246.02,20.74 246.14,20.87 246.42,20.87 246.55,20.99 246.55,20.99 246.91,21.35 248.32,21.35
PPC_VDDD_C on TOP (solid shape): 252.56,25.71 252.56,24.77 252.32,24.53 251.89,24.53 251.66,24.3 251.66,24.26 251.63,24.23 251.62,24.23 251.62,23.26 251.6,23.22 251.57,23.21 251.37,23.21 251.33,23.22 251.31,23.26 251.31,24.23 251.3,24.23 251.3,24.38 251.78,24.86 251.78,25.7 251.91,25.82 252.44,25.82
PS_USB_VBUS_DSH_QR on TOP (solid shape): 111.65,140.34 111.65,139.23 111.41,138.99 108.13,138.99 107.92,139.2 107.92,139.86 108.42,140.36 111.63,140.36
PS_USB_VDDP_IN on BOTTOM (solid shape): 19.23,101.41 19.23,101.39 19.36,101.13 19.63,101.02 19.77,101.05 19.89,101.12 19.96,101.15 20.02,101.12 21,101.12 21.07,101.09 21.1,101.03 21.15,100.87 21.26,100.74 21.3,100.68 21.29,100.61 21.25,100.51 21.23,100.41 21.35,100.13 21.63,100.01 21.9,100.12 22.02,100.4 23.13,100.4 23.18,100.34 23.18,99.83 22.95,99.59 20.5,99.59 20.29,99.38 20.29,98.59 20.14,98.44 19.26,98.44 19.15,98.55 19.15,99.26 18.46,99.96 18.44,100.03 18.41,100.08 18.4,100.15 18.44,100.21 18.56,100.35 18.6,100.52 18.48,100.8 18.21,100.92 18.08,100.9 17.97,100.84 17.9,100.82 17.83,100.85 17.7,100.95 17.54,100.99 17.51,101.01 17.49,101.04 17.49,101.36 17.57,101.44 19.2,101.44
PS_USB_VDDP_IN on IN1 (solid shape): outline of 502 points within 38.97,97.25 45.55,100.83
PS_USBC_PD_SW1 on TOP (solid shape): 110.33,156.51 110.33,154.45 109.92,154.04 105.43,154.04 105.12,154.35 105.12,156.33 105.58,156.79 110.05,156.79
PS_USBC_PD_SW2 on TOP (solid shape): 109.75,153.23 109.75,149.77 109.44,149.47 106.39,149.47 106.32,149.55 106.32,150.31 105.15,151.48 105.15,153.51 105.28,153.64 109.34,153.64
PS_USBC_PD_VOUT_1 on TOP (solid shape): 102.61,152.31 102.61,151.99 102.61,151.97 102.5,151.82 102.46,151.66 102.55,151.42 102.77,151.28 102.91,151.27 103.8,151.27 106.22,148.86 107.49,148.86 107.74,148.61 107.74,147.21 108.4,146.55 108.4,145.1 108.04,144.75 105.28,144.75 104.92,145.1 104.92,145.89 104.76,146.05 103.74,146.05 103.37,146.42 101.72,146.42 101.47,146.68 101.47,152.49 101.51,152.53 102.39,152.53
PS_USBC_PD_VOUT_1 on BOTTOM (solid shape): 106.7,148.68 108.1,148.68 108.65,148.12 108.65,145.99 108.38,145.71 105.71,145.71 105.33,146.09 105.33,147.21 103.37,149.17 103.37,150.31 103.6,150.54 104.84,150.54
R_SPKL+ on TOP (solid shape): 8.88,27.02 8.88,26.2 8.76,26.08 8.1,26.08 7.98,25.95 6.91,25.95 6.72,26.14 6.72,26.62 6.73,26.65 6.73,26.74 6.9,26.92 7.71,26.92 7.89,27.09 8.81,27.09
R_SPKL+ on BOTTOM (solid shape): 20.97,59.38 17.8,59.38 16.1,57.68 16.1,57.67 14.79,56.36 14.3,56.36 13.45,55.51 13.45,53.26 13,52.8 12.74,52.8 12.46,53.08 12.46,53.33 12.47,53.33 12.47,53.47 12.48,53.49 12.48,56.22 12.63,56.32 12.72,56.46 13.21,56.95 14.08,56.95 14.4,57.27 14.4,57.62 16.95,60.17 20.97,60.17
R_SPKL+ on IN2 (solid shape): 13.68,53.81 13.68,53.46 13.05,52.82 13.05,51.6 12.92,51.48 12.44,51.48 12.16,51.76 12.16,53.18 12.97,53.99 13.51,53.99
R_SPKL- on TOP (solid shape): 8.93,25.54 8.93,24.88 8.82,24.77 8.08,24.77 8.08,24.77 7.75,24.77 7.38,25.14 6.88,25.14 6.78,25.24 6.78,25.64 6.79,25.68 6.83,25.7 8.78,25.7
R_SPKL- on BOTTOM (solid shape): 19.18,58.92 21.1,58.92 21.1,58.13 19.34,58.13 19.27,58.16 19.11,58.49 18.84,58.6 18.56,58.49 18.45,58.21 18.45,58.16 18.46,58.12 18.43,58.04 18.42,57.96 18.42,57.94 15.45,54.97 14.96,54.97 14.86,54.93 14.82,54.83 14.82,52.82 14.23,52.24 13.35,52.24 13.29,52.3 13.29,52.5 13.83,53.03 13.83,55.23 14.57,55.98 14.94,55.98 16.48,57.51 16.48,57.52 17.87,58.92 17.88,58.92 17.96,59 19.1,59
R_SPKL- on IN2 (solid shape): 14.48,52.91 14.48,51.67 14.04,51.22 13.43,51.22 13.3,51.35 13.3,52.65 13.89,53.23 14.17,53.23
R_SPKR+ on TOP (solid shape): 9.16,20.92 9.16,20.21 9.12,20.17 7.55,20.17 7.49,20.23 6.9,20.23 6.78,20.36 6.78,20.87 6.9,21 9.09,21
R_SPKR+ on BOTTOM (solid shape): 20.97,56.88 19.32,56.88 18.94,56.5 18.94,55.41 19.07,55.29 19.07,54.14 18.94,54.02 18.05,54.02 17.93,54.14 17.93,54.49 17.93,54.49 17.93,56.91 18.36,57.34 18.44,57.37 18.51,57.32 18.66,57.2 18.84,57.15 19.12,57.27 19.23,57.55 19.23,57.56 19.26,57.64 19.34,57.67 20.97,57.67
R_SPKR+ on IN4 (solid shape): 19.24,54.65 19.24,54.2 19.04,53.99 17.48,53.99 17.48,53.99 17.05,53.99 16.88,54.16 16.88,54.7 17.01,54.83 19.06,54.83
R_SPKR- on TOP (solid shape): 9.04,22.44 9.04,21.53 8.88,21.38 6.85,21.38 6.82,21.39 6.8,21.43 6.8,21.81 6.88,21.89 7.52,21.89 7.78,22.15 7.79,22.16 8.15,22.52 8.96,22.52
R_SPKR- on BOTTOM (solid shape): 21.25,53.08 20.87,52.7 18.23,52.7 18.05,52.87 18.05,53.58 18.1,53.64 19.1,53.64 19.45,53.99 19.45,55.67 19.32,55.79 19.32,56.34 19.4,56.42 21.25,56.42
R_SPKR- on IN4 (solid shape): 19.2,53.52 19.2,52.93 18.89,52.62 17.49,52.62 17.36,52.75 17.36,53.27 17.8,53.71 19.01,53.71
S1 on TOP (solid shape): 252.19,34.07 252.19,34.07 252.88,34.07 252.91,34.05 252.93,34.02 252.93,33.9 252.89,33.87 252.19,33.87 252.17,33.85 252.11,33.85 252.01,33.75 252.01,32.58 252.11,32.48 252.19,32.48 252.19,32.47 252.9,32.47 252.94,32.45 252.95,32.42 252.95,32.27 252.85,32.17 249.65,32.17 249.52,32.05 249.52,32 249.49,31.97 249.49,31.28 249.47,31.26 249.35,31.26 249.31,31.27 249.29,31.31 249.29,32.25 249.22,32.33 249.22,33.93 249.35,34.05 251.96,34.05 252.01,34.1 252.16,34.1
S1 on BOTTOM (solid shape): 252.01,33.93 252.01,32.27 251.91,32.17 249.37,32.17 249.22,32.33 249.22,33.93 249.35,34.05 251.89,34.05
