# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R1140  TPM@2.2_5%_6  [R0603]  235.98 11.6 180 bottom
R1141  *0_5%_4  [R0402]  251.35 11.47 180 bottom
R1142  *4.7K_5%_4  [R0402]  282.7 6.32 270 bottom
R1143  *4.7K_5%_4  [R0402]  283.69 6.32 270 bottom
R1144  4.7K_5%_4  [R0402]  281.96 8.32 0 bottom
R1145  *short_0402  [S0402]  241.39 9.87 0 bottom
R1146  *short_0805  [S0805]  231.16 10.07 180 bottom
R1147  *short_0805  [S0805]  225.19 10.07 180 bottom
R1148  *short_0603  [S0603]  245.86 28.58 0 top
R1149  100K_5%_4  [R0402]  34.64 34.22 0 bottom
R1150  100K_1%_4  [R0402]  212.81 50.39 270 top
R1151  *short_0201  [S0201]  208.04 52.62 90 top
R1152  *0_5%_2  [R0201]  208.04 51.48 270 top
R1153  *short_0402  [S0402]  237.13 44.49 180 top
R1154  *short_0402  [S0402]  20.86 150.54 90 bottom
R1155  *short_0402  [S0402]  21.2 155.16 90 bottom
R1156  *short_0402  [S0402]  210.97 10.89 90 top
R1157  *short_0402  [S0402]  211.98 10.84 90 top
R1158  100K_1%_4  [R0402]  94.51 27.26 180 bottom
R1159  10K_1%_2  [R0201]  95.14 22.65 90 bottom
R1161  *0_5%_4  [R0402]  93.47 16.42 225 bottom
R1162  *0_5%_2  [R0201]  92.45 15.41 225 bottom
R1163  10K_1%_2  [R0201]  218.84 13.88 270 bottom
R1164  *10K_1%_2  [R0201]  220.69 15.46 180 bottom
R1165  *10K_1%_2  [R0201]  69.14 40.17 0 top
R1166  *EV@1M_5%_2  [R0201]  102.51 160.47 270 bottom
R1167  *EV@22_5%_8  [R0805]  102.25 152.95 180 bottom
R1168  *EV@1M_5%_2  [R0201]  100.73 158.56 270 bottom
R1169  *EV@100K_1%_2  [R0201]  104.41 157.42 0 bottom
RG1  *549_1%_4  [R0402]  87.02 133.34 0 top
RG2  1K_1%_4  [R0402]  89.73 133.35 180 top
RG3  *931_1%_4  [R0402]  91.09 132.81 90 top
RG4  *931_1%_4  [R0402]  85.13 132.25 180 top
RG5  *549_1%_4  [R0402]  89.73 132.37 180 top
RG6  1K_1%_4  [R0402]  87.01 132.28 0 top
RG7  *10K_1%_4  [R0402]  32.61 106.24 180 top
RG8  10K_5%_4  [R0402]  32.33 105.2 180 top
RG9  100K_5%_4  [R0402]  17.54 104.29 270 top
RG10  100K_5%_4  [R0402]  18.5 104.28 270 top
RG11  2.2K_5%_4  [R0402]  32.28 104.05 0 top
RG12  10K_1%_4  [R0402]  19.93 103.67 90 top
RG13  10K_5%_4  [R0402]  23.44 103.47 270 top
RG14  10K_5%_4  [R0402]  32.32 103.07 180 top
RG15  *0_5%_4  [R0402]  20.67 102.33 0 top
RG16  *0_5%_2  [R0201]  22.07 102.33 180 top
RG17  10K_5%_4  [R0402]  32.28 102.02 180 top
RG18  10K_5%_4  [R0402]  32.28 101.01 180 top
RG19  10K_5%_4  [R0402]  30.21 100.07 180 top
RG20  10K_5%_4  [R0402]  32.25 99.95 180 top
RG21  10K_5%_4  [R0402]  32.33 98.92 180 top
RG22  100K_5%_4  [R0402]  28.54 98.53 270 top
RG23  100K_5%_4  [R0402]  29.68 98.53 270 top
RG24  10K_1%_4  [R0402]  32.28 97.92 180 top
RG25  *short_0402  [S0402]  25.21 97.39 270 top
RG26  100K_1%_4  [R0402]  32.33 96.9 0 top
RG27  10K_5%_4  [R0402]  32.35 95.85 180 top
RG28  10K_1%_4  [R0402]  27.08 94.78 180 top
RG29  10K_1%_4  [R0402]  27.2 93.82 180 top
RG30  10K_5%_4  [R0402]  28.59 92.5 270 top
RG31  100K_1%_4  [R0402]  32.15 92.75 180 top
RG32  100K_5%_4  [R0402]  17.19 92.85 270 top
RG33  100K_5%_4  [R0402]  22.57 90.91 270 top
RG34  100K_5%_4  [R0402]  23.56 90.9 270 top
RG35  *100K_1%_4  [R0402]  29.99 92.75 0 top
RG36  2.49K_1%_4  [R0402]  76.62 90.57 0 top
RG37  10K_5%_4  [R0402]  32.28 90.34 0 top
RG38  100K_5%_4  [R0402]  17.19 91.01 270 top
RG39  2K_1%_4  [R0402]  27.23 87.88 0 top
RG40  2K_1%_4  [R0402]  25.42 87.86 180 top
RG41  *short_0402  [S0402]  34.31 87.54 0 top
RG42  10K_1%_4  [R0402]  52.79 85.79 270 top
RG43  *short_0402  [S0402]  23.5 86.97 270 top
RG44  *short_0402  [S0402]  32.91 86.66 90 top
RG45  10K_5%_4  [R0402]  20.19 86.38 90 top
RG46  10K_5%_4  [R0402]  23.41 84.88 90 top
RG47  33.2_1%_4  [R0402]  54.63 84.62 90 top
RG48  10K_5%_4  [R0402]  55.75 85.05 90 top
RG49  *10K_1%_4  [R0402]  56.79 84.62 90 top
RG50  10K_1%_4  [R0402]  57.93 84.62 270 top
RG51  *0_5%_4  [R0402]  22.38 84.41 270 top
RG52  100K_1%_4  [R0402]  34.56 84.37 180 top
RG53  100K_1%_4  [R0402]  36.34 84.37 0 top
RG54  *0_5%_4  [R0402]  27.17 84.22 180 top
RG56  *100K_1%_4  [R0402]  38.24 83.63 0 top
RG57  *100K_1%_4  [R0402]  40.03 83.58 0 top
RG58  2.2K_5%_4  [R0402]  23.41 83.1 90 top
RG59  2.2K_5%_4  [R0402]  28.21 81.96 90 top
RG60  10K_1%_4  [R0402]  29.23 81.96 270 top
RG61  10K_1%_4  [R0402]  33.17 81.96 270 top
RG62  33.2_1%_4  [R0402]  46.5 81.83 0 top
RG63  *0_5%_2  [R0201]  41.55 81.66 270 top
RG64  *short_0201  [S0201]  42.32 81.66 270 top
RG66  *0_5%_4  [R0402]  24.02 81.32 270 top
RG67  10K_5%_4  [R0402]  40.61 80.99 270 top
RG68  *0_5%_4  [R0402]  30.75 80.84 0 top
RG69  10K_1%_4  [R0402]  32.53 80.56 0 top
RG70  10K_5%_4  [R0402]  42.14 80.44 0 top
RG71  33.2_1%_4  [R0402]  58.16 79.92 180 top
RG72  10K_5%_4  [R0402]  47.42 79.44 270 top
RG73  *short_0201  [S0201]  32.74 79.49 270 top
RG74  *12.1K_1%_4  [R0402]  27.39 79.48 180 top
RG75  *0_5%_2  [R0201]  33.49 79.48 270 top
RG76  10K_5%_4  [R0402]  58.15 78.91 0 top
RG77  10K_5%_4  [R0402]  39.54 78.78 90 top
RG78  10K_5%_4  [R0402]  44.01 78.71 270 top
RG79  10K_5%_4  [R0402]  33.97 78.45 180 top
RG80  1K_5%_4  [R0402]  27.39 78.4 180 top
RG81  121_1%_4  [R0402]  71.04 149.97 270 bottom
RG82  10K_5%_4  [R0402]  76.89 149.93 0 bottom
RG83  10K_5%_4  [R0402]  25.52 149.83 0 bottom
RG84  121_1%_4  [R0402]  68.37 149.72 270 bottom
RG85  121_1%_4  [R0402]  40.33 149.67 0 bottom
RG86  10K_5%_4  [R0402]  32.55 149.28 90 bottom
RG87  121_1%_4  [R0402]  37.76 149.19 270 bottom
RG88  10K_5%_4  [R0402]  47.21 148.63 270 bottom
RG89  121_1%_4  [R0402]  40.28 148.02 90 bottom
RG90  121_1%_4  [R0402]  68.34 148 90 bottom
RG91  10K_5%_4  [R0402]  85.03 147.92 270 bottom
RG92  121_1%_4  [R0402]  71.01 147.76 90 bottom
RG93  10K_5%_4  [R0402]  53.82 147.74 180 bottom
RG94  121_1%_4  [R0402]  37.76 147.44 90 bottom
RG95  10K_5%_4  [R0402]  63.41 147.22 0 bottom
RG96  *931_1%_4  [R0402]  24.15 147.11 180 bottom
RG97  10K_5%_4  [R0402]  55.69 146.92 90 bottom
RG98  1K_1%_4  [R0402]  24.66 145.58 270 bottom
RG99  *549_1%_4  [R0402]  23.64 145.58 270 bottom
RG100  10K_5%_4  [R0402]  12.62 135.63 270 bottom
RG101  1K_1%_4  [R0402]  13.99 134.34 180 bottom
RG102  10K_4  [R0402]  91.2 129.33 270 bottom
RG103  10K_5%_4  [R0402]  15.91 127.49 90 bottom
RG104  121_1%_4  [R0402]  15.79 121.8 0 bottom
RG105  10K_4  [R0402]  90.89 121.72 180 bottom
RG106  121_1%_4  [R0402]  18.63 121.6 180 bottom
RG107  1K_1%_4  [R0402]  66.26 120.16 180 bottom
RG108  121_1%_4  [R0402]  18.53 119.8 180 bottom
RG109  121_1%_4  [R0402]  15.68 119.78 0 bottom
RG110  40.2_1%_4  [R0402]  65.76 119.2 180 bottom
RG111  40.2_1%_4  [R0402]  65.74 118.23 180 bottom
RG112  40.2_1%_4  [R0402]  67.05 117.18 0 bottom
RG113  121_1%_4  [R0402]  92.76 115.85 180 bottom
RG114  10K_5%_4  [R0402]  18.56 113.93 270 bottom
RG115  121_1%_4  [R0402]  96.28 112.88 180 bottom
RG116  121_1%_4  [R0402]  93.83 112.53 180 bottom
RG117  121_1%_4  [R0402]  91.95 112.51 0 bottom
RG118  *549_1%_4  [R0402]  13.67 107.15 90 bottom
RG119  10K_5%_4  [R0402]  15.39 107.1 0 bottom
RG120  10K_5%_4  [R0402]  41.38 106.91 0 bottom
RG121  *51_1%_4  [R0402]  38.65 106.83 0 bottom
RG122  10K_4  [R0402]  93.87 106.55 0 bottom
RG123  *51_1%_4  [R0402]  40.02 106.41 90 bottom
RG124  2.21K_1%_4  [R0402]  23.6 106.17 270 bottom
RG125  10K_5%_4  [R0402]  18.15 106.16 0 bottom
RG126  *931_1%_4  [R0402]  16.71 105.62 270 bottom
RG127  10K_5%_4  [R0402]  42.11 105.05 270 bottom
RG128  2K_1%_4  [R0402]  10.42 104.84 0 bottom
RG129  *0_5%_4  [R0402]  24.3 104.82 180 bottom
RG130  10K_5%_4  [R0402]  12.33 103.72 180 bottom
RG131  2.2K_5%_4  [R0402]  24.25 102.76 180 bottom
RG132  2.2K_5%_4  [R0402]  24.28 103.85 180 bottom
RG133  10K_1%_4  [R0402]  12.35 102.63 0 bottom
RG134  *0_5%_4  [R0402]  27.7 101.79 180 bottom
RG135  2K_1%_4  [R0402]  11.29 101.57 0 bottom
RG136  100K_5%_4  [R0402]  38.98 101.57 90 bottom
RG137  1K_1%_4  [R0402]  40.5 101.2 180 bottom
RG138  2K_1%_4  [R0402]  26.17 100.84 270 bottom
RG139  *0_5%_4  [R0402]  18.9 101.53 90 bottom
RG140  2K_1%_4  [R0402]  27.61 100.47 180 bottom
RG141  *short_0402  [S0402]  57.04 99.81 90 bottom
RG142  10K_4  [R0402]  90.9 99.33 0 bottom
RG143  *100K_1%_4  [R0402]  15.52 99.27 0 bottom
RG144  1K_5%_4  [R0402]  50.26 98.34 0 bottom
RG145  GSYN@100K_1%_4  [R0402]  23.85 97.83 90 top
RG146  *NGSYN@100K_1%_4  [R0402]  25.19 98.95 0 top
RG147  100K_1%_4  [R0402]  16.66 98.21 0 bottom
RG148  1K_5%_4  [R0402]  48.25 98.14 270 bottom
RG149  100K_1%_4  [R0402]  44.71 98.04 0 bottom
RG150  100K_1%_4  [R0402]  42.16 97.78 90 bottom
RG151  10K_5%_4  [R0402]  38.37 97.7 180 bottom
RG152  1K_5%_4  [R0402]  52.75 97.33 270 bottom
RG153  *100K_1%_4  [R0402]  28.59 90.72 270 top
RG154  100K_1%_4  [R0402]  29.99 90.34 0 top
RG155  *short_0402  [S0402]  16.76 96.9 180 bottom
RG156  100K_1%_4  [R0402]  44.73 96.87 0 bottom
RG157  2.49K_1%_4  [R0402]  40.13 96.7 270 bottom
RG158  SAM@100K_1%_4  [R0402]  31.77 91.35 180 top
RG159  *MIC@100K_1%_4  [R0402]  29.99 91.35 0 top
RG160  *100K_5%_4  [R0402]  37.3 95.28 90 bottom
RG161  100K_1%_4  [R0402]  25.93 97.58 0 bottom
RG162  *100K_1%_4  [R0402]  24.91 98.72 0 bottom
RG163  10K_5%_4  [R0402]  40.42 95.01 0 bottom
RG164  10K_1%_4  [R0402]  52.47 94.5 90 bottom
RG165  2.49K_1%_4  [R0402]  24.33 96.28 0 bottom
RG166  100K_1%_4  [R0402]  45.48 93.72 0 bottom
RG167  100K_1%_4  [R0402]  40.29 93.54 90 bottom
RG168  100K_1%_4  [R0402]  42.35 93.16 90 bottom
RG169  100K_1%_4  [R0402]  41.36 93.16 90 bottom
RG170  100K_1%_4  [R0402]  45.48 92.75 0 bottom
RG171  100K_1%_4  [R0402]  17.87 91.48 180 bottom
RG172  *100K_1%_4  [R0402]  15.82 90.63 270 bottom
RG173  *100K_1%_4  [R0402]  17.19 90.36 180 bottom
RG174  100K_1%_4  [R0402]  15.81 89.28 180 bottom
RG175  *0_5%_2  [R0201]  11.86 86.12 90 bottom
RG176  *short_0201  [S0201]  11.12 86.12 90 bottom
RG177  100K_5%_4  [R0402]  46.75 84.12 180 bottom
RG178  10K_5%_4  [R0402]  32.84 83.99 0 bottom
RG179  *0_5%_4  [R0402]  38.99 83.93 270 bottom
RG180  *0_5%_4  [R0402]  38.02 83.91 270 bottom
RG181  *short_0402  [S0402]  51.07 83.1 180 bottom
RG182  *short_0402  [S0402]  46.75 83.1 180 bottom
RG183  10K_5%_4  [R0402]  35.05 82.54 180 bottom
RG184  *1.21K_1%_4  [R0402]  32.09 82.37 270 bottom
RG185  10K_5%_4  [R0402]  46.75 82.11 0 bottom
RG186  *0_5%_2  [R0201]  36.72 81.46 270 bottom
RG187  *0_5%_2  [R0201]  37.73 80.94 0 bottom
RG188  10K_5%_4  [R0402]  29.26 79.56 180 bottom
RG189  1K_5%_4  [R0402]  33.55 79.14 270 bottom
RG190  *10K_5%_4  [R0402]  41.62 77.92 0 bottom
RG191  *short_0201  [S0201]  45.87 77.89 0 bottom
RG192  *0_5%_2  [R0201]  44.85 77.89 0 bottom
RG193  *short_0201  [S0201]  35.55 77.75 270 bottom
RG194  *0_5%_2  [R0201]  34.79 77.75 270 bottom
RG195  *short_0402  [S0402]  22.33 100.52 90 bottom
RG196  10K_1%_4  [R0402]  186.97 42.06 90 top
RV1  *TVM0G5R5M220R_22p  [R0402]  71.01 164.51 90 top
RV2  *TVM0G5R5M220R_22p  [R0402]  72.46 165.93 180 bottom
RV3  *TVM0G5R5M220R_22p  [R0402]  71.1 165.9 90 bottom
RV4  *TVM0G5R5M220R_22p  [R0402]  70.14 165.88 90 bottom
S1  -  [CLIP-39X35-100X18-3P]  76.9 158.2 0 top
S2  -  [CLIP-39X35-100X18-3P]  26.6 158.2 0 top
S3  -  [CLIP-39X35-100X18-3P]  20.9 89 0 top
S4  -  [CLIP-39X35-100X18-3P]  18.4 143.7 0 top
S5  -  [CLIP-39X35-100X18-3P]  6.15 137 90 top
S6  -  [CLIP-39X35-100X18-3P]  111.9 136 0 top
S7  -  [CLIP-39X35-100X18-3P]  161.9 136 0 top
S8  -  [CLIP-39X35-100X18-3P]  173.15 126.5 90 top
S9  -  [CLIP-39X35-100X18-3P]  6.15 111.8 90 top
S10  -  [CLIP-39X35-100X18-3P]  173.15 99.5 90 top
S11  -  [CLIP-39X35-100X18-3P]  15.13 96.5 90 top
S12  -  [CLIP-39X35-100X18-3P]  86.89 146.5 90 top
S13  -  [CLIP-39X35-100X18-3P]  158.36 89 0 top
S14  -  [CLIP-39X35-100X18-3P]  77.4 89 0 top
S15  -  [CLIP-39X35-100X18-3P]  115.36 89 0 top
SPAD2  *SPAD-C315  [SPAD-C315]  195.8 13.88 0 top
SPAD3  *PAD-ZGE-1  [PAD-ZGE-1]  51.29 158.18 0 top
SW1  *T3AL-23S-Q-T/R  [SW-T3AL-23-Q-TR-4P]  87.14 37.63 90 top
SW2  TME-533B-Q-T/R  [SW-TME-533B-Q-TR-6P]  186.4 61.4 180 bottom
T1  *TP  [TP2050]  90.07 150.4 180 top
T2  *TP  [TP2050]  95.4 153.36 180 top
T3  *TP  [TP2050]  89.88 151.65 180 top
T4  *TP  [TP2050]  246.96 48.96 270 top
T5  *TP  [TP2050]  247.03 47.57 270 top
T6  *TP  [TP2050]  245.26 43.09 270 top
T7  *TP  [TP2050]  245.26 41.82 270 top
T8  *TP  [TP2050]  94.31 156.82 0 bottom
T9  *TP  [TP2050]  92.76 155.79 0 bottom
T10  *TP  [TP2050]  178.58 96.13 180 bottom
T11  *TP  [TP2050]  177.13 95.77 180 bottom
T12  *TP  [TP2050]  172.84 94.2 180 bottom
T13  *TP  [TP2050]  172.58 92.93 180 bottom
T14  *TP  [TP2050]  181.5 92.37 180 bottom
T15  *TP  [TP2050]  243.05 51.76 270 bottom
T16  *TP  [TP2075]  240.43 10.71 180 bottom
TP1  *TP  [TP2650]  129.05 141.44 180 top
TP2  *TP  [TP2650]  129.05 140.17 180 top
TP3  *TP  [TP2050]  115.66 129.45 0 top
TP4  *  [TP2650]  166.41 128.79 0 top
TP5  *  [TP2650]  166.08 127.42 0 top
TP6  *  [TP2650]  166.24 121.5 180 top
TP7  *  [TP2650]  163.47 120.77 0 top
TP8  *  [TP2650]  164.48 119.42 0 top
TP9  *PAD  [TP2650]  164.42 109.99 0 top
TP10  *  [TP2650]  164.11 107.26 0 top
TP11  *  [TP2650]  165.35 105.98 0 top
TP12  *TP  [TP2050]  31.44 95.01 0 top
TP14  *TP  [TP2075]  22.24 60.24 0 top
TP15  *TP  [TP2075]  31.9 59.48 0 top
TP16  *TP  [TP2075]  41.55 59.48 0 top
TP17  *TP  [TP2075]  51.2 59.48 0 top
TP18  *TP  [TP2075]  60.85 59.48 0 top
TP19  *TP  [TP2075]  70.5 59.48 0 top
TP20  *TP  [TP2075]  80.16 59.48 0 top
TP21  *TP  [TP2075]  89.81 59.48 0 top
TP22  *TP  [TP2050]  269.38 58.74 0 top
TP23  *TP  [TP2075]  99.61 52.72 0 top
TP26  *  [TP2650]  233.73 42.76 0 top
TP27  *  [TP2650]  232.79 41.28 0 top
TP28  *TP  [TP2050]  234.21 41.01 0 top
TP29  *TP  [TP2050]  260.14 37.81 270 top
TP31  *TP  [TP2050]  256.18 30.9 270 top
TP32  *TP  [TP2050]  257.45 30.9 270 top
TP33  *TP  [TP2050]  256.81 29.76 270 top
TP34  *TP  [TP2050]  258.34 29.63 270 top
TP35  *TP  [TP2050]  259.76 29.61 270 top
TP36  *TP  [TP2050]  275.61 29 180 top
TP37  *TP  [TP2050]  277.64 29 180 top
TP38  *TP  [TP2050]  64.08 28.54 180 top
TP39  *TP  [TP2050]  65.33 27.71 180 top
TP40  *TP  [TP2050]  274.64 27.8 180 top
TP41  *TP  [TP2050]  275.99 27.73 180 top
TP42  *TP  [TP2050]  277.26 27.73 180 top
TP43  *TP  [TP2050]  275.99 26.46 180 top
TP44  *TP  [TP2050]  277.26 26.46 180 top
TP45  *TP  [TP2050]  274.72 26.52 180 top
TP46  *TP  [TP2050]  247.8 25.31 270 top
TP47  *TP  [TP2050]  276.62 25.31 180 top
TP48  *  [TP2650]  199.69 24.17 0 top
TP50  *TP  [TP2050]  248.3 18.46 270 top
TP51  *TP  [TP2050]  258.64 18.14 270 top
TP52  *TP  [TP2050]  220.09 17.97 0 top
TP53  *TP  [TP2050]  209.98 14.82 90 top
TP54  *TP  [TP2050]  208 16.28 180 top
TP55  *TP  [TP2050]  210.38 12.91 90 top
TP56  *TP  [TP2050]  260.88 13.88 270 top
TP57  *TP  [TP2050]  210.02 18.08 0 top
TP58  *TP  [TP2050]  259.86 13.12 270 top
TP59  *TP  [TP2050]  270.43 12.78 0 top
TP60  *TP  [TP2050]  270.46 11.5 0 top
TP61  *TP  [TP2650]  172.36 124.5 180 bottom
TP62  *TP  [TP2650]  172.36 122.72 180 bottom
TP63  *TP  [TP2050]  124.94 112.77 180 bottom
TP64  *TP  [TP2050]  127.41 113.27 180 bottom
TP66  *TP  [TP2050]  268.8 57.14 90 bottom
TP69  *TP  [TP2050]  204.92 42.84 270 bottom
TP70  *TP  [TP2050]  206.19 42.68 270 bottom
TP71  *TP  [TP2050]  209.34 42.08 180 bottom
TP72  *TP  [TP2050]  198.86 41.1 180 bottom
TP73  *TP  [TP2050]  201.36 41.71 90 bottom
TP74  *TP  [TP2050]  200.09 41.64 90 bottom
TP75  *TP  [TP2050]  210.23 41.14 180 bottom
TP76  *TP  [TP2050]  198.86 39.83 180 bottom
TP77  *TP  [TP2050]  249.88 37.95 180 bottom
TP78  *TP  [TP2050]  278.91 37.25 90 bottom
TP79  *TP  [TP2050]  280.33 37.05 90 bottom
TP80  *TP  [TP2050]  273.72 36.71 0 bottom
TP81  *TP  [TP2050]  275.06 36.52 0 bottom
TP82  *TP  [TP2050]  271.46 36.81 180 bottom
TP83  *TP  [TP2050]  278.81 35.95 90 bottom
TP84  *TP  [TP2050]  280.69 35.83 90 bottom
TP85  *TP  [TP2050]  273.32 35.35 180 bottom
TP86  *TP  [TP2050]  272.05 35.35 180 bottom
TP87  *TP  [TP2050]  225.87 35.3 180 bottom
TP89  *TP  [TP2050]  279.04 34.59 90 bottom
TP90  *TP  [TP2050]  280.69 34.46 90 bottom
TP91  *TP  [TP2050]  48.03 34.78 90 bottom
TP92  *TP  [TP2050]  273.32 34.08 180 bottom
TP93  *TP  [TP2050]  272.05 34.08 180 bottom
TP94  *TP  [TP2050]  245.76 33.06 180 bottom
TP95  *TP  [TP2050]  202.34 32.97 180 bottom
TP96  *TP  [TP2050]  272.05 32.81 180 bottom
TP97  *TP  [TP2050]  220.9 32.34 180 bottom
TP98  *TP  [TP2050]  246.22 31.66 180 bottom
TP99  *  [TP2650]  204.51 31.54 180 bottom
TP100  *TP  [TP2050]  201.41 31.19 180 bottom
TP101  *TP  [TP2650]  226.46 30.78 180 bottom
TP102  *TP  [TP2050]  221.13 30.31 180 bottom
TP103  *TP  [TP2050]  65.74 27.54 270 bottom
TP104  *TP  [TP2050]  227.5 26.8 180 bottom
TP105  *  [TP2650]  223.72 25.9 180 bottom
TP106  *TP  [TP2050]  248.76 25.42 270 bottom
TP107  *TP  [TP2050]  214.63 24.55 180 bottom
TP108  *TP  [TP2050]  216.1 24.54 180 bottom
TP109  *TP  [TP2050]  251.12 24.2 270 bottom
TP110  *TP  [TP2050]  221.64 23.48 180 bottom
TP111  *  [TP2650]  215.29 23.43 180 bottom
TP112  *  [TP2650]  222.91 23.23 180 bottom
TP113  *TP  [TP2650]  224.24 23.11 180 bottom
TP114  *TP  [TP2050]  262.53 22.39 270 bottom
TP115  *TP  [TP2050]  248.08 22.39 270 bottom
TP116  *TP  [TP2050]  252.37 22.14 90 bottom
TP118  *  [TP2650]  220.57 21.47 180 bottom
TP119  *TP  [TP2650]  224 21.14 180 bottom
TP120  *TP  [TP2050]  83.71 20.51 0 bottom
TP122  *  [TP2650]  226.59 16.55 180 bottom
TP123  *TP  [TP2050]  200.17 11.6 90 bottom
TP124  *TP  [TP2050]  198.9 11.6 90 bottom
TP125  *  [TP2650]  200.39 27.77 180 bottom
TP126  *  [TP2650]  199.88 29.3 180 bottom
TP127  *  [TP2650]  204.45 28.15 180 bottom
TP128  *  [TP2650]  47.96 38.17 180 bottom
TP129  *  [TP2650]  47.55 40.9 180 bottom
TP130  *  [TP2650]  46.13 40.95 180 bottom
TP131  *TP  [TP2050]  84.21 18.34 0 top
TP132  *TP  [TP2050]  84.71 20.33 0 top
TPG1  *PAD  [TP2650]  32.91 93.84 0 top
TPG2  *PAD  [TP2650]  31.08 93.69 0 top
TPG3  *PAD  [TP2650]  48.97 86.03 0 top
TPG4  *PAD  [TP2650]  50.25 86 0 top
TPG5  *PAD  [TP2650]  51.78 86.01 0 top
TPG6  *PAD  [TP2650]  47.83 85.42 0 top
TPG7  *  [TP2675]  53.71 84.09 180 top
TPG8  *  [TP2675]  57.93 83.1 0 top
TPG9  *  [TP2675]  47.9 81.7 180 top
TPG10  *  [TP2675]  56.66 78.91 180 top
TPG11  *  [TP2650]  61.08 152.31 270 bottom
TPG12  *  [TP2650]  31.38 152.02 270 bottom
TPG13  *  [TP2650]  78.36 151.91 270 bottom
TPG14  *  [TP2650]  46.46 151.52 270 bottom
TPG15  *  [TP2650]  48.73 151.32 270 bottom
TPG16  *  [TP2650]  32.38 151.02 270 bottom
TPG17  *  [TP2650]  75.55 150.78 270 bottom
TPG18  *  [TP2650]  47.41 150.47 270 bottom
TPG19  *  [TP2650]  31.31 150.1 270 bottom
TPG20  *  [TP2650]  61.96 149.61 270 bottom
TPG21  *  [TP2650]  63.2 148.92 270 bottom
TPG22  *  [TP2650]  78.22 148.7 270 bottom
TPG23  *  [TP2650]  80.04 147.09 270 bottom
TPG24  *  [TP2650]  48.13 146.78 270 bottom
TPG25  *  [TP2650]  31.58 146.7 270 bottom
TPG26  *  [TP2650]  75.96 146.45 270 bottom
TPG27  *  [TP2650]  30.05 146.37 270 bottom
TPG28  *  [TP2650]  61.68 146.21 270 bottom
TPG29  *  [TP2650]  79.05 146.21 270 bottom
TPG30  *  [TP2650]  45.42 146.14 270 bottom
TPG31  *  [TP2650]  64.29 146.07 270 bottom
TPG32  *  [TP2650]  47.99 145 270 bottom
TPG33  *  [TP2650]  61.71 144.85 270 bottom
TPG34  *  [TP2650]  33.47 144.54 270 bottom
TPG35  *  [TP2650]  16.2 129.91 0 bottom
TPG36  *PAD  [TP2650]  58.4 129.39 270 bottom
TPG37  *PAD  [TP2650]  43.62 129.26 270 bottom
TPG38  *  [TP2650]  21.01 129.02 0 bottom
TPG39  *PAD  [TP2650]  57.2 128.97 270 bottom
TPG40  *  [TP2650]  19.66 128.91 0 bottom
TPG41  *  [TP2650]  15.49 128.84 0 bottom
TPG42  *PAD  [TP2650]  76.75 129.86 270 top
TPG43  *  [TP2650]  20.25 127.67 0 bottom
TPG44  *  [TP2650]  14.42 127.65 0 bottom
TPG45  *  [TP2650]  90.99 124.28 180 bottom
TPG46  *  [TP2650]  92.08 123.37 180 bottom
TPG47  *  [TP2650]  90.38 122.79 180 bottom
TPG48  *PAD  [TP2650]  36.51 122.32 270 bottom
TPG49  *  [TP2650]  95.17 122.32 180 bottom
TPG50  *  [TP2650]  89.4 121.22 180 bottom
TPG51  *  [TP2650]  94.81 120.84 180 bottom
TPG52  *PAD  [TP2650]  73.19 116.47 180 bottom
TPG53  *  [TP2650]  14.84 114.62 0 bottom
TPG54  *  [TP2650]  20.64 114.46 0 bottom
TPG55  *  [TP2650]  13.23 113.4 0 bottom
TPG56  *  [TP2650]  20.54 113.08 0 bottom
TPG57  *  [TP2650]  19.29 112.64 0 bottom
TPG58  *  [TP2650]  16.63 112.41 0 bottom
TPG59  *PAD  [TP2650]  36.54 111.36 180 bottom
TPG60  *  [TP2650]  89.21 106.64 180 bottom
TPG61  *  [TP2650]  95.39 106.54 180 bottom
TPG62  *  [TP2650]  94.11 105.51 180 bottom
TPG63  *  [TP2650]  89.2 104.98 180 bottom
TPG64  *  [TP2650]  90.67 104.97 180 bottom
TPG65  *  [TP2650]  95.04 104.45 180 bottom
TPG66  *PAD  [TP2650]  72.54 102.91 180 bottom
TPG67  *PAD  [TP2650]  40.78 98.56 180 bottom
TPG68  *  [TP2650]  42.2 96.16 180 bottom
TPG69  *PAD  [TP2650]  52.34 93.13 180 bottom
U1  TC7SH08FU(F)  [SOT353-1-2_125-65-5P]  73.42 164.99 180 top
U2  *G5245AT11U  [SOT23-5-2_8-95-5P-G708]  69.46 160.9 180 top
U3  CPU_CFL-H_1440P  [BGA1440-INTEL-CFL-H]  139.9 118.2 0 top
U4  6K5130UA0  [QFN32-4X4-4-33P-MT6605N]  10.31 74.08 0 top
U5  TS3DS10224RUKR  [QFN20-3X3-4-26P-0_8H]  282.09 51.48 90 top
U6  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  210.46 51.1 0 top
U7  DSL6540-SLL44  [BGA337-INTEL-DSL6540]  263.04 51.1 180 top
U8  SLGC55544CVTR  [QFN16-3X3-5-17P-SLGC55544C]  18.33 49.65 90 top
U9  W25Q80DVSSIG  [SOIC8-7_9-1_27-2_16H]  251.48 47.84 180 top
U10  TUSB546-DCIRNQR  [QFN40-6X4-4-49P-SMT]  243.22 47.41 180 top
U11  SLGC55544CVTR  [QFN16-3X3-5-17P-SLGC55544C]  17.09 43.33 90 top
U12  *W25Q80DVSSIG  [SOIC8-7_9-1_27-2_16H]  239.67 37.51 270 top
U13  TPS65987SDHRSHR  [QFN56-7X7-4-78P]  249.19 34.97 0 top
U14  PCH_CFL-H_874P  [BGA874-INTEL-CNL-PCH-H]  215.4 34.5 270 top
U15  ANX7490QN-CB-R  [QFN40-5X5-4-41P-92HD99]  261.64 33.57 90 top
U16  ANX7428QN-AB-R  [QFN48-6X6-4-49P-0_9H]  275.48 33.44 270 top
U17  ALC1220-VA3-CG  [QFN56-7X7-4-57P-ALC2865-CG]  31.01 29.76 180 top
U18  IT8987E/CX  [LQFP128-16X16-4-1_6H]  77.23 27.22 270 top
U19  W25Q128JVSIQ  [SOIC8-7_9-1_27-2_16H]  238.91 26.92 0 top
U20  ALC1001-VB-CGT  [DFN12-3X3-45-13P-0_95H]  43.83 25.95 90 top
U21  PS8817QFN54GTR-A2  [QFN54-8X4_2-4-55P]  58.06 25.82 90 top
U22  ALC1001-VB-CGT  [DFN12-3X3-45-13P-0_95H]  13.23 23.79 270 top
U23  CYPD4136-24LQXQT  [QFN24-4X4-5-25P-CYPD4136]  250.72 21.63 270 top
U24  ANX7440QN-CB-R  [QFN60-7X7-4-61P-0_9H]  263.54 18.84 90 top
U25  ALC1001-VB-CGT  [DFN12-3X3-45-13P-0_95H]  23.35 18.71 0 top
U26  SLGC55544CVTR  [QFN16-3X3-5-17P-SLGC55544C]  279.85 18.54 270 top
U27  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  239.54 18.33 180 top
U28  AP21510FM-7  [DFN2018-6-1_8X2-5-7P]  248.05 14.9 180 top
U29  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  250.46 12.61 180 top
U30  PS8811QFN36GTR2-A2  [QFN36-4_2X4_2-4-37P]  276.27 12.15 270 top
U31  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  208.61 10.38 0 top
U32  *M74VHC1GT08DFT2G  [SC70-2_1-65-5P]  250.46 10.2 180 top
U33  *AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  63.77 164 90 bottom
U34  PS8209AQFN48GTR2-A2  [QFN48-6X6-4-49P-PS8409]  52.22 163.36 0 bottom
U35  G5250Q1T73U  [SOT23-2_38-95-3P]  71.24 161.71 180 bottom
U36  UP7553PMA5-15  [SOT23-5-2_8-95-5P-G708]  98.11 161.31 270 bottom
U37  *AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  63.9 160.82 90 bottom
U38  G781P8  [MSOP8-4_9-65]  23.39 154.73 0 bottom
U39  TUSB546-DCIRNQR  [QFN40-6X4-4-49P-SMT]  92.22 152.7 270 bottom
U40  SY6288C20AAC  [SOT23-2_85-95-5P]  174.39 104.82 90 bottom
U41  TUSB546-DCI  [QFN40-6X4-4-49P-SMT]  176.93 92.5 270 bottom
U42  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  232.31 22.49 0 bottom
U43  PS8527BTQFN20GTR2-A2  [TQFN20-4X4-5-25P]  45.48 21.76 270 bottom
U44  TPM@NPCT750AAAYX  [QFN32-5X5-5-33P-0_85H]  240.18 14.77 180 bottom
UG1  N18E-G3-ES-A1  [BGA2228-NVIDIA-N18E-G3]  54.8 111 270 top
UG2  MX25U8033EM1I-12G  [SOIC8-6-1_27-AT25M02]  52.38 80.95 90 top
UG3  74LVC1G32GW  [SOT353-2_1-65-5P-1_1H]  30.24 78.91 180 top
UG4  AOZ1335DI_2  [SON8-3X3-65-7P]  21.27 105.49 90 bottom
UG5  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  8.73 86.55 180 bottom
UG6  74LVC1G32GW  [SOT353-2_1-65-5P-1_1H]  40.88 82.87 270 bottom
UG7  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  48.91 82.85 270 bottom
UG8  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  35.35 80.13 90 bottom
UG9  74LVC1G32GW  [SOT353-2_1-65-5P-1_1H]  43.07 79.82 180 bottom
UG10  74LVC1G32GW  [SOT353-2_1-65-5P-1_1H]  51.33 79.44 180 bottom
UG11  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  38.63 79.32 0 bottom
VRAM1  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  31.83 148.53 270 top
VRAM2  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  47.14 148.53 90 top
VRAM3  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  62.45 148.53 270 top
VRAM4  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  77.75 148.53 90 top
VRAM5  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  17.26 128.45 180 top
VRAM6  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  92.39 121.81 180 top
VRAM7  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  17.26 113.91 0 top
VRAM8  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  92.39 105.81 0 top
Y1  25MHZ/30ppm  [XTL-2_05X1_65-1_4X1_1-0_6H]  267.23 41.19 180 top
Y2  24MHZ/20ppm  [XTL-2X1_6-1_35X1_05]  256.56 39.59 270 top
Y3  24MHZ/20ppm  [XTL-2X1_6-1_35X1_05]  258.34 27.6 180 top
Y4  32.768KHZ/20ppm  [XTL-3_2X1_5-2_5-SMT]  233.17 25.59 270 top
Y5  24MHZ/+-20PPM  [XTL-2X1_6-1_35X1_05]  199.91 45.6 270 bottom
YG1  27MHZ/10ppm  [XTL-3_2X2_5-2_2X1_6-0_9H]  30.76 85.99 90 top

## Library data of the parts
C1-C5 C8-C423 C425-C458 C460-C812 C814-C825 C827-C837 C839-C914 C917 C919-C921 C923-C938 C942 C943 C945 CG1-CG574 CG576-CG900 EC1 EC2 EC7 EC8 EC11 EC12 PC2 PC4-PC9 PC11 PC12 PC14-PC16 PC18 PC19 PC22 PC23 PC25 PC26 PC28-PC52 PC54-PC71 PC74-PC76 PC78-PC87 PC93 PC98-PC101 PC106 PC111 PC114 PC116 PC118 PC119 PC122 PC124 PC136-PC157 PC159-PC167 PC169 PC171-PC179 PC181 PC182 PC184 PC185 PC187 PC188 PC193 PC194 PC197 PC198 PC202-PC206 PC208 PC210-PC213 PC215 PC217 PC218 PC220 PC221 PC223 PC225-PC230 PC238 PC239 PC242 PC243 PC245-PC247 PC249 PC251 PC252 PC260 PC261 PC270 PC272 PC278-PC280 PC287 PC289 PC295-PC300 PC302-PC305 PC326-PC329 PC334-PC336 PC353-PC355 PC357-PC386 PC388-PC408 PC411 PC412 PC414-PC426 PC428 PC429 PC432 PC437-PC442 PC447 PC449 = CAP_NON-POL_BGM
C424 CG575 CG901-CG903 PC13 PC20 PC125-PC128 PC201 PC235 PC236 PC244 PC248 PC320 PC324 PC325 PC331 PC341-PC352 = CAP_POL_BGM
C459 C813 C826 C838 C915 C916 C918 C922 C939-C941 PC1 PC3 PC10 PC17 PC21 PC24 PC27 PC53 PC72 PC73 PC77 PC88-PC92 PC94-PC97 PC102-PC105 PC107-PC110 PC112 PC113 PC115 PC117 PC120 PC121 PC123 PC129-PC135 PC158 PC168 PC170 PC180 PC183 PC186 PC189-PC192 PC195 PC196 PC199 PC200 PC207 PC209 PC214 PC216 PC219 PC222 PC224 PC231-PC234 PC237 PC240 PC241 PC250 PC253-PC259 PC262-PC267 PC269 PC271 PC273-PC277 PC281 PC282 PC284-PC286 PC288 PC290-PC294 PC301 PC306-PC319 PC321 PC330 PC337-PC340 PC356 PC387 PC409 PC410 PC413 PC427 PC430 PC431 PC433-PC436 PC443-PC445 PC448 = CAP NON-POL_BGM
CN1 = HDMI_19P_4fix_BGM
CN2 = DP20P_4fix_V2_BGM
CN3 = USB3_1_24P_8fix_BGM
CN4 = USB3_1_24P_8F_V2_BGM
CN5 = CON30X1_9
CN6 = Header_2P_V2_BGM
CN7 = USB3_9P_4fix_V2_BGM
CN8 = FFCFPC_18P_V2_BGM
CN9 = FFCFPC_8P_BGM
CN10 = Housing_40P_6fixP_BGM
CN11 CN12 = HEADER_4P_2F_BGM
CN13 = Header_4P_50281-00401-001_BGM
CN14 = HEADER_8P_2fix_BGM
CN15 CN18 = NGFF_79P_MKEY_NAME_BGM
CN16 = NGFF_79P_EKEY_NAME_BGM
CN17 = FFCFPC_45P_R_V2_BGM
CN19 = FFCFPC_44P_2F_BGM
CN20 = Housing_20P_FIX6P_BGM
CN21 = HEADER_6P_2F_BGM
CN22 = HEADER_2P_2F_BGM
D1-D13 D16 D17 D19-D31 D34 D39-D43 D45-D51 D53-D57 D60-D76 D78 D80-D87 D89-D93 D95-D98 D100-D105 D107-D111 = TVS_DIODE_BGM
D14 D15 D18 D32 D33 D35-D38 D44 D52 D59 D88 D106 DG1-DG3 DG5-DG7 PD3 PD7 = Schottky_DIODE_BGM
D58 PD6 = BAT54C_BGM
D77 D79 PD2 = DIODE_BGM
D94 D99 = TVS_DIODE_UNI_BGM
D112 = PESD5V0X2UM_BGM
DG4 = BAT54A_BGM
EC3-EC6 EC9 EC10 = C
ESD1 U33 U37 = AZ1045-04F_BGM
HOLE1 HOLE2 HOLE4 HOLE5 HOLE12 HOLE13 HOLE16 HOLE17 HOLE19 HOLE24 HOLE26 HOLE28 HOLE29 = 3x2_2.1
HOLE3 HOLE6-HOLE11 HOLE14 HOLE15 HOLE18 HOLE20-HOLE23 HOLE25 HOLE27 HOLE30 HOLE31 SPAD2 = 3x2_3.1
J1 = OPEN
JDIM1 JDIM3 = DDR3_2
JDIM2 JDIM4 = DDR3_3
L1 L5 L17 L28 PL1-PL10 PL19 PL21 PL24 PL25 = INDUCTOR_BGM
L2-L4 L7-L16 L18-L27 L29-L31 L33 L35-L37 L39 L40 LG1 LG2 R977 = BEAD_BGM
L6 L32 L34 = BW_BGM
LED1 = LED_2P_BGM
PC268 PC283 PC322 PC323 PC332 PC333 = CAP POL_BGM
PD1 PD4 PD5 = ZENER_DIODE_BGM
PJ1 = DCJACK_11P_BGM
PJ22 = Header_10P_2fix_BGM
PL11-PL18 = INDUCTOR_V01_BGM
PL20 PL22 PL23 = TEMPOBJ_0
PQ1 PQ8 PQ9 PQ11 PQ14-PQ16 PQ18 PQ19 PQ21 PQ25 PQ26 PQ28 PQ29 PQ31 PQ39-PQ42 PQ44 PQ48 PQ50 PQ51 PQ54 PQ55 PQ57 PQ59 Q2-Q4 Q6 Q11-Q13 Q15 Q17 Q20 Q22 Q26-Q29 Q32 Q34 Q37 Q39-Q44 Q49 Q56 Q58 Q64 Q68 Q69 Q72 Q73 Q77 Q78 Q81 QG1-QG3 QG5 QG9 QG13 QG15 QG17 QG19 QG21 QG22 QG24 QG25 = MOS-N_3P_ESD_BGM
PQ2 PQ3 PQ6 PQ7 = MOS-N-Dual_10P_BGM
PQ4 PQ5 PQ32 = MOS-N_8P_ESD_BGM
PQ10 PQ13 PQ20 PQ46 PQ56 = MOS-N_3P_BGM
PQ12 = MOS_P_DUAL_EMF20B02V_V1_BGM
PQ17 PQ24 PQ30 = MOS-N_8P_BGM
PQ22 PQ23 PQ45 PQ49 PQ58 Q7 Q14 Q53 Q54 Q80 = DTC144EU_BGM
PQ27 = MOS-N_8P_SCH_BGM
PQ33 PQ38 Q5 Q10 Q25 Q59 Q67 QG4 QG6-QG8 = NPN_BGM
PQ34-PQ37 = MOS-N-Dual_9P_BGM
PQ43 = MOS-N_3P_ESD_123_1_BGM
PQ47 = MOS-P_3P_ESD_BGM
PQ52 PQ53 Q23 Q31 Q36 Q71 Q75 Q76 Q79 = MOS-P_3P_BGM
PR1-PR4 PR6-PR16 PR18-PR24 PR26-PR34 PR40-PR51 PR56 PR61 PR62 PR68 PR71 PR73-PR77 PR79-PR85 PR87 PR91 PR100-PR102 PR106 PR107 PR109 PR115 PR116 PR118 PR120 PR122 PR123 PR125 PR132-PR135 PR137-PR140 PR142 PR144 PR146 PR147 PR149 PR151-PR154 PR163 PR165-PR178 PR181-PR183 PR186-PR200 PR207-PR224 PR227 PR230 PR233 PR236 PR239 PR242 PR244-PR250 PR256-PR262 PR264-PR270 PR273 PR274 PR276 PR277 PR279-PR281 PR284 PR287 PR289 PR290 PR293 PR301 PR304 PR306 PR308 PR310-PR312 PR315-PR321 PR329-PR337 PR340-PR344 PR349 PR350 PR352-PR354 PR357 PR358 PR360 PR362-PR364 PR366-PR368 PR370 PR372 PR376-PR382 PR384-PR386 PR388 PR389 PR391-PR393 PR398-PR400 PR402 PR405 PR407-PR410 PR413 PR414 PR416 PR418 PR422-PR427 PR429-PR432 PR434 PR435 PR437 PR439-PR441 PR443 PR444 PR447 PR452-PR458 PR460 PR462-PR471 PR473-PR476 PR478 PR481 PR482 PR485-PR493 PR495 PR496 PR499-PR510 PR516-PR519 PR521-PR526 PR528-PR530 PR533-PR547 PR549-PR553 PR555-PR557 PR571-PR574 PR579-PR582 R1 R3 R6 R7 R9-R42 R44-R47 R49-R62 R64-R294 R296-R320 R322-R340 R342-R453 R456 R458-R503 R505-R601 R603-R610 R613-R625 R627-R690 R694-R912 R914-R923 R925-R942 R944-R976 R978-R1014 R1017-R1032 R1034-R1062 R1065-R1144 R1146-R1159 R1161-R1169 RG1-RG54 RG56-RG64 RG66-RG196 = RES_BGM
PR5 PR17 PR25 PR35-PR39 PR52-PR55 PR57-PR60 PR63-PR66 PR69 PR70 PR72 PR86 PR88-PR90 PR92 PR93 PR95 PR103-PR105 PR119 PR121 PR128-PR131 PR136 PR143 PR145 PR150 PR155-PR162 PR179 PR180 PR184 PR185 PR201-PR206 PR225 PR226 PR228 PR229 PR231 PR232 PR234 PR235 PR237 PR238 PR240 PR241 PR251-PR255 PR263 PR275 PR278 PR282 PR283 PR285 PR288 PR291 PR292 PR294 PR295 PR297-PR300 PR305 PR307 PR309 PR313 PR314 PR322-PR328 PR338 PR339 PR345-PR348 PR351 PR355 PR356 PR359 PR361 PR365 PR371 PR373-PR375 PR394 PR395 PR397 PR403 PR404 PR406 PR411 PR412 PR415 PR417 PR428 PR433 PR436 PR438 PR442 PR445 PR446 PR448-PR451 PR459 PR461 PR472 PR477 PR479 PR480 PR484 PR494 PR497 PR498 PR511-PR515 PR520 PR527 PR531 PR532 PR548 PR554 PR560-PR562 PR565-PR570 PR575 PR576 PR578 = SHORTPAD_V01_BGM
PR67 PR271 PR272 PR296 R504 = R_Current_SEN_BGM
PR78 PR114 PR117 = Thermistor_BGM
PR94 PR96-PR99 PR108 PR110-PR113 PR148 PR164 PR243 PR286 PR302 PR303 PR369 PR383 PR390 PR396 PR401 PR419-PR421 PR483 PR563 PR564 R43 R48 R63 = SHORTPAD_BGM
PU1 = RT8816AGQW_BGM
PU2 = NCP81205FMNTXG_52P_BGM
PU3-PU6 PU8 = NCP302045MNTWG_33P_BGM_5
PU7 = MP8858GQ_16P_BGM
PU9 = TMP708_BGM
PU10 = G9336ADJTP1U_BGM
PU11 PU26 PU31 PU32 = AOZ1331DI_BGM
PU12 PU30 = M5671RE1U_BGM
PU13 = G5719CTB1U_BGM
PU14-PU21 = QD9619AQR1_39P_V2_BGM
PU22 = TPS61087DRCR_BGM
PU23 = BQ24780SRUYR_BGM
PU24 = UP9512PQGJ_40P_V2_BGM
PU25 = US5650PQKI_32P_BGM
PU27 = RT8231BGQW_BGM
PU28 = TPS51225RUKR_BGM
PU29 = RT8237CZQW_2_BGM
Q1 Q24 = 2N7002
Q8 Q9 Q16 Q19 Q21 Q30 Q33 Q35 Q38 Q46-Q48 Q51 Q52 Q55 Q57 Q60-Q63 Q65 Q66 Q70 Q74 QG10-QG12 QG14 QG16 QG18 QG20 QG23 = MOS-N_Dual_6P_ESD_BGM
Q45 Q50 = MOS-P_Dual_6P_BGM
R321 R341 R454 R455 R691 R692 = R
R1016 R1063 R1064 R1145 = RES_B_BGM
RV1-RV4 = Varistor_BGM
S1-S15 = HOLE 1_1
SPAD3 = 3x2_5.1
SW1 = SW_4P_BGM
SW2 = SW_6P_BGM
T1-T16 TP1-TP12 TP14-TP23 TP26-TP29 TP31-TP48 TP50-TP64 TP66 TP69-TP87 TP89-TP116 TP118-TP120 TP122-TP132 TPG1-TPG69 = TP_BGM
U1 = Logic_AND_BGM
U2 = G5245AT11U_BGM
U3 = CPU_CFL_H_1440P_BGM
U4 = 6K5130UA0_32P_BGM
U5 = TS3DS10224RUKR_20P_BGM
U6 U31 = MC74VHC1G08DFT2G_5P_BGM
U7 = DSL6540_337P_BGM
U8 U11 U26 = SLGC55544CVTR_16P_BGM
U9 U12 = W25Q80BWSSIG_BGM
U10 U39 U41 = TUSB546I_BGM
U13 = TPS65987SDHRSHR_56P_BGM
U14 = PCH_CFL_H_874P_BGM
U15 = ANX7490QN-CB-R_40P_BGM
U16 = ANX7428QN-AB-R_48P_BGM
U17 = ALC1220-VA3-CG_56P_BGM
U18 = IT8987E/CX_BGM
U19 = W25Q128JVSIQ_8P_BGM
U20 U22 U25 = ALC1001-VB-CGT_12P_BGM
U21 = PS8817QFN54GTR-A2_54P_BGM
U23 = CYPD4136-24LQXQT_24P_V1_BGM
U24 = ANX7440QN-BB-R_60P_BGM
U27 U29 U42 UG5 UG7 UG8 UG11 = NL17SZ08DFT2G_5P_BGM
U28 = AP21510FM-7_BGM
U30 = PS8811QFN36GTR2-A2_36P_BGM
U32 = M74VHC1GT08DFT2G_5P_BGM
U34 = PS8209AQFN48GTR2-A2_48P_BGM
U35 = G5250Q1T73U_BGM
U36 = UP7553PMA5-15_BGM
U38 = G781_BGM
U40 = SY6288C20AAC_BGM
U43 = PS8527BTQFN20GTR2-A2_BGM
U44 = NPCT750AAAYX_32P_BGM
UG1 = GPU_N18E_2228P_BGM
UG2 = MX25U4033EM1I-12G_8P_BGM
UG3 UG6 UG9 UG10 = 74LVC1G32GW_5P_BGM
UG4 = AOZ1335DI_BGM
VRAM1-VRAM8 = GDDR6_180P_BGM
Y1-Y3 YG1 = CRYSTAL_4P_BGM
Y4 = CRYSTAL_2P_BGM
Y5 = CRYSTAL2_0

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-8X8-S
  round 0.991 smd: 1(7,-4)
50224-00801-001-8P-L
  rect 0.61x1.549 smd: 1(-3.5,3.875) 2(-2.5,3.875) 3(-1.5,3.875) 4(-0.5,3.875) 5(0.5,3.875) 6(1.5,3.875) 7(2.5,3.875) 8(3.5,3.875)
  rect 1.194x1.803 smd: 9(-4.8,0) 10(4.8,0)
50271-0040N-V01-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
50271-00201-001-2P-L
  rect 0.787x1.6 smd: 1(-0.625,2.9) 2(0.625,2.9)
  rect 2.108x2.997 smd: 3(-3.175,0) 4(3.175,0)
50273-0020N-V09-2P-L
  rect 0.787x1.6 smd: 1(-0.625,2.9) 2(0.625,2.9)
  rect 2.108x2.997 smd: 3(-3.175,0) 4(3.175,0)
51288-0060N-001-6P-L
  rect 0.787x2.007 smd: 1(-3.125,4.05) 2(-1.875,4.05) 3(-0.625,4.05) 4(0.625,4.05) 5(1.875,4.05) 6(3.125,4.05)
  rect 2.007x2.489 smd: 7(-5.325,0) 8(5.325,0)
51540-04401-V01-44P-L
  rect 0.305x0.838 smd: 1(-10.75,3.175) 2(-10.25,3.175) 3(-9.75,3.175) 4(-9.25,3.175) 5(-8.75,3.175) 6(-8.25,3.175) 7(-7.75,3.175) 8(-7.25,3.175) 9(-6.75,3.175) 10(-6.25,3.175) 11(-5.75,3.175) 12(-5.25,3.175) 13(-4.75,3.175) 14(-4.25,3.175) 15(-3.75,3.175) 16(-3.25,3.175) 17(-2.75,3.175) 18(-2.25,3.175) 19(-1.75,3.175) 20(-1.25,3.175) 21(-0.75,3.175) 22(-0.25,3.175) 23(0.25,3.175) 24(0.75,3.175) 25(1.25,3.175) 26(1.75,3.175) 27(2.25,3.175) 28(2.75,3.175) 29(3.25,3.175) 30(3.75,3.175) 31(4.25,3.175) 32(4.75,3.175) 33(5.25,3.175) 34(5.75,3.175) 35(6.25,3.175) 36(6.75,3.175) 37(7.25,3.175) 38(7.75,3.175) 39(8.25,3.175) 40(8.75,3.175) 41(9.25,3.175) 42(9.75,3.175) 43(10.25,3.175) 44(10.75,3.175)
  rect 0.787x2.007 smd: 45(-12.45,0) 46(12.45,0)
51619-0080N-001-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.8) 2(-1.25,2.8) 3(-0.75,2.8) 4(-0.25,2.8) 5(0.25,2.8) 6(0.75,2.8) 7(1.25,2.8) 8(1.75,2.8)
  rect 1.803x1.397 smd: 9(-3.4,0) 10(3.4,0)
51619-0180N-001-18P-L
  rect 0.305x1.295 smd: 1(-4.25,2.8) 2(-3.75,2.8) 3(-3.25,2.8) 4(-2.75,2.8) 5(-2.25,2.8) 6(-1.75,2.8) 7(-1.25,2.8) 8(-0.75,2.8) 9(-0.25,2.8) 10(0.25,2.8) 11(0.75,2.8) 12(1.25,2.8) 13(1.75,2.8) 14(2.25,2.8) 15(2.75,2.8) 16(3.25,2.8) 17(3.75,2.8) 18(4.25,2.8)
  rect 1.803x1.397 smd: 19(-5.9,0) 20(5.9,0)
88511-180N-18P-L
  rect 0.305x1.295 smd: 1(-4.25,2.8) 2(-3.75,2.8) 3(-3.25,2.8) 4(-2.75,2.8) 5(-2.25,2.8) 6(-1.75,2.8) 7(-1.25,2.8) 8(-0.75,2.8) 9(-0.25,2.8) 10(0.25,2.8) 11(0.75,2.8) 12(1.25,2.8) 13(1.75,2.8) 14(2.25,2.8) 15(2.75,2.8) 16(3.25,2.8) 17(3.75,2.8) 18(4.25,2.8)
  rect 1.803x1.397 smd: 19(-5.9,0) 20(5.9,0)
BGA180-MICRON-MT61K256M32
  round 0.356 smd: A1(-6.375,-4.875) A2(-6.375,-4.125) A3(-6.375,-3.375) A4(-6.375,-2.625) A5(-6.375,-1.875) A10(-6.375,1.875) A11(-6.375,2.625) A12(-6.375,3.375) A13(-6.375,4.125) A14(-6.375,4.875) B1(-5.625,-4.875) B2(-5.625,-4.125) B3(-5.625,-3.375) B4(-5.625,-2.625) B5(-5.625,-1.875) B10(-5.625,1.875) B11(-5.625,2.625) B12(-5.625,3.375) B13(-5.625,4.125) B14(-5.625,4.875) C1(-4.875,-4.875) C2(-4.875,-4.125) C3(-4.875,-3.375) C4(-4.875,-2.625) C5(-4.875,-1.875) C10(-4.875,1.875) C11(-4.875,2.625) C12(-4.875,3.375) C13(-4.875,4.125) C14(-4.875,4.875) D1(-4.125,-4.875) D2(-4.125,-4.125) D3(-4.125,-3.375) D4(-4.125,-2.625) D5(-4.125,-1.875) D10(-4.125,1.875) D11(-4.125,2.625) D12(-4.125,3.375) D13(-4.125,4.125) D14(-4.125,4.875) E1(-3.375,-4.875) E2(-3.375,-4.125) E3(-3.375,-3.375) E4(-3.375,-2.625) E5(-3.375,-1.875) E10(-3.375,1.875) E11(-3.375,2.625) E12(-3.375,3.375) E13(-3.375,4.125) E14(-3.375,4.875) F1(-2.625,-4.875) F2(-2.625,-4.125) F3(-2.625,-3.375) F4(-2.625,-2.625) F5(-2.625,-1.875) F10(-2.625,1.875) F11(-2.625,2.625) F12(-2.625,3.375) F13(-2.625,4.125) F14(-2.625,4.875) G1(-1.875,-4.875) G2(-1.875,-4.125) G3(-1.875,-3.375) G4(-1.875,-2.625) G5(-1.875,-1.875) G10(-1.875,1.875) G11(-1.875,2.625) G12(-1.875,3.375) G13(-1.875,4.125) G14(-1.875,4.875) H1(-1.125,-4.875) H2(-1.125,-4.125) H3(-1.125,-3.375) H4(-1.125,-2.625) H5(-1.125,-1.875) H10(-1.125,1.875) H11(-1.125,2.625) H12(-1.125,3.375) H13(-1.125,4.125) H14(-1.125,4.875) J1(-0.375,-4.875) J2(-0.375,-4.125) J3(-0.375,-3.375) J4(-0.375,-2.625) J5(-0.375,-1.875) J10(-0.375,1.875) J11(-0.375,2.625) J12(-0.375,3.375) J13(-0.375,4.125) J14(-0.375,4.875) K1(0.375,-4.875) K2(0.375,-4.125) K3(0.375,-3.375) K4(0.375,-2.625) K5(0.375,-1.875) K10(0.375,1.875) K11(0.375,2.625) K12(0.375,3.375) K13(0.375,4.125) K14(0.375,4.875) L1(1.125,-4.875) L2(1.125,-4.125) L3(1.125,-3.375) L4(1.125,-2.625) L5(1.125,-1.875) L10(1.125,1.875) L11(1.125,2.625) L12(1.125,3.375) L13(1.125,4.125) L14(1.125,4.875) M1(1.875,-4.875) M2(1.875,-4.125) M3(1.875,-3.375) M4(1.875,-2.625) M5(1.875,-1.875) M10(1.875,1.875) M11(1.875,2.625) M12(1.875,3.375) M13(1.875,4.125) M14(1.875,4.875) N1(2.625,-4.875) N2(2.625,-4.125) N3(2.625,-3.375) N4(2.625,-2.625) N5(2.625,-1.875) N10(2.625,1.875) N11(2.625,2.625) N12(2.625,3.375) N13(2.625,4.125) N14(2.625,4.875) P1(3.375,-4.875) P2(3.375,-4.125) P3(3.375,-3.375) P4(3.375,-2.625) P5(3.375,-1.875) P10(3.375,1.875) P11(3.375,2.625) P12(3.375,3.375) P13(3.375,4.125) P14(3.375,4.875) R1(4.125,-4.875) R2(4.125,-4.125) R3(4.125,-3.375) R4(4.125,-2.625) R5(4.125,-1.875) R10(4.125,1.875) R11(4.125,2.625) R12(4.125,3.375) R13(4.125,4.125) R14(4.125,4.875) T1(4.875,-4.875) T2(4.875,-4.125) T3(4.875,-3.375) T4(4.875,-2.625) T5(4.875,-1.875) T10(4.875,1.875) T11(4.875,2.625) T12(4.875,3.375) T13(4.875,4.125) T14(4.875,4.875) U1(5.625,-4.875) U2(5.625,-4.125) U3(5.625,-3.375) U4(5.625,-2.625) U5(5.625,-1.875) U10(5.625,1.875) U11(5.625,2.625) U12(5.625,3.375) U13(5.625,4.125) U14(5.625,4.875) V1(6.375,-4.875) V2(6.375,-4.125) V3(6.375,-3.375) V4(6.375,-2.625) V5(6.375,-1.875) V10(6.375,1.875) V11(6.375,2.625) V12(6.375,3.375) V13(6.375,4.125) V14(6.375,4.875)
BGA337-INTEL-DSL6540
  round 0.254 smd: A1(-5.06,-5.06) A23(-5.06,5.06) AA2(4.14,-4.6) AA22(4.14,4.6) AB2(4.6,-4.6) AB3(4.6,-4.14) AB4(4.6,-3.68) AB5(4.6,-3.22) AB6(4.6,-2.76) AB7(4.6,-2.3) AB8(4.6,-1.84) AB9(4.6,-1.38) AB10(4.6,-0.92) AB11(4.6,-0.46) AB12(4.6,0) AB13(4.6,0.46) AB14(4.6,0.92) AB15(4.6,1.38) AB16(4.6,1.84) AB17(4.6,2.3) AB18(4.6,2.76) AB19(4.6,3.22) AB20(4.6,3.68) AB21(4.6,4.14) AB22(4.6,4.6) AC1(5.06,-5.06) AC23(5.06,5.06) B2(-4.6,-4.6) B3(-4.6,-4.14) B4(-4.6,-3.68) B5(-4.6,-3.22) B6(-4.6,-2.76) B7(-4.6,-2.3) B8(-4.6,-1.84) B9(-4.6,-1.38) B10(-4.6,-0.92) B11(-4.6,-0.46) B12(-4.6,0) B13(-4.6,0.46) B14(-4.6,0.92) B15(-4.6,1.38) B16(-4.6,1.84) B17(-4.6,2.3) B18(-4.6,2.76) B19(-4.6,3.22) B20(-4.6,3.68) B21(-4.6,4.14) B22(-4.6,4.6) C2(-4.14,-4.6) C22(-4.14,4.6) D2(-3.68,-4.6) D4(-3.9,-3.9) D5(-3.9,-3.25) D6(-3.9,-2.6) D8(-3.9,-1.95) D9(-3.9,-1.3) D11(-3.9,-0.65) D12(-3.9,0) D13(-3.9,0.65) D15(-3.9,1.3) D16(-3.9,1.95) D18(-3.9,2.6) D19(-3.9,3.25) D20(-3.9,3.9) D22(-3.68,4.6) E2(-3.22,-4.6) E4(-3.25,-3.9) E5(-3.25,-3.25) E6(-3.25,-2.6) E8(-3.25,-1.95) E9(-3.25,-1.3) E11(-3.25,-0.65) E12(-3.25,0) E13(-3.25,0.65) E15(-3.25,1.3) E16(-3.25,1.95) E18(-3.25,2.6) E19(-3.25,3.25) E20(-3.25,3.9) E22(-3.22,4.6) F2(-2.76,-4.6) F4(-2.6,-3.9) F5(-2.6,-3.25) F6(-2.6,-2.6) F8(-2.6,-1.95) F9(-2.6,-1.3) F11(-2.6,-0.65) F12(-2.6,0) F13(-2.6,0.65) F15(-2.6,1.3) F16(-2.6,1.95) F18(-2.6,2.6) F19(-2.6,3.25) F20(-2.6,3.9) F22(-2.76,4.6) G2(-2.3,-4.6) G22(-2.3,4.6) H2(-1.84,-4.6) H4(-1.95,-3.9) H5(-1.95,-3.25) H6(-1.95,-2.6) H8(-1.95,-1.95) H9(-1.95,-1.3) H11(-1.95,-0.65) H12(-1.95,0) H13(-1.95,0.65) H15(-1.95,1.3) H16(-1.95,1.95) H18(-1.95,2.6) H19(-1.95,3.25) H20(-1.95,3.9) H22(-1.84,4.6) J2(-1.38,-4.6) J4(-1.3,-3.9) J5(-1.3,-3.25) J6(-1.3,-2.6) J8(-1.3,-1.95) J9(-1.3,-1.3) J11(-1.3,-0.65) J12(-1.3,0) J13(-1.3,0.65) J15(-1.3,1.3) J16(-1.3,1.95) J18(-1.3,2.6) J19(-1.3,3.25) J20(-1.3,3.9) J22(-1.38,4.6) K2(-0.92,-4.6) K22(-0.92,4.6) L2(-0.46,-4.6) L4(-0.65,-3.9) L5(-0.65,-3.25) L6(-0.65,-2.6) L8(-0.65,-1.95) L9(-0.65,-1.3) L11(-0.65,-0.65) L12(-0.65,0) L13(-0.65,0.65) L15(-0.65,1.3) L16(-0.65,1.95) L18(-0.65,2.6) L19(-0.65,3.25) L20(-0.65,3.9) L22(-0.46,4.6) M2(0,-4.6) M4(0,-3.9) M5(0,-3.25) M6(0,-2.6) M8(0,-1.95) M9(0,-1.3) M11(0,-0.65) M12(0,0) M13(0,0.65) M15(0,1.3) M16(0,1.95) M18(0,2.6) M19(0,3.25) M20(0,3.9) M22(0,4.6) N2(0.46,-4.6) N4(0.65,-3.9) N5(0.65,-3.25) N6(0.65,-2.6) N8(0.65,-1.95) N9(0.65,-1.3) N11(0.65,-0.65) N12(0.65,0) N13(0.65,0.65) N15(0.65,1.3) N16(0.65,1.95) N18(0.65,2.6) N19(0.65,3.25) N20(0.65,3.9) N22(0.46,4.6) P2(0.92,-4.6) P22(0.92,4.6) R2(1.38,-4.6) R4(1.3,-3.9) R5(1.3,-3.25) R6(1.3,-2.6) R8(1.3,-1.95) R9(1.3,-1.3) R11(1.3,-0.65) R12(1.3,0) R13(1.3,0.65) R15(1.3,1.3) R16(1.3,1.95) R18(1.3,2.6) R19(1.3,3.25) R20(1.3,3.9) R22(1.38,4.6) T2(1.84,-4.6) T4(1.95,-3.9) T5(1.95,-3.25) T6(1.95,-2.6) T8(1.95,-1.95) T9(1.95,-1.3) T11(1.95,-0.65) T12(1.95,0) T13(1.95,0.65) T15(1.95,1.3) T16(1.95,1.95) T18(1.95,2.6) T19(1.95,3.25) T20(1.95,3.9) T22(1.84,4.6) U2(2.3,-4.6) U22(2.3,4.6) V2(2.76,-4.6) V4(2.6,-3.9) V5(2.6,-3.25) V6(2.6,-2.6) V8(2.6,-1.95) V9(2.6,-1.3) V11(2.6,-0.65) V12(2.6,0) V13(2.6,0.65) V15(2.6,1.3) V16(2.6,1.95) V18(2.6,2.6) V19(2.6,3.25) V20(2.6,3.9) V22(2.76,4.6) W2(3.22,-4.6) W4(3.25,-3.9) W5(3.25,-3.25) W6(3.25,-2.6) W8(3.25,-1.95) W9(3.25,-1.3) W11(3.25,-0.65) W12(3.25,0) W13(3.25,0.65) W15(3.25,1.3) W16(3.25,1.95) W18(3.25,2.6) W19(3.25,3.25) W20(3.25,3.9) W22(3.22,4.6) Y2(3.68,-4.6) Y4(3.9,-3.9) Y5(3.9,-3.25) Y6(3.9,-2.6) Y8(3.9,-1.95) Y9(3.9,-1.3) Y11(3.9,-0.65) Y12(3.9,0) Y13(3.9,0.65) Y15(3.9,1.3) Y16(3.9,1.95) Y18(3.9,2.6) Y19(3.9,3.25) Y20(3.9,3.9) Y22(3.68,4.6)
  oval 0.33x0.178 smd: A2(-5.06,-4.6) A3(-5.06,-4.14) A4(-5.06,-3.68) A5(-5.06,-3.22) A6(-5.06,-2.76) A7(-5.06,-2.3) A8(-5.06,-1.84) A9(-5.06,-1.38) A10(-5.06,-0.92) A11(-5.06,-0.46) A12(-5.06,0) A13(-5.06,0.46) A14(-5.06,0.92) A15(-5.06,1.38) A16(-5.06,1.84) A17(-5.06,2.3) A18(-5.06,2.76) A19(-5.06,3.22) A20(-5.06,3.68) A21(-5.06,4.14) A22(-5.06,4.6) AC2(5.06,-4.6) AC3(5.06,-4.14) AC4(5.06,-3.68) AC5(5.06,-3.22) AC6(5.06,-2.76) AC7(5.06,-2.3) AC8(5.06,-1.84) AC9(5.06,-1.38) AC10(5.06,-0.92) AC11(5.06,-0.46) AC12(5.06,0) AC13(5.06,0.46) AC14(5.06,0.92) AC15(5.06,1.38) AC16(5.06,1.84) AC17(5.06,2.3) AC18(5.06,2.76) AC19(5.06,3.22) AC20(5.06,3.68) AC21(5.06,4.14) AC22(5.06,4.6)
  oval 0.178x0.33 smd: AA1(4.14,-5.06) AA23(4.14,5.06) AB1(4.6,-5.06) AB23(4.6,5.06) B1(-4.6,-5.06) B23(-4.6,5.06) C1(-4.14,-5.06) C23(-4.14,5.06) D1(-3.68,-5.06) D23(-3.68,5.06) E1(-3.22,-5.06) E23(-3.22,5.06) F1(-2.76,-5.06) F23(-2.76,5.06) G1(-2.3,-5.06) G23(-2.3,5.06) H1(-1.84,-5.06) H23(-1.84,5.06) J1(-1.38,-5.06) J23(-1.38,5.06) K1(-0.92,-5.06) K23(-0.92,5.06) L1(-0.46,-5.06) L23(-0.46,5.06) M1(0,-5.06) M23(0,5.06) N1(0.46,-5.06) N23(0.46,5.06) P1(0.92,-5.06) P23(0.92,5.06) R1(1.38,-5.06) R23(1.38,5.06) T1(1.84,-5.06) T23(1.84,5.06) U1(2.3,-5.06) U23(2.3,5.06) V1(2.76,-5.06) V23(2.76,5.06) W1(3.22,-5.06) W23(3.22,5.06) Y1(3.68,-5.06) Y23(3.68,5.06)
BGA874-INTEL-CNL-PCH-H
  round 0.305 smd: A2(-11.314,-11.46) A3(-11.314,-10.959) A4(-11.314,-10.459) A46(-11.314,10.459) A47(-11.314,10.959) A48(-11.314,11.46) AA19(-1.549,-3.099) AA20(-1.549,-2.324) AA22(-1.549,-1.549) AA23(-1.549,-0.775) AA25(-1.549,0) AA27(-1.549,0.775) AA28(-1.549,1.549) AA30(-1.549,2.324) AA31(-1.549,3.099) AB19(-0.775,-3.099) AB20(-0.775,-2.324) AB22(-0.775,-1.549) AB23(-0.775,-0.775) AB25(-0.775,0) AB27(-0.775,0.775) AB28(-0.775,1.549) AB30(-0.775,2.324) AB31(-0.775,3.099) AC6(-0.579,-9.374) AC7(-0.579,-8.612) AC9(-0.579,-7.85) AC11(-0.579,-7.088) AC12(-0.579,-6.326) AC14(-0.579,-5.564) AC15(-0.579,-4.802) AC17(-0.579,-4.04) AC33(-0.579,4.04) AC35(-0.579,4.802) AC36(-0.579,5.564) AC38(-0.579,6.326) AC39(-0.579,7.088) AC41(-0.579,7.85) AC43(-0.579,8.612) AC44(-0.579,9.374) AD19(0,-3.099) AD20(0,-2.324) AD22(0,-1.549) AD23(0,-0.775) AD25(0,0) AD27(0,0.775) AD28(0,1.549) AD30(0,2.324) AD31(0,3.099) AE6(0.579,-9.374) AE7(0.579,-8.612) AE9(0.579,-7.85) AE11(0.579,-7.088) AE12(0.579,-6.326) AE14(0.579,-5.564) AE15(0.579,-4.802) AE17(0.579,-4.04) AE33(0.579,4.04) AE35(0.579,4.802) AE36(0.579,5.564) AE38(0.579,6.326) AE39(0.579,7.088) AE41(0.579,7.85) AE43(0.579,8.612) AE44(0.579,9.374) AF19(0.775,-3.099) AF20(0.775,-2.324) AF22(0.775,-1.549) AF23(0.775,-0.775) AF25(0.775,0) AF27(0.775,0.775) AF28(0.775,1.549) AF30(0.775,2.324) AF31(0.775,3.099) AG19(1.549,-3.099) AG20(1.549,-2.324) AG22(1.549,-1.549) AG23(1.549,-0.775) AG25(1.549,0) AG27(1.549,0.775) AG28(1.549,1.549) AG30(1.549,2.324) AG31(1.549,3.099) AH9(2.205,-7.919) AH10(2.014,-7.18) AH12(2.014,-6.402) AH14(2.014,-5.564) AH15(2.014,-4.789) AH17(2.014,-4.027) AH33(2.014,4.027) AH35(2.014,4.789) AH36(2.014,5.564) AH38(2.014,6.402) AH40(2.014,7.18) AH41(2.205,7.919) AJ6(2.586,-9.397) AJ7(2.395,-8.658) AJ19(2.324,-3.099) AJ20(2.324,-2.324) AJ22(2.324,-1.549) AJ23(2.324,-0.775) AJ25(2.324,0) AJ27(2.324,0.775) AJ28(2.324,1.549) AJ30(2.324,2.324) AJ31(2.324,3.099) AJ43(2.395,8.658) AJ44(2.586,9.397) AK19(3.099,-3.099) AK20(3.099,-2.324) AK22(3.099,-1.549) AK23(3.099,-0.775) AK25(3.099,0) AK27(3.099,0.775) AK28(3.099,1.549) AK30(3.099,2.324) AK31(3.099,3.099) AL9(3.495,-7.914) AL10(3.259,-7.181) AL12(3.259,-6.419) AL13(3.259,-5.657) AL15(3.259,-4.895) AL17(3.259,-4.133) AL21(3.578,-2.014) AL24(3.591,-0.579) AL26(3.591,0.579) AL29(3.578,2.014) AL33(3.259,4.133) AL35(3.259,4.895) AL37(3.259,5.657) AL38(3.259,6.419) AL40(3.259,7.181) AL41(3.495,7.914) AM7(3.843,-8.635) AM18(3.683,-3.259) AM32(3.683,3.259) AM43(3.843,8.635) AN6(4.224,-9.295) AN10(4.656,-7.181) AN12(4.351,-6.444) AN13(4.351,-5.682) AN15(4.351,-4.92) AN16(4.394,-4.351) AN18(4.394,-3.259) AN21(4.289,-2.014) AN24(4.302,-0.579) AN26(4.302,0.579) AN29(4.289,2.014) AN32(4.394,3.259) AN34(4.394,4.351) AN35(4.351,4.92) AN37(4.351,5.682) AN38(4.351,6.444) AN40(4.656,7.181) AN44(4.224,9.295) AP9(4.968,-7.914) AP21(5.064,-2.014) AP24(5.064,-0.579) AP26(5.064,0.579) AP29(5.064,2.014) AP41(4.968,7.914) AR8(5.469,-8.508) AR12(5.443,-6.444) AR13(5.443,-5.682) AR15(5.443,-4.92) AR16(5.182,-4.351) AR18(5.156,-3.259) AR32(5.156,3.259) AR34(5.182,4.351) AR35(5.443,4.92) AR37(5.443,5.682) AR38(5.443,6.444) AR42(5.469,8.508) AT6(5.659,-9.295) AT10(5.773,-7.181) AT16(5.944,-4.351) AT18(5.918,-3.259) AT21(5.902,-2.014) AT24(5.826,-0.579) AT26(5.826,0.579) AT29(5.902,2.014) AT32(5.918,3.259) AT34(5.944,4.351) AT40(5.773,7.181) AT44(5.659,9.295) AU9(6.416,-7.914) AU24(6.588,-0.579) AU26(6.588,0.579) AU41(6.416,7.914) AV6(7.094,-9.295) AV7(6.764,-8.597) AV11(6.975,-7.079) AV13(6.757,-5.748) AV16(6.719,-4.656) AV18(6.68,-3.259) AV21(6.679,-2.014) AV29(6.679,2.014) AV32(6.68,3.259) AV34(6.719,4.656) AV37(6.757,5.748) AV39(6.975,7.079) AV43(6.764,8.597) AV44(7.094,9.295) AW9(7.577,-7.824) AW10(7.509,-7.262) AW13(7.49,-6.01) AW15(7.452,-4.892) AW18(7.413,-3.495) AW21(7.419,-2.205) AW24(7.35,-0.579) AW26(7.35,0.579) AW29(7.419,2.205) AW32(7.413,3.495) AW35(7.452,4.892) AW37(7.49,6.01) AW40(7.509,7.262) AW41(7.577,7.824) AY8(7.898,-8.533) AY42(7.898,8.533) B1(-10.96,-11.814) B2(-10.83,-11.33) B3(-10.878,-10.709) B47(-10.878,10.709) B48(-10.83,11.33) B49(-10.96,11.814) BA6(8.203,-9.13) BA12(8.135,-6.485) BA14(8.135,-5.24) BA17(8.135,-3.843) BA20(8.158,-2.395) BA24(8.112,-0.579) BA26(8.112,0.579) BA30(8.158,2.395) BA33(8.135,3.843) BA36(8.135,5.24) BA38(8.135,6.485) BA44(8.203,9.13) BB6(8.706,-9.088) BB7(9,-8.589) BB9(8.774,-8.024) BB11(8.795,-6.866) BB14(8.795,-5.621) BB16(8.795,-4.224) BB20(8.897,-2.586) BB24(8.874,-0.579) BB26(8.874,0.579) BB30(8.897,2.586) BB34(8.795,4.224) BB36(8.795,5.621) BB39(8.795,6.866) BB41(8.774,8.024) BB43(9,8.589) BB44(8.706,9.088) BC5(9.254,-9.634) BC45(9.254,9.634) BD1(9.959,-11.814) BD4(9.983,-10.474) BD46(9.983,10.474) BD49(9.959,11.814) BE1(10.459,-11.814) BE2(10.196,-11.373) BE3(10.311,-10.86) BE4(10.487,-10.391) BE5(10.212,-9.965) BE45(10.212,9.965) BE46(10.487,10.391) BE47(10.311,10.86) BE48(10.196,11.373) BE49(10.459,11.814) BF1(10.96,-11.814) BF2(10.83,-11.33) BF3(10.878,-10.709) BF47(10.878,10.709) BF48(10.83,11.33) BF49(10.96,11.814) BG2(11.314,-11.46) BG3(11.314,-10.959) BG4(11.314,-10.459) BG46(11.314,10.459) BG47(11.314,10.959) BG48(11.314,11.46) C1(-10.459,-11.814) C2(-10.196,-11.373) C3(-10.311,-10.86) C4(-10.487,-10.391) C5(-10.212,-9.965) C45(-10.212,9.965) C46(-10.487,10.391) C47(-10.311,10.86) C48(-10.196,11.373) C49(-10.459,11.814) D1(-9.959,-11.814) D4(-9.983,-10.474) D46(-9.983,10.474) D49(-9.959,11.814) E5(-9.254,-9.634) E45(-9.254,9.634) F6(-8.706,-9.088) F7(-9,-8.589) F9(-8.774,-8.024) F11(-8.795,-6.866) F14(-8.795,-5.621) F16(-8.795,-4.224) F20(-8.897,-2.586) F24(-8.874,-0.579) F26(-8.874,0.579) F30(-8.897,2.586) F34(-8.795,4.224) F36(-8.795,5.621) F39(-8.795,6.866) F41(-8.774,8.024) F43(-9,8.589) F44(-8.706,9.088) G6(-8.203,-9.13) G12(-8.135,-6.485) G14(-8.135,-5.24) G17(-8.135,-3.843) G20(-8.158,-2.395) G24(-8.112,-0.579) G26(-8.112,0.579) G30(-8.158,2.395) G33(-8.135,3.843) G36(-8.135,5.24) G38(-8.135,6.485) G44(-8.203,9.13) H8(-7.898,-8.533) H42(-7.898,8.533) J9(-7.577,-7.824) J10(-7.509,-7.262) J13(-7.49,-6.01) J15(-7.452,-4.892) J18(-7.413,-3.495) J21(-7.419,-2.205) J24(-7.35,-0.579) J26(-7.35,0.579) J29(-7.419,2.205) J32(-7.413,3.495) J35(-7.452,4.892) J37(-7.49,6.01) J40(-7.509,7.262) J41(-7.577,7.824) K6(-7.094,-9.295) K7(-6.764,-8.597) K11(-6.975,-7.079) K13(-6.757,-5.748) K16(-6.719,-4.656) K18(-6.68,-3.259) K21(-6.679,-2.014) K29(-6.679,2.014) K32(-6.68,3.259) K34(-6.719,4.656) K37(-6.757,5.748) K39(-6.975,7.079) K43(-6.764,8.597) K44(-7.094,9.295) L9(-6.416,-7.914) L24(-6.588,-0.579) L26(-6.588,0.579) L41(-6.416,7.914) M6(-5.659,-9.295) M10(-5.773,-7.181) M16(-5.944,-4.351) M18(-5.918,-3.259) M21(-5.902,-2.014) M24(-5.826,-0.579) M26(-5.826,0.579) M29(-5.902,2.014) M32(-5.918,3.259) M34(-5.944,4.351) M40(-5.773,7.181) M44(-5.659,9.295) N8(-5.469,-8.508) N12(-5.443,-6.444) N13(-5.443,-5.682) N15(-5.443,-4.92) N16(-5.182,-4.351) N18(-5.156,-3.259) N32(-5.156,3.259) N34(-5.182,4.351) N35(-5.443,4.92) N37(-5.443,5.682) N38(-5.443,6.444) N42(-5.469,8.508) P9(-4.968,-7.914) P21(-5.064,-2.014) P24(-5.064,-0.579) P26(-5.064,0.579) P29(-5.064,2.014) P41(-4.968,7.914) R6(-4.224,-9.295) R10(-4.656,-7.181) R12(-4.351,-6.444) R13(-4.351,-5.682) R15(-4.351,-4.92) R16(-4.394,-4.351) R18(-4.394,-3.259) R21(-4.289,-2.014) R24(-4.302,-0.579) R26(-4.302,0.579) R29(-4.289,2.014) R32(-4.394,3.259) R34(-4.394,4.351) R35(-4.351,4.92) R37(-4.351,5.682) R38(-4.351,6.444) R40(-4.656,7.181) R44(-4.224,9.295) T7(-3.843,-8.635) T17(-3.683,-3.811) T18(-3.683,-3.259) T32(-3.683,3.259) T43(-3.843,8.635) U9(-3.495,-7.914) U10(-3.259,-7.181) U12(-3.259,-6.419) U13(-3.259,-5.657) U15(-3.259,-4.895) U17(-3.259,-4.133) U21(-3.578,-2.014) U24(-3.591,-0.579) U26(-3.591,0.579) U29(-3.578,2.014) U33(-3.259,4.133) U35(-3.259,4.895) U37(-3.259,5.657) U38(-3.259,6.419) U40(-3.259,7.181) U41(-3.495,7.914) V19(-3.099,-3.099) V20(-3.099,-2.324) V22(-3.099,-1.549) V23(-3.099,-0.775) V25(-3.099,0) V27(-3.099,0.775) V28(-3.099,1.549) V30(-3.099,2.324) V31(-3.099,3.099) W6(-2.586,-9.397) W7(-2.395,-8.658) W19(-2.324,-3.099) W20(-2.324,-2.324) W22(-2.324,-1.549) W23(-2.324,-0.775) W25(-2.324,0) W27(-2.324,0.775) W28(-2.324,1.549) W30(-2.324,2.324) W31(-2.324,3.099) W43(-2.395,8.658) W44(-2.586,9.397) Y9(-2.205,-7.919) Y10(-2.014,-7.18) Y12(-2.014,-6.402) Y14(-2.014,-5.564) Y15(-2.014,-4.789) Y17(-2.014,-4.027) Y33(-2.014,4.027) Y35(-2.014,4.789) Y36(-2.014,5.564) Y38(-2.014,6.402) Y40(-2.014,7.18) Y41(-2.205,7.919)
  round 0.279 smd: A5(-11.314,-9.958) A45(-11.314,9.958) BC1(9.458,-11.814) BC49(9.458,11.814) BG5(11.314,-9.958) BG45(11.314,9.958) E1(-9.458,-11.814) E49(-9.458,11.814)
  oval 0.254x0.203 smd: A6(-11.314,-9.399) A8(-11.314,-8.294) A42(-11.314,8.294) A44(-11.314,9.399) BD8(9.813,-8.411) BD12(9.813,-6.214) BD17(9.813,-4.017) BD21(9.813,-1.82) BD29(9.813,1.82) BD33(9.813,4.017) BD38(9.813,6.214) BD42(9.813,8.411) BE9(10.186,-7.784) BE10(10.059,-7.283) BE14(10.186,-5.587) BE15(10.059,-5.086) BE18(10.186,-3.39) BE19(10.059,-2.889) BE23(10.186,-1.193) BE24(10.059,-0.692) BE26(10.059,0.692) BE27(10.186,1.193) BE31(10.059,2.889) BE32(10.186,3.39) BE35(10.059,5.086) BE36(10.186,5.587) BE40(10.059,7.283) BE41(10.186,7.784) BG6(11.314,-9.399) BG8(11.314,-8.294) BG42(11.314,8.294) BG44(11.314,9.399) C9(-10.186,-7.784) C10(-10.059,-7.283) C14(-10.186,-5.587) C15(-10.059,-5.086) C18(-10.186,-3.39) C19(-10.059,-2.889) C23(-10.186,-1.193) C24(-10.059,-0.692) C26(-10.059,0.692) C27(-10.186,1.193) C31(-10.059,2.889) C32(-10.186,3.39) C35(-10.059,5.086) C36(-10.186,5.587) C40(-10.059,7.283) C41(-10.186,7.784) D8(-9.813,-8.411) D12(-9.813,-6.214) D17(-9.813,-4.017) D21(-9.813,-1.82) D29(-9.813,1.82) D33(-9.813,4.017) D38(-9.813,6.214) D42(-9.813,8.411)
  oval 0.254x0.152 smd: A13(-11.314,-6.072) A17(-11.314,-3.875) A22(-11.314,-1.678) A25(-11.314,0) A28(-11.314,1.678) A33(-11.314,3.875) A37(-11.314,6.072) B10(-10.603,-7.123) B12(-10.816,-6.265) B14(-10.687,-5.587) B15(-10.603,-4.926) B17(-10.816,-4.068) B18(-10.687,-3.39) B19(-10.603,-2.729) B21(-10.816,-1.871) B23(-10.687,-1.193) B24(-10.603,-0.532) B25(-10.806,0) B26(-10.603,0.532) B27(-10.687,1.193) B29(-10.816,1.871) B31(-10.603,2.729) B32(-10.687,3.39) B33(-10.816,4.068) B35(-10.603,4.926) B36(-10.687,5.587) B38(-10.816,6.265) B40(-10.603,7.123) BE11(10.118,-6.76) BE12(10.313,-6.295) BE16(10.118,-4.563) BE17(10.313,-4.098) BE20(10.118,-2.366) BE21(10.313,-1.901) BE25(10.298,0) BE29(10.313,1.901) BE30(10.118,2.366) BE33(10.313,4.098) BE34(10.118,4.563) BE38(10.313,6.295) BE39(10.118,6.76) BF10(10.603,-7.123) BF12(10.816,-6.265) BF14(10.687,-5.587) BF15(10.603,-4.926) BF17(10.816,-4.068) BF18(10.687,-3.39) BF19(10.603,-2.729) BF21(10.816,-1.871) BF23(10.687,-1.193) BF24(10.603,-0.532) BF25(10.806,0) BF26(10.603,0.532) BF27(10.687,1.193) BF29(10.816,1.871) BF31(10.603,2.729) BF32(10.687,3.39) BF33(10.816,4.068) BF35(10.603,4.926) BF36(10.687,5.587) BF38(10.816,6.265) BF40(10.603,7.123) BG13(11.314,-6.072) BG17(11.314,-3.875) BG22(11.314,-1.678) BG25(11.314,0) BG28(11.314,1.678) BG33(11.314,3.875) BG37(11.314,6.072) C11(-10.118,-6.76) C12(-10.313,-6.295) C16(-10.118,-4.563) C17(-10.313,-4.098) C20(-10.118,-2.366) C21(-10.313,-1.901) C25(-10.298,0) C29(-10.313,1.901) C30(-10.118,2.366) C33(-10.313,4.098) C34(-10.118,4.563) C38(-10.313,6.295) C39(-10.118,6.76)
  oval 0.152x0.254 smd: AA1(-1.678,-11.814) AA49(-1.678,11.814) AB2(-1.193,-11.187) AB48(-1.193,11.187) AC2(-0.532,-11.103) AC48(-0.532,11.103) AD1(0,-11.814) AD2(0,-11.306) AD3(0,-10.798) AD47(0,10.798) AD48(0,11.306) AD49(0,11.814) AE2(0.532,-11.103) AE48(0.532,11.103) AF2(1.193,-11.187) AF48(1.193,11.187) AG1(1.678,-11.814) AG49(1.678,11.814) AH2(1.871,-11.316) AH3(1.901,-10.813) AH47(1.901,10.813) AH48(1.871,11.316) AJ3(2.366,-10.618) AJ47(2.366,10.618) AK2(2.729,-11.103) AK48(2.729,11.103) AL2(3.39,-11.187) AL48(3.39,11.187) AM1(3.875,-11.814) AM2(4.068,-11.316) AM3(4.098,-10.813) AM47(4.098,10.813) AM48(4.068,11.316) AM49(3.875,11.814) AN3(4.563,-10.618) AN47(4.563,10.618) AP2(4.926,-11.103) AP48(4.926,11.103) P2(-4.926,-11.103) P48(-4.926,11.103) R3(-4.563,-10.618) R47(-4.563,10.618) T1(-3.875,-11.814) T2(-4.068,-11.316) T3(-4.098,-10.813) T47(-4.098,10.813) T48(-4.068,11.316) T49(-3.875,11.814) U2(-3.39,-11.187) U48(-3.39,11.187) V2(-2.729,-11.103) V48(-2.729,11.103) W3(-2.366,-10.618) W47(-2.366,10.618) Y2(-1.871,-11.316) Y3(-1.901,-10.813) Y47(-1.901,10.813) Y48(-1.871,11.316)
  round 0.254 smd: AA5(-1.601,-9.856) AA45(-1.601,9.856) AC4(-0.579,-10.06) AC46(-0.579,10.06) AE4(0.579,-10.06) AE46(0.579,10.06) AG5(1.601,-9.856) AG45(1.601,9.856) AJ4(2.274,-10.098) AJ46(2.274,10.098) AK4(2.776,-10.06) AK46(2.776,10.06) AM5(3.799,-9.856) AM45(3.799,9.856) AN4(4.471,-10.098) AN46(4.471,10.098) AP4(4.973,-10.06) AP46(4.973,10.06) AT5(5.996,-9.856) AT45(5.996,9.856) AV4(6.669,-10.098) AV46(6.669,10.098) AW4(7.17,-10.06) AW46(7.17,10.06) B6(-10.811,-9.397) B44(-10.811,9.397) BA2(8.526,-11.316) BA3(8.594,-10.809) BA4(8.468,-10.304) BA5(8.193,-9.856) BA45(8.193,9.856) BA46(8.468,10.304) BA47(8.594,10.809) BA48(8.526,11.316) BB3(9.315,-11.318) BB4(9.126,-10.825) BB46(9.126,10.825) BB47(9.315,11.318) BC8(9.356,-8.193) BC10(9.56,-7.17) BC13(9.356,-5.996) BC15(9.56,-4.973) BC17(9.356,-3.799) BC19(9.56,-2.776) BC22(9.356,-1.601) BC24(9.56,-0.579) BC26(9.56,0.579) BC28(9.356,1.601) BC31(9.56,2.776) BC33(9.356,3.799) BC35(9.56,4.973) BC37(9.356,5.996) BC40(9.56,7.17) BC42(9.356,8.193) BD7(9.872,-8.914) BD11(9.598,-6.669) BD16(9.598,-4.471) BD20(9.598,-2.274) BD30(9.598,2.274) BD34(9.598,4.471) BD39(9.598,6.669) BD43(9.872,8.914) BE6(10.357,-9.091) BE44(10.357,9.091) BF6(10.811,-9.397) BF44(10.811,9.397) C6(-10.357,-9.091) C44(-10.357,9.091) D7(-9.872,-8.914) D11(-9.598,-6.669) D16(-9.598,-4.471) D20(-9.598,-2.274) D30(-9.598,2.274) D34(-9.598,4.471) D39(-9.598,6.669) D43(-9.872,8.914) E8(-9.356,-8.193) E10(-9.56,-7.17) E13(-9.356,-5.996) E15(-9.56,-4.973) E17(-9.356,-3.799) E19(-9.56,-2.776) E22(-9.356,-1.601) E24(-9.56,-0.579) E26(-9.56,0.579) E28(-9.356,1.601) E31(-9.56,2.776) E33(-9.356,3.799) E35(-9.56,4.973) E37(-9.356,5.996) E40(-9.56,7.17) E42(-9.356,8.193) F3(-9.315,-11.318) F4(-9.126,-10.825) F46(-9.126,10.825) F47(-9.315,11.318) G2(-8.526,-11.316) G3(-8.594,-10.809) G4(-8.468,-10.304) G5(-8.193,-9.856) G45(-8.193,9.856) G46(-8.468,10.304) G47(-8.594,10.809) G48(-8.526,11.316) J4(-7.17,-10.06) J46(-7.17,10.06) K4(-6.669,-10.098) K46(-6.669,10.098) M5(-5.996,-9.856) M45(-5.996,9.856) P4(-4.973,-10.06) P46(-4.973,10.06) R4(-4.471,-10.098) R46(-4.471,10.098) T5(-3.799,-9.856) T45(-3.799,9.856) V4(-2.776,-10.06) V46(-2.776,10.06) W4(-2.274,-10.098) W46(-2.274,10.098)
  oval 0.203x0.254 smd: AB3(-1.193,-10.686) AB47(-1.193,10.686) AC3(-0.692,-10.559) AC47(-0.692,10.559) AE3(0.692,-10.559) AE47(0.692,10.559) AF3(1.193,-10.686) AF47(1.193,10.686) AH4(1.82,-10.313) AH46(1.82,10.313) AK3(2.883,-10.559) AK47(2.883,10.559) AL3(3.39,-10.686) AL47(3.39,10.686) AM4(4.017,-10.313) AM46(4.017,10.313) AP3(5.08,-10.559) AP47(5.08,10.559) AR3(5.587,-10.686) AR47(5.587,10.686) AT1(6.097,-11.814) AT49(6.097,11.814) AU4(6.214,-10.313) AU46(6.214,10.313) AW3(7.277,-10.559) AW47(7.277,10.559) AY3(7.784,-10.686) AY47(7.784,10.686) BA1(8.32,-11.814) BA49(8.32,11.814) G1(-8.32,-11.814) G49(-8.32,11.814) H3(-7.784,-10.686) H47(-7.784,10.686) J3(-7.277,-10.559) J47(-7.277,10.559) L4(-6.214,-10.313) L46(-6.214,10.313) M1(-6.097,-11.814) M49(-6.097,11.814) N3(-5.587,-10.686) N47(-5.587,10.686) P3(-5.08,-10.559) P47(-5.08,10.559) T4(-4.017,-10.313) T46(-4.017,10.313) U3(-3.39,-10.686) U47(-3.39,10.686) V3(-2.883,-10.559) V47(-2.883,10.559) Y4(-1.82,-10.313) Y46(-1.82,10.313)
  oval 0.152x0.305 smd: AR2(5.587,-11.187) AR48(5.587,11.187) AU2(6.265,-11.316) AU3(6.295,-10.813) AU47(6.295,10.813) AU48(6.265,11.316) AV3(6.76,-10.618) AV47(6.76,10.618) AW2(7.123,-11.103) AW48(7.123,11.103) AY2(7.784,-11.187) AY48(7.784,11.187) H2(-7.784,-11.187) H48(-7.784,11.187) J2(-7.123,-11.103) J48(-7.123,11.103) K3(-6.76,-10.618) K47(-6.76,10.618) L2(-6.265,-11.316) L3(-6.295,-10.813) L47(-6.295,10.813) L48(-6.265,11.316) N2(-5.587,-11.187) N48(-5.587,11.187)
  oval 0.305x0.152 smd: B8(-10.816,-8.462) B9(-10.687,-7.784) B41(-10.687,7.784) B42(-10.816,8.462) BE8(10.313,-8.492) BE42(10.313,8.492) BF8(10.816,-8.462) BF9(10.687,-7.784) BF41(10.687,7.784) BF42(10.816,8.462) C8(-10.313,-8.492) C42(-10.313,8.492)
