# Allegro board ZGE(DA0ZGEMBCE0-E)-ANNIE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GLS_LED_EN_G: length 128.2
  TOP w0.508: v1(9.73,57.88) 10.01,58.16 D19.1 9.14,58.59 Q21.6
  IN4 w0.508: v1(18.43,162.09) 19.2,161.33 19.2,159.43 17.8,158.03 17.8,156.33 18.81,155.31 18.81,147.85 17.13,146.17 14.32,146.17 11.33,143.18 8.21,143.18 7.41,142.38 7.41,137.45 6.85,136.89 6.85,110.66 8.49,109.02 8.49,105.69 9.93,104.25 12.55,104.25 13.43,103.37 13.89,103.37 14.78,102.48 14.78,99.02 16.76,97.04 16.76,93.74 16.88,93.62 16.88,91.5 17.11,91.27 17.11,90.77 16.76,90.41 15.91,90.41 12.62,87.11 11.4,85.9 11.4,78.63 11.17,78.4 11.17,76.11 11.83,75.45 11.83,74.54 12.08,74.28 12.08,72.76 10.33,71 10.33,70.57 9.69,69.93 9.69,61.47 10.03,61.13 10.03,58.17 v1(9.73,57.88)
  BOTTOM w0.254: 18.15,161.81 CN9.5
  BOTTOM w0.508: v1(18.43,162.09) 18.15,161.81
GLS_LED_EN_R: length 121.1
  IN4 w0.508: v1(18.05,159.45) 18.05,159.15 17.19,158.28 17.19,156.08 18.21,155.06 18.21,148.1 16.88,146.78 14.07,146.78 11.08,143.79 7.91,143.79 6.8,142.69 6.8,137.71 6.24,137.15 6.24,110.41 6.64,110.01 6.64,106.53 9.53,103.64 11.5,103.64 12.24,102.91 12.24,100.69 15.61,97.32 15.61,90.97 10.49,85.85 10.49,79.45 9.32,78.27 9.32,76.14 9.67,75.78 10.64,75.78 11.22,75.2 11.22,74.29 11.47,74.03 11.47,73.01 9.59,71.12 9.59,70.69 9.08,70.18 9.08,67.02 8.71,66.64 8.71,60.24 9.21,59.73 v1(9.29,59.73)
  BOTTOM w0.254: 17.65,159.68 CN9.4
  BOTTOM w0.508: v1(18.05,159.45) 17.87,159.45 17.65,159.68
GLS_LED_PWR: length 137.3
  TOP w0.635: v1(11.58,61.23) 11.75,61.05 v1(11.75,60.21) 11.59,60.05 11.59,58.09 11.5,58 11.5,56.4 11.6,56.3 D20.1 10.86,55.94 10.76,56.05 Q23.3 10.42,55.77 9.58,54.94 9.58,54.93 8.95,54.3 8.06,54.3
  IN2 w0.635: v1(16.02,163.49) 15.94,163.41 14.19,163.41 13.54,162.76 11.18,162.76 10.23,161.81 7.43,161.81 6.86,161.25 6.86,131.62 6.35,131.11 6.35,104.91 9.77,101.49 11.45,101.49 15.59,97.36 15.59,93.92 15.05,93.38 15.05,92.17 13.55,90.67 8.12,90.67 7.95,90.84 7.05,90.84 6.43,90.22 6.43,87.95 6.95,87.43 6.95,84.27 7.45,83.77 9,83.77 9.75,83.02 9.75,79.49 9.06,78.81 9.06,75.89 8.41,75.23 8.41,73.52 10.27,71.66 10.27,69.39 10.06,69.18 10.06,64.86 10.19,64.74 10.19,62.62 v1(11.58,61.23)
  vias: v1(16.02,162.73)
GLS_LED_PWR_CTL: length 23.8
  TOP w0.14: v1(6.83,74.51) 7.4,75.08 U4.26 ; Q23.2 7.76,56.34 R145.2 6.8,56.65 v1(6.8,56.96)
  IN1 w0.086: v1(6.83,74.51) 7.41,73.93 7.41,73.46 6.76,72.82 6.76,66.04 8.79,64.02 8.79,62.08 7.67,60.96 7.67,57.66 6.97,56.96 v1(6.8,56.96)
GPIO18_IFPE_HPD: length 9.2
  TOP w0.102: 31.77,97.45 32.2,97.45 RG24.2 33.09,97.92 33.29,97.72 37.85,97.72 38.17,98.05 UG1.BE3
  TOP w0.14: 31.77,97.45 31.57,97.45 v1(31.1,96.99) 30.59,96.48 QG6.3
GPIO18_IFPE_HPD_Q: length 3.3
  TOP w0.14: QG6.2 29.16,96.81 29.68,97.33 RG23.1 RG22.1
GPIO22_SWAPRDY_IN: length 10.8
  TOP w0.102: RG11.1 33.57,104.05 35.12,102.51 v1(36.09,102.51) ; UG1.BB6 40.77,99.83 v2(40.82,99.83)
  IN2 w0.089: v1(36.09,102.51) 36.09,101.9 36.92,101.06 38.78,101.06 39.64,100.2 40.46,100.2 v2(40.82,99.83)
GPIO23_RASTER_SYNC1: length 7.2
  TOP w0.102: RG26.2 32.41,96.43 33.62,96.43 34.41,97.22 37.26,97.22 37.49,97 37.78,97 38.13,96.65 UG1.BG3
GPIO24_IFPF_HPD: length 378.8
  TOP w0.14: v1(251.35,16.15) 251.35,16.67 R526.1 ; R440.2 90.77,22.18 v1(90.95,22.37) ; v1(187.63,40.65) 187.63,38.72 188.2,38.15 Q78.2
  IN2 w0.089: v1(244.46,33.62) 244.13,33.29 244.13,31.66 244.47,31.32 244.47,27.47 244.73,27.21 245.06,27.21 245.47,26.8 245.47,26.29 246.58,25.19 246.58,24.45 246.96,24.07 248.2,24.07 248.81,23.46 248.81,19.6 249.57,18.84 249.57,17.92 v1(251.35,16.15)
  IN3 w0.089: v1(91.03,39.03) 91.81,39.03 91.87,38.98 94.26,38.98 94.65,38.58 94.65,38.33 94.95,38.04 99.93,38.04 100.27,37.7 176.21,37.7 178.87,40.36 182.83,40.36 183.31,40.84 186.19,40.84 186.32,40.97 187.32,40.97 v1(187.63,40.65) 188,41.02 189.83,41.02 193.31,37.55 195.45,37.55 199.9,33.09 202.62,33.09 203.06,33.54 204.46,33.54 204.83,33.91 210.25,33.91 210.43,33.73 211.43,33.73 211.7,34 213.24,34 214.39,32.85 218.8,32.85 219.48,32.17 220.86,32.17 221.22,32.52 224.09,32.52 224.64,33.08 225.07,33.08 225.37,32.78 226.03,32.78 227.17,33.92 227.17,34.51 227.63,34.97 229.78,34.97 230.96,33.79 232.5,33.79 233.19,34.47 234.39,34.47 235.1,33.76 236.01,33.76 236.39,34.14 237.25,34.14 237.46,34.35 237.46,34.93 237.95,35.43 239.56,35.43 239.87,35.12 240.98,35.12 242.02,34.08 244.01,34.08 v1(244.46,33.62) ; v1(16.2,101.61) 15.6,101 15.6,99.22 15.9,98.92 15.9,95.56 17.2,94.26 17.74,94.26 18.01,94 18.01,93.66 17.37,93.02 17.37,92.24 16.66,91.52 16.02,91.52 15.84,91.34 15.84,88.21 15.12,87.49 14.88,87.49 12.44,85.05 12.44,83.4 13.06,82.79 13.83,82.79 13.92,82.7 13.92,78.85 13.43,78.36 13.43,77.32 14.05,76.7 14.05,71.44 13.69,71.09 13.69,69.81 14.12,69.39 14.12,65.32 13.8,65 13.8,61.06 14,60.87 14,60.21 16.92,57.29 16.92,55.77 17.5,55.19 17.5,52.08 18.12,51.46 18.88,51.46 20.48,49.85 20.48,48.02 22.19,46.31 25.73,46.31 27,45.05 28.03,45.05 28.66,45.67 28.66,46.97 27.73,47.9 27.73,48.33 27.95,48.55 28.3,48.55 28.54,48.32 28.54,47.89 29.04,47.39 29.04,46.48 31.1,44.43 31.2,44.43 32.09,43.54 32.09,43.38 36.52,38.95 38.05,38.95 38.66,38.34 41.7,38.34 41.82,38.46 45.39,38.46 45.52,38.6 47.03,38.6 47.43,38.99 47.43,39.4 47.62,39.6 48.15,39.6 50.06,37.69 53.5,37.69 54.17,37.02 57.21,37.02 57.87,36.36 59.27,36.36 59.81,35.82 61.33,35.82 61.78,35.38 65.1,35.38 65.44,35.03 67.79,35.03 67.86,34.97 68.54,34.97 68.55,34.95 68.56,34.95 68.85,34.67 71.35,34.67 71.87,34.14 74.58,34.14 74.77,33.95 75.63,33.95 76.28,33.3 76.61,33.3 76.85,33.53 78.63,33.53 v1(79.12,33.03)
  BOTTOM w0.14: R1074.2 253.09,17.64 R1083.2 251.9,16.8 251.35,16.25 v1(251.35,16.15) ; v1(16.2,101.61) 16.01,101.41 Q64.2 ; v1(79.12,33.03) 79.12,33.39 82.09,36.36 82.09,38.16 81.79,38.45 81.79,40.44 82.7,41.35 82.7,43.79 83.3,44.39 86.35,44.39 86.56,44.19 86.89,44.19 88.28,42.8 88.28,42.45 88.58,42.14 88.58,41.5 91,39.08 91,39.06 v1(91.03,39.03) 91.55,38.51 91.67,38.51 93.73,36.45 93.73,35.4 96.26,32.87 96.26,31.68 94.52,29.94 92.35,29.94 91.57,29.16 91.57,28.5 92.47,27.6 92.47,23.08 92.27,22.88 91.46,22.88 v1(90.95,22.37)
GPIO24_IFPF_HPD_PCH: length 5.1
  TOP w0.14: Q78.3 189.15,40.2 189.62,40.67 R239.2 189.62,41.69 188.86,42.45 RG196.1
GPIO26_FP_FUSE: length 37.2
  TOP w0.121: v2(40.79,97.72) 41.13,98.05 UG1.BE7
  IN2 w0.089: v2(40.79,97.72) 40.67,97.72 40.26,97.3 39.24,97.3 39.02,97.07 39.02,96.83 38.21,96.02 37.65,96.02 37.15,95.52 35.63,95.52 35.16,95.05 31.66,95.05 29.54,97.18 26.21,97.18 24.85,98.54 23.58,98.54 22.57,99.54 21.65,99.54 20.66,100.52 19.64,100.52 18.33,101.83 17.4,101.83 v1(16.98,101.41)
  BOTTOM w0.14: v1(16.98,101.41) 16.98,101.75 16.46,102.28 16.18,102.28 15.75,102.71 15.75,103.82 16.38,104.45 16.82,104.45 17.27,104.9 17.27,105.54 17.41,105.68 18.06,105.68 RG125.1 18.84,106.46 UG4.4
GPIO27_IFPC_HPD: length 25.3
  TOP w0.102: v2(38.73,100.53) UG1.BA4
  TOP w0.14: RG12.2 18.76,102.11 QG4.3 19.47,101.57 v1(19.63,101.41)
  IN2 w0.089: v1(19.63,101.41) 20.31,102.1 23.45,102.1 24.92,100.63 28.23,100.63 28.34,100.52 29.28,100.52 30.25,99.55 31.56,99.55 32.54,98.56 34.49,98.56 36.08,100.15 38.35,100.15 v2(38.73,100.53)
GPIO27_IFPE_HPD_Q: length 2.7
  TOP w0.14: RG10.1 17.93,103.89 17.92,103.9 RG9.1 17.54,103.31 QG4.2
GPIO28_OC_WARN#: length 124.3
  TOP w0.102: v2(38.66,99.78) 38.68,99.8 38.7,99.8 UG1.BB4 ; RG7.2 33,105.77 32.72,105.49 RG8.2 v1(33.42,105.2)
  TOP w0.14: v1(39.24,33.57) 39.24,33.5 PR351.2
  IN1 w0.086: v1(19.37,91.18) 19.3,91.18 19.08,91.39 19.08,92.32 19.6,92.84 22.23,92.84 23.12,93.74 25,93.74 25.46,94.2 26.72,94.2 27.18,93.74 31.44,93.74 32.94,95.23 34.76,95.23 38.64,99.1 38.64,99.76 v2(38.66,99.78)
  IN2 w0.089: v1(39.24,33.57) 39.12,33.45 36.41,33.45 35.44,34.42 33.69,34.42 33.45,34.19 32.8,34.19 31.86,33.25 29.68,33.25 29.02,33.91 27.11,33.91 26.84,34.18 26.84,34.78 26.14,35.49 26.14,36.92 25.24,37.82 22.78,37.82 20.15,40.45 20.15,42.85 18.17,44.84 18.17,45.97 18.82,46.63 18.82,48.69 19.18,49.05 19.18,50.43 18.01,51.59 18.01,52.44 17.68,52.78 17.68,53.66 15.59,55.75 13.4,55.75 12.76,56.39 12.76,56.82 11.87,57.72 11.87,60.3 12.23,60.67 12.23,69.75 11.26,70.72 11.26,74.84 9.52,76.57 9.52,78.61 10.31,79.4 10.31,83.35 14.45,87.5 15.33,87.5 19.01,91.18 v1(19.37,91.18)
  BOTTOM w0.14: v1(33.42,105.2) 35.58,103.04 35.58,100.37 36.95,99 37.88,99 v2(38.66,99.78)
GPIO29_IDLE_IN_SW: length 6.6
  TOP w0.102: UG1.BA3 37.99,101.21 35.52,101.21 33.66,103.07 RG14.2
GPP_B2: length 15.1
  TOP w0.102: U14.BE32 218.56,24.09 218.56,23.67 218.77,23.46 218.77,22.67 219.02,22.42 219.02,21.56 219.7,20.87 219.7,20.51
  TOP w0.14: 219.7,20.51 219.7,18.71 219.59,18.59 219.59,18.16 219.28,17.86 218.82,17.86 218.32,17.36 218.32,16.56 217.73,15.97 v1(217.73,15.54) 217.73,15.37 R579.1 217.47,14.09 217.47,13.55 217.21,13.3 217.21,11.94 R620.1
GPP_B15: length 1.5
  TOP w0.14: v1(215.61,25.25) 215.6,25.25 U14.BB26
  BOTTOM w0.102: TP108.1 216.1,24.75 v1(215.61,25.25)
GPP_C11: length 11.1
  TOP w0.14: v1(215.28,28.31) 215.28,28.98 215.16,29.09 U14.AP24
  BOTTOM w0.102: 214.52,22.67 214.01,23.18 214.01,23.27 v1(213.75,23.53) 213.64,23.65 213.64,24.7 214.12,25.19 214.12,26.27 214.53,26.67 214.53,27.56 v1(215.28,28.31)
  BOTTOM w0.14: 214.52,22.67 214.52,20.9 215.24,20.18 R1059.2
GPP_G3: length 10.4
  TOP w0.102: U14.BF9 208,23.43 208,22.5 207.51,22.01 207.36,22.01 206.87,21.52 205.81,21.52
  TOP w0.14: R441.1 200.02,22.14 200.64,21.52 205.81,21.52
GPP_H21: length 3.4
  TOP w0.102: v1(225.61,33.24) 225.87,32.97 226.21,32.97 226.34,32.84 226.51,32.84 U14.AH48
  BOTTOM w0.14: v1(225.61,33.24) 224.66,33.24 224.01,32.59 R895.1
GPP_I14: length 30.1
  TOP w0.102: v1(207.13,30.29) U14.AM7
  TOP w0.14: v1(188.39,40.3) 188.39,40.46 R239.1
  IN3 w0.089: v1(207.13,30.29) 207.13,29.88 206.69,29.44 206.56,29.44 206.16,29.85 205.2,29.85 204.48,29.13 204.48,27.93 203.48,26.93 202.62,26.93 201.79,27.75 201.04,27.75 199.69,29.1 199.69,31.39 197.91,33.17 197.91,34 195,36.9 193.42,36.9 189.98,40.34 188.44,40.34 v1(188.39,40.3)
GPP_J0: length 8.7
  TOP w0.14: v1(206.24,28.34) 206.24,27.54 U14.AV6
  BOTTOM w0.14: v1(206.24,28.34) 206.24,27.76 205.99,27.51 204.35,27.51 v1(203.82,26.97) 203.47,26.62 202.14,26.62 201.62,27.14 200.94,27.14 R946.1
GPP_J1: length 18.7
  TOP w0.102: 197.94,27.69 198.17,27.45 201.75,27.45 202.24,26.95 203.1,26.95 203.2,27.04 204.39,27.04 U14.AY3
  TOP w0.14: Q34.2 190.19,31.76 190.19,30.12 190.34,29.96 v1(194.09,29.96) 195.09,29.96 195.83,29.23 196.28,29.23 196.63,28.88 197.06,28.88 197.39,28.56 R383.2 197.94,27.69
GPP_J8: length 5
  TOP w0.102: U14.AW2 203.66,27.38 203.26,27.78 200.13,27.78 R384.1
GPP_J9: length 17
  TOP w0.14: U14.AU9 207.49,27.58 207.48,27.58 v1(207.48,27.52) ; v1(198.42,24.38) v1(197.51,24.38) 197.39,24.5 R416.2 R404.1
  IN4 w0.086: v1(198.42,24.38) 198.44,24.35 199.2,24.35 200.29,25.44 200.29,26.45 201.09,27.25 201.77,27.25 202.08,26.94 203.98,26.94 204.54,27.5 206.11,27.5 206.27,27.65 207.03,27.65 207.16,27.52 v1(207.48,27.52)
  BOTTOM w0.102: v1(207.48,27.52) 207.48,28.05 207.82,28.39 207.82,28.79 207.29,29.32 R914.1
GPP_J10: length 17
  TOP w0.14: v1(206.74,27.21) 206.8,27.27 U14.AV7
  IN3 w0.089: v1(215.31,25.81) 216.07,26.58 216.07,27.25 215.61,27.7 215.21,27.7 213.94,26.43 213.53,26.43 213.2,26.76 213.2,27.09 213.02,27.27 212.49,27.27 211.7,26.48 211.18,26.48 210.97,26.7 209.73,26.7 209.19,27.25 208.17,27.25 207.94,27.02 206.94,27.02 v1(206.74,27.21)
  BOTTOM w0.102: v1(215.31,25.81) 215.62,25.81 216.51,24.92 216.51,23.47 R998.1
GPP_K21: length 7
  TOP w0.14: U14.T45 225.47,38.3 225.56,38.21 226.85,38.21 227.02,38.04 227.76,38.04 v1(228.32,38.6)
  BOTTOM w0.14: v1(228.32,38.6) 228.32,37.81 228.49,37.64 R852.2 229.39,37.01 230.05,37.01 R856.1
GPU_ADC_INN: length 119.3
  TOP w0.102: v2(43.63,94.91) 43.63,94.91 43.63,94.93 UG1.BJ11
  TOP w0.127: PR339.1 46.71,38.92 46.71,39.21 v1(46.83,39.33)
  IN1 w0.127: v1(21.75,87.98) 21.5,88.23 21.5,89.09 21.83,89.42 34.16,89.42 34.77,90.04 35.92,90.04 36.98,91.09 37.55,91.09 38.17,91.71 38.99,91.71 40.38,93.11 42.62,93.11 43.66,94.15 43.66,94.89 v2(43.63,94.91)
  IN2 w0.127: v1(21.75,87.98) 21.5,88.22 21.5,88.66 21.01,89.15 17.67,89.15 15.56,87.04 14.39,87.04 11.12,83.77 11.12,76.19 11.91,75.4 11.91,71.51 12.54,70.88 12.54,61.16 13.05,60.65 13.05,60.35 13.05,60.25 13.05,59.95 15.34,57.65 15.34,56.98 17.36,54.96 18.87,54.96 19.53,54.3 19.53,53.14 20.84,51.82 20.84,47.34 22.34,45.84 25.44,45.84 27.99,43.29 27.99,40.43 27.45,39.9 27.45,38.97 28.28,38.14 29.87,38.14 31.49,39.77 31.49,40.22 31.69,40.41 36.1,40.41 37.41,39.11 43.97,39.11 44.46,38.62 45.83,38.62 46.12,38.91 46.35,38.91 46.77,39.33 v1(46.83,39.33)
  BOTTOM w0.127: v2(43.63,94.91) 43.8,94.74 43.8,93.87 CG869.2
GPU_ADC_INP: length 117
  TOP w0.102: v2(42.88,94.92) UG1.BJ9
  TOP w0.127: PR338.1 46.46,38.83 46.46,39.05 v1(46.18,39.33)
  IN1 w0.127: v2(42.88,94.92) 43.04,94.92 43.4,94.56 43.4,94.25 42.51,93.36 40.28,93.36 38.88,91.96 38.06,91.96 37.44,91.34 36.87,91.34 35.82,90.29 34.66,90.29 34.05,89.68 21.72,89.68 21.24,89.2 21.24,88.11 21.12,87.98 21.08,87.98 21.08,87.99 v1(21.08,87.99)
  IN2 w0.127: v1(21.08,87.99) 21.08,87.99 21.08,87.98 21.12,87.98 21.25,88.11 21.25,88.55 20.91,88.89 17.78,88.89 15.67,86.78 14.5,86.78 11.37,83.66 11.37,76.29 12.16,75.51 12.16,71.62 12.79,70.98 12.79,61.27 13.3,60.76 13.3,60.25 13.3,60.05 15.6,57.76 15.6,57.09 17.47,55.21 18.97,55.21 19.78,54.41 19.78,53.24 21.1,51.93 21.1,47.45 22.45,46.09 25.54,46.09 28.24,43.4 28.24,40.33 27.7,39.79 27.7,39.07 28.38,38.4 29.76,38.4 31.24,39.87 31.24,40.33 31.58,40.67 36.21,40.67 37.51,39.36 44.07,39.36 44.56,38.87 45.72,38.87 v1(46.18,39.33)
  BOTTOM w0.127: CG865.2 42.51,95.29 v2(42.88,94.92)
GPU_CLK: length 185.7
  TOP w0.102: 47.88,98.05 47.68,98.25 v2(47.68,98.5)
  TOP w0.105: 47.88,98.05 UG1.BE17
  IN4 w0.086: v1(43.68,165.09) 43.88,165.29 48.02,165.29 48.88,166.15 53.69,166.15 54.2,166.66 56.9,166.66 58.48,165.08 62.43,165.08 64.02,163.49 64.02,162.49 64.75,161.76 68.96,161.76 69.42,161.31 70.67,161.31 71.33,161.97 74.02,161.97 74.47,161.52 80.48,161.52 81.03,160.97 82.81,160.97 83.7,160.07 84.41,160.07 89.11,155.37 89.11,150.49 90.59,149.01 93.47,149.01 94.37,148.12 94.37,146.53 97.7,143.21 97.7,137.41 103.26,131.84 103.26,100.37 101.47,98.58 101.47,96.54 98.75,93.82 85.51,93.82 81.12,89.43 75.78,89.43 73.97,87.62 60.17,87.62 58.67,89.12 56.69,89.12 55.95,89.86 55.95,91.79 55.46,92.27 51.81,92.27 50.06,94.02 49.32,94.02 48.89,94.45 48.89,95.93 48.61,96.21 48.61,97.34 48.12,97.83 47.88,97.83 47.68,98.03 v2(47.68,98.5)
  BOTTOM w0.14: v1(43.68,165.09) 43.83,165.24 44.17,165.24 44.36,165.04 C499.2
GPU_CLK#: length 185.7
  TOP w0.102: UG1.BF17 47.97,97.53 v2(47.67,97.53)
  IN4 w0.086: v1(43.68,165.75) 43.91,165.53 47.92,165.53 48.78,166.39 53.59,166.39 54.1,166.9 57,166.9 58.57,165.32 62.53,165.32 64.26,163.59 64.26,162.59 64.85,162 69.06,162 69.52,161.55 70.57,161.55 71.23,162.21 74.12,162.21 74.57,161.76 80.58,161.76 81.13,161.2 82.91,161.2 83.8,160.31 84.51,160.31 89.35,155.46 89.35,150.59 90.69,149.25 93.57,149.25 94.61,148.22 94.61,146.63 97.94,143.31 97.94,137.51 103.5,131.94 103.5,100.27 101.71,98.48 101.71,96.44 98.84,93.58 85.61,93.58 81.22,89.2 75.88,89.2 74.06,87.38 60.07,87.38 58.57,88.88 56.59,88.88 55.71,89.76 55.71,91.69 55.36,92.04 51.71,92.04 49.96,93.78 49.22,93.78 48.65,94.35 48.65,95.83 48.37,96.11 48.37,97.24 48.02,97.59 47.73,97.59 v2(47.67,97.53)
  BOTTOM w0.14: C498.2 44.36,165.8 44.22,165.65 43.78,165.65 v1(43.68,165.75)
GPU_CLK#_C: length 4.3
  BOTTOM w0.14: U34.48 48.82,165.56 48.63,165.75 47.18,165.75 47.09,165.66 45.44,165.66 C498.1
GPU_CLK_C: length 4.3
  BOTTOM w0.14: U34.47 48.63,165.16 48.46,165.33 47.35,165.33 47.26,165.24 45.44,165.24 C499.1
GPU_D0: length 180.9
  TOP w0.102: v2(49.22,96.31) 48.76,96.31 48.66,96.41 48.66,96.57 48.74,96.65 UG1.BG18
  IN4 w0.086: v2(49.22,96.31) 49.33,96.2 49.33,95.35 51.2,93.48 51.87,93.48 52.03,93.32 52.48,93.32 52.92,92.88 57.62,92.88 57.73,92.77 61.89,92.77 63.56,91.1 69.28,91.1 69.77,90.61 69.77,89.58 70.63,88.73 72.58,88.73 73.97,90.11 80.45,90.11 85.54,95.21 90.29,95.21 91.08,94.42 98.37,94.42 100.82,96.86 100.82,98.83 102.65,100.66 102.65,131.58 97.08,137.14 97.08,142.69 93.35,146.42 91.76,146.42 90.57,147.62 88.11,147.62 87.58,148.14 87.58,155.96 84.3,159.25 83.69,159.25 82.57,160.36 80.23,160.36 79.67,160.92 74.15,160.92 73.7,161.38 71.58,161.38 70.62,160.42 67.92,160.42 67.84,160.51 67.84,160.94 67.61,161.17 66.99,161.17 66.77,160.94 66.77,160.51 66.68,160.42 65.51,160.42 64.86,161.06 64.6,161.06 63.11,162.55 63.11,162.73 61.53,164.31 58.4,164.31 57.27,165.45 50.31,165.45 49.76,164.9 48.66,164.9 47.86,164.1 46.97,164.1 45.92,163.04 45.22,163.04 44.96,163.31 44.96,163.66 45.11,163.82 45.21,163.82 v1(45.44,163.6)
  BOTTOM w0.14: v1(45.44,163.6) 45.54,163.7 45.96,163.7 C504.2
GPU_D0#: length 180.9
  TOP w0.102: UG1.BF18 48.85,97.35 49.16,97.04 v2(49.22,97.04)
  IN4 w0.086: v1(45.42,164.32) 45.17,164.06 45.01,164.06 44.72,163.76 44.72,163.21 45.12,162.81 46.02,162.81 47.07,163.86 47.96,163.86 48.76,164.66 49.86,164.66 50.41,165.21 57.17,165.21 58.3,164.07 61.43,164.07 62.87,162.63 62.87,162.46 64.51,160.82 64.76,160.82 65.41,160.18 66.78,160.18 67,160.41 67,160.84 67.09,160.93 67.51,160.93 67.6,160.84 67.6,160.41 67.82,160.18 70.72,160.18 71.68,161.14 73.6,161.14 74.05,160.68 79.57,160.68 80.13,160.12 82.47,160.12 83.59,159.01 84.2,159.01 87.34,155.86 87.34,148.04 88.01,147.38 90.47,147.38 91.66,146.18 93.25,146.18 96.84,142.59 96.84,137.04 102.41,131.48 102.41,100.75 100.58,98.92 100.58,96.96 98.27,94.66 91.18,94.66 90.39,95.44 85.44,95.44 80.35,90.35 73.87,90.35 72.48,88.97 70.72,88.97 70.01,89.68 70.01,90.71 69.38,91.34 63.65,91.34 61.99,93.01 57.83,93.01 57.71,93.12 53.02,93.12 52.58,93.56 52.13,93.56 51.97,93.72 51.3,93.72 49.57,95.45 49.57,96.42 49.2,96.97 v2(49.22,97.04)
  BOTTOM w0.14: C503.2 45.92,164.12 45.62,164.12 v1(45.42,164.32)
GPU_D0#_C: length 2.4
  BOTTOM w0.14: U34.45 48.2,164.36 47.97,164.13 47.32,164.13 C503.1
GPU_D0_C: length 2.5
  BOTTOM w0.14: U34.44 48.81,163.96 48.79,163.94 48.38,163.94 48.14,163.71 47.31,163.71 C504.1
GPU_D1: length 179.6
  TOP w0.102: v2(49.92,95.62) 49.93,95.62 50.25,95.95 UG1.BH20
  IN4 w0.086: v1(42.8,161.94) 42.54,161.68 42.54,161.53 42.63,161.45 43.65,161.45 44.38,162.17 46.44,162.17 47.08,162.8 48.65,162.8 48.71,162.87 48.71,163.47 48.98,163.74 49.51,163.74 49.81,163.44 49.81,161.86 50.02,161.66 54.06,161.66 54.53,162.12 54.53,162.76 55.88,164.11 57.19,164.11 57.83,163.48 59.75,163.48 61.56,161.66 62.81,161.66 64.26,160.21 64.31,160.21 65.55,158.97 66.43,158.97 67.02,159.56 70.94,159.56 71.68,160.3 73.55,160.3 74.49,159.36 80.5,159.36 80.89,158.97 82.78,158.97 86.74,155.01 86.74,147.61 88.79,145.57 92.98,145.57 96.24,142.3 96.24,138.18 95.47,137.41 95.47,136.88 101.81,130.54 101.81,101.01 99.46,98.66 99.46,96.92 97.85,95.31 91.66,95.31 90.88,96.09 84.72,96.09 80.58,91.95 63.93,91.95 62.27,93.61 58.21,93.61 58.1,93.71 53.32,93.71 52.89,94.15 51.61,94.15 50.71,95.05 50.71,95.37 50.16,95.92 50.01,95.92 49.92,95.83 v2(49.92,95.62)
  BOTTOM w0.14: C506.2 43.85,162.46 42.8,162.46 42.66,162.32 42.66,162.08 v1(42.8,161.94)
GPU_D1#: length 179.6
  TOP w0.102: UG1.BG20 50.25,96.63 v2(49.92,96.31)
  IN4 w0.086: v1(42.1,161.91) 42.3,161.71 42.3,161.43 42.53,161.21 43.75,161.21 44.48,161.93 46.54,161.93 47.17,162.56 48.75,162.56 48.95,162.77 48.95,163.37 49.08,163.5 49.41,163.5 49.57,163.34 49.57,161.76 49.92,161.42 54.16,161.42 54.77,162.03 54.77,162.66 55.98,163.87 57.09,163.87 57.73,163.24 59.65,163.24 61.46,161.42 62.71,161.42 64.16,159.98 64.21,159.98 65.45,158.73 66.53,158.73 67.12,159.32 71.04,159.32 71.78,160.06 73.45,160.06 74.39,159.12 80.4,159.12 80.79,158.73 82.68,158.73 86.51,154.91 86.51,147.51 88.69,145.33 92.88,145.33 96.01,142.21 96.01,138.28 95.23,137.5 95.23,136.78 101.57,130.44 101.57,101.11 99.22,98.76 99.22,97.01 97.75,95.55 91.76,95.55 90.98,96.33 84.62,96.33 80.48,92.19 64.03,92.19 62.37,93.85 58.3,93.85 58.2,93.95 53.42,93.95 52.99,94.39 51.71,94.39 50.95,95.15 50.95,95.47 50.26,96.16 50.07,96.16 v2(49.92,96.31)
  BOTTOM w0.14: C505.2 44.17,162.88 42.63,162.88 42.24,162.5 42.24,162.06 v1(42.1,161.91)
GPU_D1#_C: length 4.5
  BOTTOM w0.14: U34.42 48.51,163.16 48.17,162.82 47.24,162.82 47.13,162.71 45.4,162.71 C505.1
GPU_D1_C: length 4.5
  BOTTOM w0.14: U34.41 48.7,162.76 48.34,162.4 47.41,162.4 47.3,162.29 45.38,162.29 C506.1
GPU_D2: length 176.5
  TOP w0.102: v2(50.59,97.69) 50.65,97.75 50.65,98.3 50.52,98.42 50.14,98.42 50.04,98.32 50.04,98.15 50.14,98.05 UG1.BE20
  IN4 w0.086: v2(50.59,97.69) 50.43,97.69 50.35,97.6 50.35,97.45 50.74,97.06 50.74,96.36 51.76,95.34 52.51,95.34 52.92,95.75 53.48,95.75 54.07,95.16 54.43,95.16 54.87,95.61 55.71,95.61 56.26,95.06 56.81,95.06 57.22,95.47 57.98,95.47 58.29,95.16 59.04,95.16 59.29,95.4 60.13,95.4 60.45,95.08 61.2,95.08 61.56,95.44 62.17,95.44 62.83,94.78 62.83,94.57 64.32,93.08 79.78,93.08 84.13,97.44 94.84,97.44 95.46,98.06 97.3,98.06 100.73,101.49 100.73,120.28 100.4,120.62 100.4,123.08 100.73,123.41 100.73,130.08 94.4,136.42 94.4,137.86 95.17,138.63 95.17,141.85 92.73,144.29 88.39,144.29 85.61,147.06 85.61,154.63 82.34,157.9 80.38,157.9 80,158.28 67.41,158.28 67.02,157.89 65.1,157.89 63.88,159.11 62.78,159.11 61.49,160.41 59.79,160.41 59.42,160.78 59.42,162.28 59.3,162.41 58.92,162.41 58.82,162.31 58.82,160.71 58.58,160.47 57.98,160.47 57.75,160.7 57.75,162.31 57.65,162.41 57.26,162.41 57.16,162.31 57.16,160.48 56.93,160.26 56.33,160.26 56.09,160.5 56.09,161.32 56,161.41 55.59,161.41 55.49,161.3 55.49,160.81 55.27,160.59 49.57,160.59 49.09,161.07 48.1,161.07 48,160.97 48,160.68 47.73,160.42 47.15,160.42 46.92,160.65 46.92,160.97 46.82,161.07 46.43,161.07 46.08,160.72 45.76,160.72 v1(45.55,160.52)
  BOTTOM w0.14: v1(45.55,160.52) 45.62,160.58 45.97,160.58 C510.2
GPU_D2#: length 176.4
  TOP w0.102: UG1.BF20 v2(49.9,97.7)
  IN4 w0.086: v1(45.54,161.2) 45.78,160.96 45.98,160.96 46.34,161.31 46.92,161.31 47.16,161.06 47.16,160.75 47.25,160.66 47.64,160.66 47.76,160.78 47.76,161.06 48,161.31 49.18,161.31 49.67,160.82 55.17,160.82 55.25,160.91 55.25,161.4 55.49,161.64 56.1,161.64 56.33,161.42 56.33,160.6 56.43,160.49 56.83,160.49 56.92,160.58 56.92,162.41 57.16,162.65 57.75,162.65 57.99,162.4 57.99,160.8 58.08,160.71 58.49,160.71 58.59,160.81 58.59,162.4 58.83,162.65 59.4,162.65 59.66,162.38 59.66,160.88 59.89,160.65 61.58,160.65 62.88,159.35 63.98,159.35 65.19,158.13 66.92,158.13 67.31,158.52 80.09,158.52 80.48,158.14 82.44,158.14 85.85,154.73 85.85,147.16 88.48,144.53 92.83,144.53 95.41,141.95 95.41,138.53 94.63,137.76 94.63,136.52 100.97,130.18 100.97,123.31 100.64,122.98 100.64,120.71 100.97,120.38 100.97,101.39 97.4,97.82 95.56,97.82 94.94,97.2 84.23,97.2 79.87,92.84 64.22,92.84 62.59,94.47 62.59,94.68 62.07,95.21 61.66,95.21 61.3,94.84 60.35,94.84 60.03,95.16 59.39,95.16 59.14,94.92 58.19,94.92 57.88,95.23 57.32,95.23 56.91,94.82 56.16,94.82 55.61,95.37 54.97,95.37 54.53,94.93 53.97,94.93 53.38,95.52 53.02,95.52 52.6,95.1 51.66,95.1 50.5,96.26 50.5,96.96 50.11,97.35 50.11,97.49 v2(49.9,97.7)
  BOTTOM w0.14: v1(45.54,161.2) 45.74,161 45.91,161 C507.2
GPU_D2#_C: length 2.7
  BOTTOM w0.14: U34.39 48.62,161.96 47.69,161.03 47.32,161.03 C507.1
GPU_D2_C: length 2.7
  BOTTOM w0.14: C510.1 47.32,160.61 47.87,160.61 48.82,161.56 U34.38
GPU_DDCCLK: length 102
  TOP w0.102: 40.39,88.71 40.54,88.86 40.54,88.97 41.26,89.69 41.26,89.93 43.08,91.75 43.08,93.53 42.88,93.72 42.88,93.96 42.65,94.19 42.38,94.19 42.29,94.28 42.29,94.44 42.4,94.55 UG1.BK9
  TOP w0.14: v1(39.5,82.89) 39.47,82.89 39.51,82.93 39.51,83.23 39.64,83.35 RG57.2 39.22,84 39.22,84.53 39.53,84.84 39.53,85.63 39.35,85.8 39.35,87.68 40.39,88.71
  IN1 w0.086: v1(9.28,138.36) 9.28,137.85 7.5,136.07 7.5,108.39 7.93,107.96 7.93,105.62 9.32,104.22 13.9,104.22 15.38,102.75 15.38,99.73 16.62,98.49 16.62,93.76 17.04,93.34 17.04,91.71 17.42,91.33 17.42,90.34 18.03,89.73 18.03,86.88 19.12,85.79 20.07,85.79 22.4,83.47 22.4,83.05 24.66,80.78 27.14,80.78 27.78,81.42 30.4,81.42 31.02,82.03 36.25,82.03 37.29,83.07 37.85,83.07 38.35,82.57 39.18,82.57 v1(39.5,82.89)
  BOTTOM w0.14: v1(9.28,138.36) 9.28,138.6 9.52,138.84 R677.1 ; R682.1 9.8,138.5 9.85,138.56 R677.1 ; R676.1 R677.1
GPU_DDCCLK_Q: length 67.3
  IN4 w0.086: v1(9.49,136.46) 9.49,136.77 9.67,136.95 11.02,136.95 11.81,137.74 11.81,138.84 12.64,139.67 12.64,142.76 14.83,144.95 17.61,144.95 20.01,147.35 20.01,147.61 20.97,148.58 21.68,148.58 22.15,149.05 22.15,154.14 21.57,154.73 21.57,155.46 21.77,155.67 21.77,156.3 22.66,157.19 23.1,157.63 23.1,158.94 24.35,160.19 26.93,160.19 27.28,159.84 28.23,159.84 28.75,159.33 29.69,159.33 30.23,159.87 33.85,159.87 35.31,158.41 36.4,158.41 37.15,159.16 41.67,159.16 42.13,159.62 48.89,159.62 48.97,159.53 48.97,159.4 49.06,159.31 49.23,159.31 49.32,159.4 49.32,159.53 49.4,159.62 49.58,159.62 49.66,159.53 49.66,159.4 49.75,159.31 49.92,159.31 50.01,159.4 50.01,159.53 50.1,159.62 50.42,159.62 50.51,159.53 v1(50.51,159.43)
  BOTTOM w0.14: U34.34 50.82,159.73 v1(50.51,159.43) 51.1,158.84 51.1,158.36 50.96,158.22 R656.2 ; v1(9.49,136.46) 9.34,136.61 9.34,136.93 9.48,137.07 R682.2 10.06,137.33 10.55,137.33 R681.1
GPU_DDCDATA: length 102
  TOP w0.102: UG1.BL9 42.55,93.77 42.88,93.44 42.88,91.84 41.05,90.02 41.05,89.87 40.09,88.9
  TOP w0.14: v1(38.55,82.97) 38.63,83.05 RG56.1 38.91,83.91 38.91,84.65 39.26,85 39.26,85.52 39.08,85.7 39.08,87.77 39.99,88.69 39.99,88.8 40.09,88.9
  IN1 w0.086: v1(38.55,82.97) 38.24,83.29 37.21,83.29 36.18,82.26 30.95,82.26 30.32,81.63 27.69,81.63 27.05,81 24.75,81 22.61,83.14 22.61,83.56 20.16,86.01 19.44,86.01 18.29,87.15 18.29,89.8 17.65,90.44 17.65,91.4 17.25,91.8 17.25,93.43 16.83,93.85 16.83,98.58 15.59,99.82 15.59,102.84 13.99,104.44 9.41,104.44 8.14,105.71 8.14,108.05 7.71,108.48 7.71,135.98 9.86,138.13 9.86,139.19 9.61,139.44 v1(8.13,139.44)
  BOTTOM w0.14: R679.2 7.53,138.84 v1(8.13,139.44) 8.13,139.2 8.48,138.84 R678.1 R683.1
GPU_DDCDATA_Q: length 66.6
  IN4 w0.086: v1(8.81,136.36) 9.61,137.16 10.96,137.16 11.62,137.82 11.62,138.95 12.43,139.75 12.43,142.85 14.74,145.16 17.56,145.16 19.82,147.42 19.82,147.73 20.86,148.76 21.61,148.76 21.94,149.1 21.94,154.09 21.38,154.65 21.38,155.54 21.58,155.74 21.58,156.38 22.92,157.71 22.92,159.02 24.27,160.38 27.01,160.38 27.36,160.03 28.31,160.03 28.82,159.51 29.61,159.51 30.16,160.06 33.93,160.06 35.39,158.6 36.29,158.6 37.08,159.39 41.64,159.39 42.07,159.83 50.89,159.83 v1(51.22,159.5)
  BOTTOM w0.14: R684.1 R683.2 8.78,136.39 v1(8.81,136.36) ; U34.33 v1(51.22,159.5) 51.38,159.34 51.38,158.42 R655.2
GPU_GPIO24_IFPF_HPD: length 37.7
  TOP w0.102: v2(39.38,98.37) 39.38,98.38 UG1.BD5
  IN2 w0.089: v1(13.44,102.76) 14.46,102.76 15.2,102.02 18.41,102.02 19.45,100.98 19.86,100.98 20.57,101.7 21.53,101.7 22.94,100.29 26.66,100.29 26.97,99.98 26.97,98.76 26.51,98.3 26.51,98.06 27.01,97.56 29.69,97.56 31.82,95.44 35.01,95.44 35.47,95.9 36.68,95.9 39,98.22 39.24,98.22 v2(39.38,98.37)
  BOTTOM w0.14: v1(13.44,102.76) 13.31,102.63 RG133.1 12.72,102.66 RG130.2 13.82,103.72 v1(14.2,103.34) 14.52,103.34 Q64.3
GPU_IFPB_I2C_SCL: length 51.4
  TOP w0.105: v2(44.99,95.61) 44.65,95.95 UG1.BH12
  TOP w0.14: RG54.1 26.78,84.21 26.39,83.82 26.38,83.82 v1(25.93,83.36) 25.78,83.36 25.54,83.11 QG14.4 24.87,83.11 24.38,82.62 23.87,82.62 23.78,82.71 RG58.2
  IN1 w0.086: v1(25.93,83.36) 26.18,83.61 33.28,83.61 33.82,84.16 34.02,84.16 34.51,84.64 34.51,87.7 35.49,88.68 36.56,88.68 37.39,89.51 41.56,89.51 42.68,90.63 42.68,91.37 44.76,93.45 44.76,95.38 v2(44.99,95.61)
  BOTTOM w0.14: QG20.4 10.6,82.42 10.74,82.56 12.9,82.56 14.08,83.74 14.08,84.16 14.51,84.59 14.51,84.71 16.38,86.58 19.78,86.58 20.03,86.33 20.59,86.33 23.09,83.83 25.46,83.83 v1(25.93,83.36)
GPU_IFPB_I2C_SDA: length 58.8
  TOP w0.105: UG1.BG12 44.65,96.65 45,96.3 v2(45,96.27)
  TOP w0.14: RG59.2 27.25,81.57 QG14.1 26.4,81.81 v1(26.18,82.03) 25.52,81.37 24.46,81.37 RG66.1
  IN1 w0.086: v1(26.18,82.03) 25.83,82.03 25.24,82.62 25.24,83.28 25.92,83.95 33.13,83.95 33.68,84.5 33.88,84.5 34.17,84.79 34.17,87.84 35.35,89.02 36.42,89.02 37.25,89.85 41.42,89.85 42.34,90.77 42.34,91.51 44.42,93.59 44.42,95.69 v2(45,96.27)
  BOTTOM w0.14: QG20.1 9.3,84.44 10.02,85.16 13.51,85.16 14,85.65 14.19,85.65 14.91,86.37 15.59,86.37 16.25,87.03 17.72,87.03 17.89,86.86 19.97,86.86 20.26,86.57 20.74,86.57 21.88,85.43 22.04,85.43 23.25,84.22 26.26,84.22 27.26,83.22 27.26,82.98 26.31,82.03 v1(26.18,82.03)
GPU_TBT_AUXN: length 271.2
  TOP w0.105: UG1.BH11 43.95,95.95 43.67,95.67 43.65,95.67 43.65,95.62 v2(43.63,95.62)
  TOP w0.14: v1(246.57,41.91) 246.84,41.91 247.02,41.73 247.02,41.47 246.23,40.68 245.75,40.68 245.61,40.82 C230.1
  IN4 w0.086: v1(246.57,41.91) 246.89,41.91 246.98,42 246.98,42.28 246.86,42.4 245.61,42.4 245.04,41.82 245.04,41.28 244.49,40.73 240.43,40.73 239.5,41.66 237.75,41.66 236.65,42.76 235.86,42.76 235.34,42.25 234.86,42.25 234.17,42.94 231.48,42.94 231.15,42.61 228.4,42.61 227.5,43.52 226.3,43.52 225.39,42.61 224.54,42.61 223.83,41.9 223.83,41.34 223.34,40.85 222.8,40.85 222.29,41.36 221.84,41.36 220.67,40.19 216.18,40.19 214.72,41.65 214.72,42.1 213.51,43.32 213.51,43.79 211.61,45.69 211.61,47.32 209.26,49.67 208.49,49.67 207.57,48.76 203.48,48.76 202.95,49.29 202.95,52.64 200.69,54.91 199.37,54.91 199.3,54.98 193.58,54.98 193.41,55.15 191.89,55.15 191.09,54.34 189.45,54.34 188.74,55.04 188.4,55.04 188.01,55.44 186.48,55.44 185.29,56.63 183.35,56.63 181.42,58.56 181.42,59.23 179.27,61.38 179.27,62.08 177.81,63.54 177.81,63.86 177.44,64.23 177.44,64.52 165.2,76.75 109.32,76.75 106.79,74.22 106.47,74.22 105.84,73.59 103.36,73.59 100.78,76.17 99.93,76.17 98.96,77.15 98.46,77.15 97.76,77.84 94.09,77.84 93.77,78.17 92.93,78.17 92.6,77.84 89.6,77.84 88.32,79.13 56.28,79.13 55.54,79.86 53.06,79.86 52.5,79.31 50.9,79.31 50.46,79.74 49.3,80.91 49.1,80.91 45.53,84.48 45.53,86.21 44.06,87.67 44.06,91.24 43.45,91.85 43.45,93.01 44,93.55 44,95.78 43.89,95.9 43.7,95.9 43.65,95.85 43.65,95.62 v2(43.63,95.62)
  BOTTOM w0.14: RG170.2 45.09,92.94 44.93,93.1 44.6,93.1 44.32,93.39 44.32,94.5 44.19,94.63 44.19,95.66 44.01,95.84 43.79,95.84 43.65,95.7 43.65,95.62 v2(43.63,95.62) ; C731.2 257.67,51.39 256.71,51.39 249.84,44.52 248.26,44.52 247.72,43.98 247.72,43.35 246.75,42.38 246.75,42.09 v1(246.57,41.91)
GPU_TBT_AUXP: length 271.1
  TOP w0.105: UG1.BG11 43.95,96.65 43.64,96.34 v2(43.64,96.31)
  TOP w0.14: v1(247.48,41.91) 247.34,41.77 247.34,41.34 246.36,40.36 245.67,40.36 C233.1
  IN4 w0.086: v2(43.64,96.31) 43.74,96.31 43.97,96.08 44.19,95.86 44.19,93.48 43.64,92.93 43.64,91.93 44.25,91.32 44.25,87.75 45.71,86.29 45.71,84.56 49.18,81.1 49.37,81.1 50.98,79.49 52.42,79.49 52.98,80.05 55.62,80.05 56.36,79.32 88.4,79.32 89.68,78.03 92.53,78.03 92.85,78.36 93.84,78.36 94.17,78.03 97.84,78.03 98.54,77.33 99.04,77.33 100.01,76.36 100.86,76.36 103.44,73.78 105.77,73.78 106.39,74.41 106.71,74.41 109.24,76.94 165.28,76.94 177.63,64.59 177.63,64.31 178,63.94 178,63.62 179.45,62.16 179.45,61.46 181.61,59.31 181.61,58.64 183.43,56.82 185.36,56.82 186.56,55.63 188.09,55.63 188.48,55.23 188.82,55.23 189.52,54.53 191.01,54.53 191.81,55.34 193.49,55.34 193.66,55.17 199.37,55.17 199.45,55.09 200.77,55.09 203.14,52.72 203.14,49.36 203.56,48.95 207.5,48.95 208.41,49.86 209.34,49.86 211.8,47.4 211.8,45.76 213.7,43.86 213.7,43.39 214.91,42.18 214.91,41.72 216.26,40.38 220.59,40.38 221.76,41.55 222.37,41.55 222.88,41.04 223.26,41.04 223.64,41.42 223.64,41.98 224.46,42.8 225.31,42.8 226.22,43.7 227.58,43.7 228.48,42.8 231.07,42.8 231.4,43.13 234.25,43.13 234.94,42.43 235.26,42.43 235.78,42.95 236.72,42.95 237.83,41.85 239.58,41.85 240.51,40.92 244.42,40.92 244.85,41.35 244.85,41.9 245.53,42.59 246.94,42.59 247.17,42.36 247.17,42.07 247.32,41.91 v1(247.48,41.91)
  BOTTOM w0.14: C737.2 257.8,50.75 257.8,50.97 257.69,51.07 256.84,51.07 249.97,44.2 248.39,44.2 248.04,43.84 248.04,43.22 247.07,42.25 247.07,42.13 247.29,41.91 v1(247.48,41.91) ; v2(43.64,96.31) 43.79,96.16 44.14,96.16 44.51,95.79 44.51,94.76 44.63,94.64 44.63,93.52 44.73,93.42 44.93,93.42 45.09,93.58 RG166.2
GPU_TBT_D0: length 214.6
  TOP w0.102: 53.38,96.38 53.38,96.53 53.25,96.65 53.1,96.65
  TOP w0.105: 53.1,96.65 UG1.BG24 ; v2(53.38,96.32) 53.38,96.38
  TOP w0.14: C167.1 238.68,50.08 238.11,50.08 234.62,53.57 229.36,53.57 226.78,56.15 221.48,56.15 220.82,56.81 216.02,56.81 213.3,59.53 208.32,59.53 206.98,60.86 203.13,60.86 201.67,62.32 197.88,62.32 197.69,62.13 195.02,62.13 194.83,62.32 193.03,62.32 192.41,62.95 190.75,62.95 190.23,63.47 187.7,63.47 186.29,64.88 186.29,65.09 180.01,71.37 178.35,71.37 164.99,84.73 107.03,84.73 106.49,85.26 103.16,85.26 102.88,85.54 v1(102.88,85.55)
  IN2 w0.089: v2(53.38,96.32) 53.38,96.59 53.29,96.68 53.2,96.68 53.02,96.5 53.02,95.89 53.19,95.72 53.19,94.36 53.79,93.76 55.84,93.76 58.09,91.52 58.09,89.6 60.04,87.65 81.39,87.65 86.89,93.15 94.92,93.15 101.78,86.3 101.78,85.8 102.5,85.07 102.79,85.07 102.88,85.16 v1(102.88,85.55)
GPU_TBT_D0#: length 214.6
  TOP w0.105: UG1.BF24 53.05,97.35 53.38,97.02 v2(53.38,97.02)
  TOP w0.14: C172.1 238.75,49.76 237.98,49.76 234.49,53.25 229.23,53.25 226.65,55.83 221.35,55.83 220.69,56.49 215.89,56.49 213.17,59.21 208.18,59.21 206.85,60.54 203,60.54 201.54,62.01 198.02,62.01 197.83,61.81 194.89,61.81 194.7,62.01 192.9,62.01 192.28,62.63 190.62,62.63 190.1,63.15 187.57,63.15 185.97,64.75 185.97,64.96 179.88,71.05 178.21,71.05 164.86,84.41 106.9,84.41 106.36,84.95 103.18,84.95 v1(102.88,84.65)
  IN2 w0.089: v2(53.38,97.02) 53.26,96.89 53.11,96.89 52.8,96.59 52.8,95.8 52.97,95.63 52.97,94.27 53.7,93.55 55.75,93.55 57.87,91.43 57.87,89.51 59.95,87.43 81.48,87.43 86.98,92.94 94.83,92.94 101.56,86.21 101.56,85.71 102.41,84.86 102.67,84.86 v1(102.88,84.65)
GPU_TBT_D1: length 218.6
  TOP w0.105: v2(52.02,98.38) 52.35,98.05 UG1.BE23
  TOP w0.14: C182.1 238.71,48.59 238.21,48.59 234.19,52.61 228.96,52.61 226.38,55.19 221.08,55.19 220.42,55.85 215.62,55.85 212.93,58.54 207.71,58.54 206.36,59.9 202.16,59.9 200.7,61.36 198.38,61.36 198.19,61.17 194.51,61.17 194.32,61.36 192.58,61.36 191.95,61.98 190.32,61.98 189.8,62.5 187.3,62.5 185.32,64.48 185.32,64.69 179.61,70.41 177.95,70.41 164.95,83.4 107.98,83.4 107.7,83.68 105.77,83.68 105.47,83.99 102.73,83.99 102.59,83.85 102.36,83.85 v1(102.13,84.08)
  IN2 w0.089: v2(52.02,98.38) 52.02,98.14 52.13,98.03 52.46,98.03 52.68,97.82 52.68,96.87 52.55,96.74 52.55,95.4 52.5,95.35 52.5,94.08 53.51,93.07 54.95,93.07 55.86,92.16 55.86,89.19 58.09,86.96 81.68,86.96 87.12,92.41 94.51,92.41 101.09,85.83 101.09,84 101.27,83.83 101.88,83.83 v1(102.13,84.08)
GPU_TBT_D1#: length 218.6
  TOP w0.105: UG1.BF23 52.35,97.35 52.03,97.67 v2(51.99,97.67)
  TOP w0.14: v1(102.13,83.18) 102.48,83.53 102.72,83.53 102.86,83.67 105.34,83.67 105.64,83.37 107.56,83.37 107.84,83.09 164.81,83.09 177.81,70.09 179.48,70.09 185.01,64.56 185.01,64.34 187.17,62.18 189.67,62.18 190.19,61.66 191.82,61.66 192.44,61.04 194.19,61.04 194.38,60.85 198.32,60.85 198.51,61.04 200.57,61.04 202.03,59.58 206.22,59.58 207.58,58.22 212.79,58.22 215.49,55.53 220.29,55.53 220.95,54.87 226.25,54.87 228.83,52.29 234.06,52.29 238.08,48.27 238.71,48.27 C187.1
  IN2 w0.089: v2(51.99,97.67) 52.14,97.82 52.37,97.82 52.46,97.73 52.46,96.96 52.33,96.83 52.33,95.49 52.29,95.44 52.29,93.99 53.42,92.86 54.86,92.86 55.64,92.07 55.64,89.1 58,86.75 81.77,86.75 87.21,92.19 94.42,92.19 100.88,85.74 100.88,83.91 101.18,83.61 101.69,83.61 v1(102.13,83.18)
GPU_TBT_D2: length 217.5
  TOP w0.102: v2(51.96,95.7) 51.96,95.85 52.07,95.95 UG1.BH23
  TOP w0.14: C193.1 238.93,47.1 238.8,46.96 238.29,46.96 233.61,51.64 228.56,51.64 225.98,54.22 220.68,54.22 220.02,54.88 215.22,54.88 212.53,57.57 206.94,57.57 205.71,58.8 201.89,58.8 200.32,60.37 199.06,60.37 198.9,60.2 194.05,60.2 193.89,60.37 192.2,60.37 191.55,61.01 188.34,61.01 187.84,61.52 186.92,61.52 184.35,64.09 184.35,64.31 179.91,68.74 178.24,68.74 164.89,82.1 107.75,82.1 107.13,82.72 103.26,82.72 103.12,82.86 v1(103.12,83.02)
  IN2 w0.089: v1(103.12,83.02) 103.12,82.68 102.99,82.55 101.4,82.55 100.29,83.66 100.29,85.67 95.34,90.61 86.29,90.61 81.95,86.27 57.69,86.27 56.9,87.05 56.1,87.86 54.96,87.86 54.46,88.36 54.46,91.15 51.45,94.16 51.45,95.63 51.74,95.92 51.87,95.92 51.96,95.82 v2(51.96,95.7)
GPU_TBT_D2#: length 217.4
  TOP w0.105: UG1.BG23 52.35,96.65 52.01,96.31 v2(51.96,96.31)
  TOP w0.14: v1(103.12,82.12) 103.41,82.4 106.99,82.4 107.62,81.78 164.76,81.78 178.11,68.43 179.78,68.43 184.03,64.17 184.03,63.95 186.78,61.2 187.7,61.2 188.21,60.7 191.42,60.7 192.06,60.05 193.76,60.05 193.92,59.88 199.03,59.88 199.19,60.05 200.19,60.05 201.75,58.49 205.57,58.49 206.81,57.26 212.39,57.26 215.09,54.56 219.89,54.56 220.55,53.9 225.85,53.9 228.43,51.32 233.48,51.32 238.16,46.64 238.81,46.64 C201.1
  IN2 w0.089: v2(51.96,96.31) 51.79,96.13 51.65,96.13 51.24,95.72 51.24,94.07 54.25,91.06 54.25,88.27 54.87,87.64 56.01,87.64 56.68,86.96 57.6,86.05 82.04,86.05 86.38,90.39 95.25,90.39 100.07,85.58 100.07,83.57 101.31,82.33 102.9,82.33 v1(103.12,82.12)
GPU_TBT_D3: length 219.8
  TOP w0.105: v2(51.31,96.29) 51.31,96.38 51.04,96.65 UG1.BG21
  TOP w0.14: C203.1 238.69,45.51 238.33,45.51 234.66,49.18 234.27,49.18 232.77,50.68 227.86,50.68 225.31,53.22 220.31,53.22 219.62,53.92 214.82,53.92 212.15,56.58 206.56,56.58 205.31,57.84 201.09,57.84 199.89,59.03 199.38,59.03 199.17,59.24 193.55,59.24 193.39,59.4 191.43,59.4 190.79,60.05 187.88,60.05 187.39,60.54 186.36,60.54 180.5,66.39 179.23,66.39 164.57,81.04 107.15,81.04 106.44,81.75 104.26,81.75 103.97,81.47 102.32,81.47 102.13,81.65 v1(102.13,81.83)
  IN2 w0.089: v1(102.13,81.83) 102.13,81.56 101.93,81.36 101.42,81.36 99.6,83.18 99.6,85.38 95.06,89.92 86.58,89.92 82.15,85.49 57.44,85.49 55.79,87.15 54.66,87.15 53.37,88.44 53.37,90.38 50.75,93 50.75,96.44 50.95,96.64 51.17,96.64 51.31,96.5 v2(51.31,96.29)
GPU_TBT_D3#: length 219.8
  TOP w0.105: UG1.BF21 v2(51.3,97)
  TOP w0.14: C208.1 238.74,45.2 238.2,45.2 234.53,48.87 234.13,48.87 232.64,50.36 227.73,50.36 225.18,52.91 220.18,52.91 219.49,53.6 214.69,53.6 212.02,56.26 206.43,56.26 205.17,57.52 200.95,57.52 199.76,58.72 199.24,58.72 199.04,58.92 193.42,58.92 193.26,59.08 191.3,59.08 190.65,59.73 187.75,59.73 187.26,60.22 186.22,60.22 180.37,66.07 179.1,66.07 164.44,80.73 107.01,80.73 106.31,81.44 104.39,81.44 104.1,81.15 102.36,81.15 v1(102.13,80.92)
  IN2 w0.089: v2(51.3,97) 51.16,96.85 50.86,96.85 50.54,96.53 50.54,92.91 53.15,90.29 53.15,88.35 54.58,86.93 55.7,86.93 57.35,85.28 82.24,85.28 86.67,89.71 94.97,89.71 99.38,85.29 99.38,83.09 101.33,81.15 101.91,81.15 v1(102.13,80.92)
GPU_THROTTING#: length 140.5
  TOP w0.14: v1(97.17,47.6) 97.23,47.54 PR291.2 ; RG16.2 RG15.1 20.63,101.9 DG2.1 20.63,100.94 20.08,100.4 20.08,98.06 20.38,97.77 v1(20.38,97.57)
  IN2 w0.089: v1(94.75,70.28) 95.36,70.28 98.31,73.23 98.31,77.56 96.91,78.96 96.91,80.8 96.44,81.27 96.44,82.91 95.82,83.52 95.82,84.26 93.5,86.58 88.28,86.58 82.58,80.88 59.31,80.88 58.64,81.55 58,81.55 57.83,81.39 56.02,81.39 53.77,83.63 50.64,83.63 49.16,85.11 49.16,85.49 47.76,86.9 42.68,86.9 41.83,87.75 41.83,89.04 41.22,89.65 33.34,89.65 33.07,89.92 30.36,89.92 29.58,90.71 29.58,91.2 27.15,93.62 26.23,93.62 25.41,94.45 24.52,94.45 24.22,94.75 23.14,94.75 22.54,95.36 22.09,95.36 20.38,97.06 v1(20.38,97.57) ; v1(99.46,68.37) 98.69,67.6 98.69,65.44 97.94,64.68 97.94,63.84 98.69,63.09 98.69,58.53 97.21,57.05 97.21,56.11 97.14,56.03 97.14,53.2 95.59,51.65 95.59,51.55 95.13,51.09 95.13,49.98 96.35,48.76 96.57,48.76 96.78,48.54 96.78,48.03 97.17,47.64 v1(97.17,47.6)
  IN4 w0.086: v1(94.75,70.28) 95.22,69.8 98.03,69.8 v1(99.46,68.37)
GPU_TSENSE: length 93.6
  TOP w0.14: PR241.2 87.98,54.33 87.7,54.04 87.7,53.58 86.77,52.65 79.82,52.65 v1(79.6,52.87) ; v1(40.15,53.76) 39.92,53.99 PR226.2 ; v1(70.7,54.26) 70.7,54.24 70.55,54.09 69.19,54.09 PR235.2 ; PR232.2 59.61,54.02 61.56,54.02 v1(62.16,54.61) ; PR220.1 20.72,54.4 21.05,54.07 21.62,54.07 21.75,53.94 22.07,53.94 22.55,53.45 27.57,53.45 v1(27.91,53.79) ; PR229.2 49.25,54.07 v1(49.25,53.89) ; v1(30.24,53.76) 30.27,53.79 PR223.1 ; PR238.2 78.53,54.29 78.88,53.94 v1(78.88,53.92)
  IN1 w0.14: v1(30.24,53.76) 31.26,53.76 31.8,53.23 33.47,53.23 33.88,53.64 35.4,53.64 35.81,53.23 39.61,53.23 v1(40.15,53.76) 40.57,54.19 41.47,54.19 42.19,54.91 44.23,54.91 44.54,54.6 48.53,54.6 v1(49.25,53.89) 49.25,55.01 50.26,56.03 52.01,56.03 52.43,55.61 52.71,55.61 53.41,54.91 59.56,54.91 60.39,54.07 61.62,54.07 v1(62.16,54.61) 62.78,55.24 63.88,55.24 64.57,54.55 68.77,54.55 69.16,54.16 70.6,54.16 v1(70.7,54.26) 71.03,53.93 71.96,53.93 72.92,54.88 77.91,54.88 78.87,53.92 v1(78.88,53.92) 78.88,53.91 78.88,53.62 79.6,52.91 v1(79.6,52.87)
  IN2 w0.14: v1(34.18,47.98) 32.07,47.98 31.15,48.89 31.15,52.85 v1(30.24,53.76)
  IN4 w0.14: v1(27.91,53.79) 28.47,53.23 29.71,53.23 v1(30.24,53.76)
  BOTTOM w0.14: v1(34.18,47.98) 34.18,48.06 34.43,48.31 34.71,48.31 PR520.2
GPU_USB_I2C_SCL: length 65
  TOP w0.102: UG1.BB8 42,100 42,99.96 v2(42.17,99.79)
  IN2 w0.089: v1(30.91,97.83) 30.94,97.87 34.74,97.87 34.82,97.79 36.45,97.79 37.88,99.22 38.89,99.22 38.95,99.28 41.02,99.28 41.08,99.34 41.72,99.34 v2(42.17,99.79)
  IN4 w0.086: v1(13.51,82.39) 13.02,82.87 13.02,84.55 14.35,85.88 15.06,85.88 17.22,88.04 17.22,88.75 18.61,90.14 18.61,91.89 18.39,92.12 18.39,92.56 19.08,93.25 19.08,98.12 19.4,98.44 20.69,98.44 21.3,97.83 22.32,97.83 22.95,98.47 22.95,99.37 23.61,100.02 28.18,100.02 28.28,100.12 29.5,100.12 30.37,99.24 30.37,98.95 30.91,98.42 v1(30.91,97.83)
  BOTTOM w0.14: v1(30.91,97.83) 30.91,98.42 30.33,98.99 30.33,100.8 29.75,101.38 28.46,101.38 28.41,101.33 27.55,101.33 27.31,101.57 RG134.1 27.5,101.98 27.5,103.42 27.21,103.71 Q63.1 25.33,103.71 24.64,103.02 RG131.2 ; v1(13.51,82.39) 13.33,82.21 13.07,82.21 12.82,81.96 11.99,81.96 10.61,80.58 10.61,79.39 10.29,79.07 Q65.4
GPU_USB_I2C_SDA: length 66.5
  TOP w0.102: v2(41.52,99.79) UG1.BB7
  TOP w0.14: v1(29.54,102.39) 29.54,102.88 29.44,102.97 29.44,104.35 v1(29.4,104.4)
  IN2 w0.089: v2(41.52,99.79) 41.27,99.53 41,99.53 40.94,99.47 38.87,99.47 38.81,99.41 37.63,99.41 37.32,99.11 35.53,99.11 34.63,98.21 32.4,98.21 31.57,99.05 31.05,99.05 v1(30.95,99.15) ; v1(23.27,104.72) 23.33,104.77 23.84,104.77 24.55,104.07 26.45,104.07 27.3,104.92 28.88,104.92 v1(29.4,104.4)
  IN4 w0.086: v1(30.95,99.15) 29.64,100.46 28.14,100.46 28.03,100.36 23.46,100.36 22.61,99.51 22.61,98.61 22.18,98.17 21.45,98.17 20.84,98.78 19.26,98.78 18.74,98.26 18.74,93.39 18.05,92.7 18.05,91.98 18.27,91.75 18.27,90.29 16.88,88.89 16.88,88.18 14.92,86.22 14.21,86.22 12.68,84.7 12.68,82.56 v1(13.51,81.73)
  BOTTOM w0.14: RG132.2 24.67,104.06 RG129.1 23.38,104.82 v1(23.27,104.72) ; Q63.4 28.99,105.01 29.4,104.6 v1(29.4,104.4) ; Q65.1 11.46,80.37 11.32,80.51 11.32,80.73 12.16,81.56 12.98,81.56 13.13,81.72 13.5,81.72 v1(13.51,81.73) ; v1(30.95,99.15) 30.73,99.37 30.73,100.97 30.15,101.54 29.52,102.17 29.52,102.37 v1(29.54,102.39)
GPU_USB_L0+: length 289.5
  TOP w0.102: UG1.BA2 37.65,100.92 37.73,101 37.91,101 38.04,100.87 38.04,100.56 v2(37.99,100.51)
  IN4 w0.102: v2(37.99,100.51) 37.78,100.51 37.59,100.31 37.59,100.18 37.32,99.91 35.66,99.91 32.94,97.2 32.94,93.7 32.2,92.96 32.2,91.02 33.54,89.68 33.8,89.68 34.51,88.97 34.51,87.12 34.31,86.92 34.31,84.63 35.27,83.67 35.27,83.41 36.3,82.38 36.3,82.16 38.3,80.15 38.52,80.15 39.52,79.16 41.4,79.16 41.45,79.21 45.29,79.21 45.62,79.54 49.38,79.54 50.53,78.4 52.93,78.4 53.52,78.99 55.21,78.99 55.92,78.27 87.92,78.27 89.22,76.98 93.66,76.98 96.8,73.84 97.64,73.84 97.94,74.15 97.94,74.59 97.74,74.79 97.49,74.79 97.36,74.66 v1(97.36,74.44)
  BOTTOM w0.165: C835.2 257.02,30.91 257.24,31.13 257.24,31.49 256.36,32.38 256.36,36 258.98,38.62 258.98,40.83 258.17,41.65 249.31,41.65 249.07,41.41 248.62,41.41 247.81,40.59 243.82,40.59 243.71,40.49 240.13,40.49 238.47,42.15 238.47,43.28 237.31,44.44 237.31,45.39 236.05,46.65 228.49,46.65 227.04,48.11 222.61,48.11 221.97,48.75 220.25,48.75 218.18,50.82 218.18,51.47 217.7,51.96 211.23,51.96 209.89,53.31 209.89,58.92 204.56,64.24 198.97,64.24 198.77,64.44 192.27,64.44 189.56,67.16 184.69,67.16 184.12,67.73 183.19,67.73 178.46,72.46 169.09,72.46 165.19,68.55 111.02,68.55 107.69,71.88 105.71,71.88 105.29,72.3 103.01,72.3 100.21,75.1 99.32,75.1 99.1,74.88 97.66,74.88 97.36,74.59 v1(97.36,74.44)
GPU_USB_L0-: length 289.5
  TOP w0.102: UG1.BA1 v2(37.29,100.51)
  IN4 w0.102: v1(97.35,75.25) 97.58,75.02 97.83,75.02 98.17,74.68 98.17,74.06 97.73,73.62 96.7,73.62 93.57,76.75 89.12,76.75 87.83,78.05 55.83,78.05 55.12,78.76 53.61,78.76 53.03,78.17 50.43,78.17 49.29,79.32 45.71,79.32 45.38,78.99 41.55,78.99 41.49,78.93 39.42,78.93 38.43,79.93 38.21,79.93 36.07,82.07 36.07,82.29 35.04,83.32 35.04,83.58 34.08,84.53 34.08,87.01 34.29,87.22 34.29,88.87 33.7,89.45 33.44,89.45 31.97,90.93 31.97,93.06 32.71,93.8 32.71,97.29 35.56,100.14 37.23,100.14 37.36,100.27 37.36,100.44 v2(37.29,100.51)
  BOTTOM w0.165: v1(97.35,75.25) 98.94,75.25 99.17,75.47 100.37,75.47 103.17,72.67 105.44,72.67 105.86,72.25 107.84,72.25 111.17,68.92 165.03,68.92 168.94,72.83 178.61,72.83 183.34,68.1 184.27,68.1 184.85,67.52 189.71,67.52 192.42,64.81 198.93,64.81 199.13,64.61 204.71,64.61 210.25,59.07 210.25,53.46 211.38,52.33 217.85,52.33 218.55,51.62 218.55,50.97 220.4,49.12 222.12,49.12 222.77,48.48 227.19,48.48 228.64,47.02 236.2,47.02 237.67,45.54 237.67,44.59 238.84,43.43 238.84,42.3 240.28,40.86 243.56,40.86 243.67,40.96 247.66,40.96 248.47,41.77 248.91,41.77 249.15,42.02 258.32,42.02 259.35,40.99 259.35,38.47 256.72,35.84 256.72,32.53 257.61,31.64 257.61,31.01 C834.2
GPU_USB_L1+: length 307.7
  TOP w0.102: v2(42.2,100.51) 41.86,100.85 UG1.BA8
  IN4 w0.102: v1(101.43,70.41) 101.28,70.57 100.35,70.57 99.88,71.04 97.58,71.04 95.13,73.49 95.13,74.35 93.34,76.14 88.85,76.14 87.5,77.49 50.28,77.49 49.06,78.71 46.25,78.71 45.18,77.64 41.55,77.64 40.92,78.28 39.16,78.28 38.57,78.88 35.69,78.88 34.94,79.63 34.94,82.34 34.18,83.11 33.66,83.11 33.27,83.5 33.27,84 32.84,84.43 32.84,86.7 33.7,87.56 33.7,88.59 33.4,88.89 31.59,88.89 30.45,90.04 30.45,92.74 31.84,94.13 31.84,98.05 32.33,98.54 32.33,99.7 33.91,101.29 41.07,101.29 41.24,101.11 41.75,101.11 41.98,100.88 41.98,100.73 v2(42.2,100.51)
  BOTTOM w0.165: C856.2 263.75,27.34 263.75,26.78 263.01,26.04 260.69,26.04 260.46,25.81 257.33,25.81 255.17,27.97 255.17,31.08 254.69,31.56 254.69,37.34 254.13,37.9 254.13,38.61 252.67,40.07 250.64,40.07 249.27,38.7 248.09,38.7 247.12,39.67 244.28,39.67 244.18,39.56 239.5,39.56 239.14,39.93 238.38,39.93 237.05,41.25 237.05,42.78 236.35,43.47 236.35,44.19 235.96,44.58 234.28,44.58 233.38,45.48 228.71,45.48 228.3,45.08 226.95,45.08 226.13,45.91 223.3,45.91 222.02,44.63 215.97,44.63 214.37,46.23 214.37,48.01 211.91,50.47 210.23,50.47 207.97,52.73 205.89,52.73 204.12,54.5 204.12,57.23 202.98,58.37 200.04,58.37 199.82,58.59 197.35,58.59 196.87,59.07 196.87,62.65 196.15,63.38 191.94,63.38 189.09,66.23 184.2,66.23 183.61,66.82 182.81,66.82 178.31,71.32 169.67,71.32 165.87,67.51 110.55,67.51 107.22,70.84 103.84,70.84 103.69,71 102.47,71 101.97,70.5 101.52,70.5 v1(101.43,70.41)
GPU_USB_L1-: length 307.7
  TOP w0.102: v2(41.51,100.5) 41.55,100.53 41.55,101.04 41.34,101.25 41.15,101.25 41.02,101.12 41.02,100.98 UG1.BA7
  IN4 w0.102: v1(101.44,71.13) 101.44,70.94 101.31,70.8 100.44,70.8 99.98,71.27 97.68,71.27 95.36,73.58 95.36,74.44 93.43,76.37 88.94,76.37 87.6,77.72 50.38,77.72 49.16,78.93 46.15,78.93 45.09,77.87 41.65,77.87 41.01,78.51 39.26,78.51 38.66,79.1 35.79,79.1 35.17,79.72 35.17,82.44 34.28,83.34 33.76,83.34 33.5,83.59 33.5,84.09 33.06,84.53 33.06,86.61 33.93,87.47 33.93,88.69 33.49,89.12 31.69,89.12 30.68,90.14 30.68,92.64 32.07,94.04 32.07,97.96 32.56,98.44 32.56,99.61 34,101.06 40.97,101.06 41.15,100.88 41.66,100.88 41.75,100.79 41.75,100.73 v2(41.51,100.5)
  BOTTOM w0.165: C857.2 263.18,27.44 263.38,27.24 263.38,26.93 262.86,26.41 260.53,26.41 260.3,26.18 257.49,26.18 255.54,28.12 255.54,31.23 255.06,31.72 255.06,37.49 254.5,38.05 254.5,38.76 252.83,40.44 250.49,40.44 249.12,39.07 248.24,39.07 247.28,40.03 244.13,40.03 244.02,39.93 239.66,39.93 239.29,40.3 238.53,40.3 237.42,41.41 237.42,42.93 236.72,43.63 236.72,44.34 236.11,44.95 234.44,44.95 233.53,45.85 228.56,45.85 228.15,45.44 227.11,45.44 226.28,46.27 223.15,46.27 221.87,45 216.12,45 214.74,46.38 214.74,48.16 212.06,50.84 210.38,50.84 208.12,53.1 206.04,53.1 204.49,54.65 204.49,57.38 203.13,58.74 200.2,58.74 199.98,58.96 197.5,58.96 197.24,59.23 197.24,62.81 196.3,63.75 192.09,63.75 189.24,66.6 184.35,66.6 183.76,67.19 182.96,67.19 178.46,71.69 169.52,71.69 165.72,67.88 110.7,67.88 107.37,71.21 104,71.21 103.84,71.37 102.32,71.37 101.82,70.87 101.61,70.87 101.44,71.04 v1(101.44,71.13)
GPUEVENT#: length 8.5
  TOP w0.102: UG1.BD1 36.44,98.75
  TOP w0.14: 36.44,98.75 35.68,99.51 33.78,99.51 32.86,100.42 30.95,100.42 RG19.2 30.24,100.42 DG1.2
GPUEVENT#_PCH: length 261
  TOP w0.14: DG1.1 30.24,102.91 30.19,102.86 v1(30.19,102.21) ; v1(217.11,26.38) 217.21,26.38 217.66,25.93 217.66,24.91 U14.BD30
  IN2 w0.089: v1(99.62,74.63) 99.62,75.82 100.55,76.74 100.55,80.01 100.36,80.19 100.36,81.45 98.91,82.9 98.91,85.1 94.77,89.24 86.86,89.24 82.43,84.81 61.61,84.81 61.54,84.74 57.22,84.74 55.5,86.46 54.38,86.46 52.68,88.16 52.68,90.1 48.61,94.17 48.61,97.7 48.96,98.06 49.45,98.06 49.57,98.19 49.57,99.48 48.95,100.11 43.74,100.11 42.44,101.41 39.33,101.41 39.2,101.54 39.2,102.01 38.52,102.7 36.99,102.7 36.43,103.25 35.19,103.25 33.9,101.97 30.44,101.97 v1(30.19,102.21) ; v1(200.02,53.99) 200.32,54.3 201.42,54.3 203.13,52.58 203.13,50.27 202.76,49.91 202.76,48.64 203.53,47.87 203.53,46.17 204.16,45.53 204.16,41.99 205.96,40.19 206.94,40.19 208.18,38.94 210.07,38.94 210.61,39.48 213.8,39.48 215.33,37.94 215.33,35.81 214.83,35.3 213.99,35.3 213.79,35.09 213.79,34.17 215.08,32.87 216.45,32.87 217.25,32.07 217.25,31.31 218.62,29.95 218.62,29.28 217.73,28.39 217.73,27 v1(217.11,26.38)
  IN4 w0.086: v1(200.02,53.99) 199.99,53.99 198.73,52.73 198.21,52.73 197.76,52.27 195.8,52.27 194.97,51.45 190.19,51.45 188.91,52.73 188.91,53.73 188.4,54.23 187.4,54.23 187.03,54.61 186.13,54.61 185.03,55.71 183.12,55.71 180.61,58.22 180.61,58.89 180.09,59.42 179.51,59.42 178.46,60.47 177.94,60.47 176.54,61.88 176.43,61.88 175.5,62.81 175.5,63.78 164.71,74.57 115.27,74.57 112.57,71.86 105.62,71.86 105.04,72.44 101.81,72.44 v1(99.62,74.63)
